# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_MDIN3: length 24.8
  IN5 w0.089: v2(204.05,145.1) 204.05,145.14 204.18,145.27 204.47,145.27 205.89,143.84 221.3,143.84 222.01,144.56 222.01,145.31 v2(222.18,145.47)
  BOTTOM w0.089: TL1.1 222.52,146.71 222.01,146.2 222.01,145.64 v2(222.18,145.47) ; v2(204.05,145.1) 203.87,145.28 203.65,145.28 203.33,145.59 203.33,146.2 203.2,146.33 202.82,146.33 202.69,146.46 UL1.21
LAN_MDIP0: length 12.2
  IN1 w0.089: v2(204.8,151.28) 204.8,151.15 204.88,151.07 204.96,151.07 205.01,151.03 205.83,151.03 206.32,150.54 206.32,150.31 206.32,147.06 207.53,145.84 207.89,145.84 v2(208.05,146)
  BOTTOM w0.089: v2(208.05,146) 208.05,145.87 208.13,145.79 208.21,145.79 208.32,145.68 208.67,145.68 208.92,145.93 208.92,146.07 208.79,146.2 208.68,146.2 208.55,146.33 TL1.12 ; v2(204.8,151.28) 204.8,151.16 204.72,151.07 204.65,151.07 204.58,151.01 204.23,151.01 204.07,151.17 UL1.11
LAN_MDIP1: length 18.4
  IN5 w0.089: v2(204.83,150.08) 204.7,149.95 203.94,149.95 203.53,149.54 203.53,147.68 203.99,147.22 204.88,147.22 205.72,146.38 213.95,146.38 214.07,146.25 214.07,145.75 v2(214.01,145.68)
  BOTTOM w0.089: v2(214.01,145.68) 214.01,146.07 213.63,146.46 TL1.8 ; v2(204.83,150.08) 204.72,149.97 UL1.14
LAN_MDIP2: length 22.1
  IN1 w0.089: v2(204.8,148.87) 204.69,148.75 203.98,148.75 203.61,148.38 203.61,147.11 206.76,143.96 211.64,143.96 214.07,146.39 215.71,146.39 216.27,145.83 216.27,145.58 v2(216.12,145.43)
  BOTTOM w0.089: UL1.17 203.82,148.77 203.93,148.67 204.6,148.67 v2(204.8,148.87) ; TL1.6 216.17,146.39 216.43,146.13 216.43,146 216.29,145.86 216.29,145.6 v2(216.12,145.43)
LAN_MDIP3: length 24.8
  IN5 w0.089: v2(204.05,145.68) 204.21,145.52 204.58,145.52 206,144.1 221.19,144.1 221.75,144.66 221.75,145.31 v2(221.59,145.47)
  BOTTOM w0.089: TL1.2 221.25,146.71 221.76,146.2 221.76,145.64 v2(221.59,145.47) ; UL1.20 203.79,147.57 203.97,147.39 203.97,146.83 203.57,146.44 203.57,145.69 203.75,145.52 203.9,145.52 v2(204.05,145.68)
LCD_TEST: length 202.5
  TOP w0.114: UE5.72 v1(98.27,22.94) 98.27,23.18 96.73,24.73 v2(96.72,24.73) ; v2(121.17,161.63) 122.96,161.63 123.6,161 JEDP.31
  IN3 w0.124: v2(121.17,161.63) 111.71,161.63 109.68,159.6 v2(109.68,158.84)
  IN4 w0.137: v2(109.68,158.84) 108.46,157.62 108.46,155.78 106.36,153.68 100.79,153.68 99.38,155.09 95.23,155.09 94.29,154.15 94.29,151.57 92.56,149.85 92.56,144.72 94.38,142.9 v2(94.38,142.76)
  IN5 w0.097: v2(96.72,24.73) 96.27,25.18 94.51,25.18 93.87,24.54 92.34,24.54 91.45,25.42 87.69,25.42 86.87,26.25 84.07,26.25 82.79,24.97 78.35,24.97 76.97,26.35 76.97,46.55 79.5,49.09 79.5,54.62 85.28,60.4 85.28,90 86.82,91.55 86.82,133.08 87.43,133.69 87.43,134.69 86.85,135.26 86.85,140.55 88.72,142.43 94.04,142.43 v2(94.38,142.76)
LDO2-CAP: length 4.7
  BOTTOM w0.203: UA1.22 26.41,33.9 26.13,33.62 26.13,32.96 CA28.1
  BOTTOM w0.254: RA12.2 26.61,30.96 CA29.1 26.61,32.08 26.5,32.2 CA28.1
LG_3V: length 8.9
  TOP w0.114: v2(36.78,29.25) v1(37.32,29.25)
  IN2 w1.016: 38.18,29.83 41.8,33.44 45.03,33.44
  vias: v2(36.33,28.81) v2(46.3,33.7) v2(46.3,33.06)
LG_5V: length 2.9
  TOP w0.114: v2(39.95,27.92) 39.8,27.92 v1(39.49,28.22)
  IN5 w1.016: 40.02,26.9 39.26,26.14 37.99,26.14
  vias: v2(36.4,26.27) v2(37.03,26.27) v2(40.59,27.92)
LG_+1VALWP: length 0.8
  TOP w0.114: v2(211.59,21.63) v1(211.59,22.43)
  vias: v2(206.45,20.05) v2(207.09,20.05) v2(210.96,21.63)
LID_SW: length 10.8
  TOP w0.114: v2(259.73,51.59) 258.79,50.65 RE8.2 257.81,50.65 257.38,51.08 DE1.2 ; v2(261.95,48.35) v3(262.93,48.35) 263.22,48.35 263.82,47.75 UE1.23
  IN1 w0.097: v2(261.95,48.35) 261.95,49.36 v2(259.73,51.59)
LID_SW#: length 295.1
  TOP w0.114: v2(85.72,12.71) 85.72,12.44 CE43.1 ; v2(85.72,12.71) 86.07,12.71 86.24,12.54 UE5.115 ; v2(85.72,12.71) 85.71,12.71 RE70.2 ; v2(182.63,11.71) 182.63,11.98 182.76,12.11 183.38,12.11 183.39,12.1 184.52,12.1 185.44,13.02 211.41,13.02 215.79,17.4 217.36,17.4 218.64,18.68 218.64,20.73 220.8,22.88 221.03,22.88 221.13,22.98 v3(222.01,22.98) v2(222.87,22.98) ; DE1.1 257.38,48.79 256.94,48.35 253.89,48.35 251.73,46.19 251.73,43.56 v2(251.59,43.41) ; CH1.1 316.41,80.09 v2(316.41,80.87) UH5.3
  IN1 w0.097: v2(85.72,12.71) 86.75,13.74 89.08,13.74 90.62,15.28 90.62,16.06 92.9,18.34 95.63,18.34 99.22,21.93 104.39,21.93 105.67,20.65 108.34,20.65 109.3,21.61 111.84,21.61 113.04,20.41 118.05,20.41 119.46,21.82 150.37,21.82 151.39,22.84 154.2,22.84 155.34,21.7 155.34,20.6 157.05,18.88 163.03,18.88 164.03,17.88 164.03,17.17 164.93,16.28 166.98,16.28 169.36,13.89 174.79,13.89 175.11,14.21 179.15,14.21 180.66,12.7 181.99,12.7 182.63,12.06 v2(182.63,11.71)
  IN4 w0.137: v2(222.87,22.98) 223.39,22.98 227.4,26.99 227.4,29.28 231.41,33.29 231.41,34.44 235.87,38.9 242.21,38.9 247.27,43.97 251.05,43.97 251.43,43.59 251.43,43.57 v2(251.59,43.41) 252.07,43.41 252.81,44.16 267.55,44.16 285.77,62.37 288.55,62.37 290.59,64.41 293.77,64.41 297.45,68.1 301.64,68.1 303.99,70.45 303.99,71.08 304.56,71.65 304.56,76.29 307.04,78.76 310.02,78.76 310.85,77.94 313.53,77.94 314.14,78.55 314.76,78.55 316.41,80.2 v2(316.41,80.87)
LINE1_JD: length 30.4
  TOP w0.114: RA36.2 33.2,37.83 v2(33.79,37.83)
  IN2 w0.254: JACK2.5 11.51,35.14 12.08,35.71 16.69,35.71 18.36,37.38 18.36,38.91 18.74,39.29 29.41,39.29 30.29,40.16 31.9,40.16 32.21,39.86 32.21,38.46 32.78,37.89 33.73,37.89 v2(33.79,37.83)
  BOTTOM w0.114: v2(33.79,37.83) 35.16,37.83 v1(35.63,38.29)
LINE1_L: length 8.1
  BOTTOM w0.203: UA1.35 22.64,37.98 22.55,37.89 21.48,37.89 20.69,37.11
  BOTTOM w0.254: v1(15.95,35.54) CA49.1 19.13,35.54 20.69,37.11
LINE1_R: length 12.6
  BOTTOM w0.203: CA47.1 16.95,32.31 20.03,32.31 21.24,33.51 21.24,34.21 20.71,34.74 20.71,36.62 21.51,37.41 v1(21.77,37.41) 22.02,37.41 22.12,37.51 22.62,37.51 22.69,37.58 UA1.34
LINE1_VREFO_L: length 11.2
  TOP w0.254: RA41.1 v1(20.1,34.78) 20.59,34.29 v2(20.59,33.95)
  IN1 w0.254: v2(22.09,40.24) 22.94,39.39 22.94,36.75 20.59,34.4 v2(20.59,33.95)
  BOTTOM w0.203: UA1.40 22.5,39.98 22.24,40.24 v2(22.09,40.24)
LINE1_VREFO_R: length 14.2
  TOP w0.254: v2(20.02,33.76) 20.52,33.25 20.52,31.32 v1(20.12,30.91) RA40.1
  IN4 w0.254: v2(20.02,33.76) 19.13,34.65 19.13,38.89 19.45,39.2 20.49,39.2 21.03,39.75 v2(21.03,39.86)
  BOTTOM w0.203: UA1.39 22.39,39.58 22.24,39.73 21.16,39.73 v2(21.03,39.86)
LINE-IN-L: length 16.6
  TOP w0.254: v2(18.17,27.71) 18.17,28.49 v1(18.06,28.6) RA38.1 ; LA9.2 17.29,16.56 RA35.2 17.36,16.13 v2(17.18,15.95)
  IN1 w0.254: v2(18.17,27.71) 18.17,27.22 18.51,26.88 18.51,19.8 16.54,17.83 16.54,17 17.18,16.37 v2(17.18,15.95)
LINE-IN-R: length 6
  TOP w0.114: v1(18.98,20.87) 18.98,21.58 RA37.2
  TOP w0.254: RA37.2 18.05,21.84 LA10.2 17.1,22.8 RA39.1
LOGO_LED_B_DRV#: length 20.4
  TOP w0.114: JLOGO.8 192.86,159.21 v2(193.12,159.47) ; v3(179.53,154.4) v2(179.53,153.84) 179.77,153.59 UE3.9
  IN5 w0.097: v2(193.12,159.47) 191.59,157.95 189.63,157.95 189.3,157.62 189.3,156.03 187.02,153.76 179.61,153.76 v2(179.53,153.84)
LOGO_LED_G_DRV#: length 17.8
  TOP w0.114: JLOGO.7 193.86,158.68 v2(193.53,159.01) ; UE3.8 181.52,154.78 181.43,154.87 181.25,154.87 181.03,154.65 v2(181.03,154.64)
  IN1 w0.097: v2(193.53,159.01) 192.78,159.01 191.66,157.89 189.75,157.89 188.81,156.95 187.87,156.95 187.17,156.24 182.96,156.24 182.14,155.42 182.14,154.76 182.01,154.64 v2(181.03,154.64)
  BOTTOM w0.114: v2(181.03,154.64) 181.5,154.17 v3(181.5,153.9)
LOGO_LED_R_DRV#: length 17.3
  TOP w0.114: v1(182.52,155.8) v2(182.52,155.2) 182.52,155.19 UE3.6 ; v2(194.36,158.87) 194.37,158.87 194.86,158.38 JLOGO.6
  IN1 w0.097: v2(182.52,155.2) 183.36,156.03 187.24,156.03 187.95,156.75 189.24,156.75 189.37,156.62 189.37,156.17 189.75,155.79 190.7,155.79 191.15,156.23 191.15,156.81 192.93,158.58 194.08,158.58 v2(194.36,158.87)
LPC_AD0: length 111.9
  TOP w0.089: v2(177.41,42.78) 177.41,42.91 v1(177.05,43.27)
  TOP w0.114: v2(92.64,15.62) 93.03,15.24 93.03,14.68 92.68,14.33 92.68,9.74 92.17,9.22 92.17,6.82 92.27,6.72 UE5.10
  IN2 w0.097: v2(177.41,42.78) 177.41,41.86 176.53,40.98 175.69,40.98 175.27,40.57 175.27,40.34 175.06,40.13 174.56,40.13 173.76,39.33 173,39.33 171.55,37.88 170.49,37.88 168.58,35.97 166.19,35.97 165.5,36.66 162.26,36.66 160.73,35.14 160.73,31.59 160.33,31.19 158.74,31.19 158.57,31.01 156.22,31.01 152.76,27.55 152.07,27.55 150.38,25.87 147.41,25.87 145.06,23.52 143.44,23.52 141.81,21.89 118.42,21.89 115.9,19.37 114.19,19.37 111.63,16.81 107.03,16.81 106.28,17.56 103.03,17.56 101.69,16.22 98.63,16.22 98.19,16.66 96.03,16.66 95.44,16.08 93.09,16.08 v2(92.64,15.62)
  BOTTOM w0.089: v2(177.41,42.78) 177.6,42.59 UH1.AT22
LPC_AD1: length 109.3
  TOP w0.114: v2(92.64,15.01) 92.47,14.84 92.47,9.83 91.95,9.31 91.95,7.68 91.47,7.2 UE5.8
  IN2 w0.097: v2(178.19,42.84) 178.19,42.38 175.94,40.13 175.33,40.13 173.8,38.6 172.64,38.6 170.31,36.27 170.31,34.12 168.54,32.35 165.24,32.35 164.16,31.27 160.86,31.27 160.58,30.99 158.84,30.99 158.48,30.63 156.48,30.63 152.95,27.1 152.2,27.1 150.52,25.42 147.58,25.42 145.45,23.29 143.77,23.29 142.18,21.69 138.29,21.69 137.96,21.36 118.17,21.36 115.98,19.17 114.27,19.17 111.7,16.6 102.77,16.6 102.14,15.96 98.5,15.96 98.06,16.41 96.38,16.41 95.26,15.3 94.05,15.3 93.76,15.01 v2(92.64,15.01)
  BOTTOM w0.089: UH1.AV22 178.19,42.53 v2(178.19,42.84)
LPC_AD2: length 111.4
  TOP w0.114: UE5.7 91.07,7.11 91.73,7.77 91.73,9.4 92.25,9.92 92.25,16.01 v2(92.53,16.29)
  IN2 w0.097: v2(177.17,43.92) 176.45,43.2 176.45,42.79 175.84,42.18 174.57,42.18 174.05,41.67 173.51,41.67 172.87,41.02 172.87,40.22 172.64,39.99 172.64,39.76 171.49,38.61 167.7,38.61 167.51,38.79 158.62,38.79 157.63,37.8 157.63,34.41 156.36,33.13 155.9,33.13 149.73,26.96 146.83,26.96 145.62,25.75 143.82,25.75 141.95,23.88 138.09,23.88 137.1,22.9 117.16,22.9 111.66,17.4 106.99,17.4 106.44,17.95 102.58,17.95 101.84,17.21 96.25,17.21 95.32,16.27 92.55,16.27 v2(92.53,16.29)
  BOTTOM w0.089: UH1.AT19 177.59,43.46 177.17,43.88 v2(177.17,43.92)
LPC_AD3: length 120.9
  TOP w0.114: UE5.5 90.27,6.92 91.3,7.94 91.3,9.58 91.82,10.1 91.82,11.13 v2(91.52,11.43)
  IN2 w0.097: v2(183.34,44.55) 182.52,44.55 181.2,43.22 181.2,40.17 179.89,38.86 178.56,38.86 178.37,38.68 177.79,38.68 177.6,38.86 176.8,38.86 176.24,38.31 175.06,38.31 173.94,37.19 173.94,32.3 173.27,31.62 173.27,31.46 172.49,30.68 172.49,29.12 171.79,28.42 171.18,28.42 170.73,27.96 169.11,27.96 168.86,28.22 167.76,28.22 167.26,27.72 165.19,27.72 163.97,26.5 156.26,26.5 153.64,23.88 152.56,23.88 151.7,23.02 150.32,23.02 148.23,20.93 144.56,20.93 142.89,19.26 139.5,19.26 138.62,18.38 119.47,18.38 117.75,16.65 116.44,16.65 113.45,13.66 109.81,13.66 109.05,12.9 103.48,12.9 102.83,13.55 97.21,13.55 96.63,12.97 93.58,12.97 92.04,11.43 v2(91.52,11.43)
  BOTTOM w0.089: v2(183.34,44.55) 183.08,44.81 181.73,44.81 181.35,45.19 UH1.BD16
LPC_FRAME#: length 121.2
  TOP w0.114: UE5.4 89.87,6.83 91.09,8.04 91.09,9.67 91.42,10.01 91.42,10.84 v2(91.43,10.85)
  IN2 w0.097: v2(183.91,44.55) 183.54,44.18 182.73,44.18 182.72,44.18 182.42,44.18 181.38,43.14 181.38,40.09 179.97,38.67 178.64,38.67 178.45,38.49 177.71,38.49 177.52,38.68 176.87,38.68 176.32,38.12 175.14,38.12 174.13,37.11 174.13,32.22 173.88,31.97 173.88,31.65 173.37,31.14 173.37,29.72 171.88,28.23 171.43,28.23 170.96,27.77 169.03,27.77 168.83,27.96 167.9,27.96 166.14,26.21 156.29,26.21 153.76,23.68 152.64,23.68 151.78,22.83 150.4,22.83 147.75,20.18 144.35,20.18 142.55,18.38 138.9,18.38 138.64,18.12 119.5,18.12 117.83,16.45 116.52,16.45 113.53,13.46 109.89,13.46 109.13,12.7 103.4,12.7 102.75,13.35 97.3,13.35 96.72,12.77 93.79,12.77 91.87,10.85 v2(91.43,10.85)
  BOTTOM w0.089: v2(183.91,44.55) 183.47,44.98 181.97,44.98 UH1.BE16
LX_1.0VS_VGAP: length 5.5
  TOP w0.114: v1(162.57,152.49) 162.68,152.39 v2(162.68,151.7)
  TOP w0.508: PR803.1 163.29,151.09 v2(162.68,151.7)
  IN4 w0.254: v2(166.21,151.05) 165.6,151.66 162.89,151.66 162.85,151.7 v2(162.68,151.7)
LX_3V: length 14
  IN5 w1.016: 46.43,38.02 42.43,38.02 35.38,30.97
  vias: v2(34.43,30.52) v2(34.43,29.94) v2(47.32,38.59) v2(47.32,37.95) v2(47.95,38.59) v2(47.95,37.95) v2(48.27,37.45) v2(48.59,38.59) v2(48.59,37.95) v2(48.91,37.45) v2(49.22,38.59) v2(49.22,37.95) v2(49.54,37.45) v2(50.12,37.74) v2(50.18,37.04) v2(50.75,37.62) v3(43.94,38.7)
LX_5V: length 8
  TOP w0.114: v2(45.29,21.94) v1(45.29,21.39)
  IN5 w1.016: 42.1,22.88 42.08,22.9 36.52,22.9 35.19,24.24
  vias: v2(34.42,25.05) v2(34.4,24.47) v2(42.92,23.21) v2(42.92,22.57) v2(43.55,23.21) v2(43.55,22.57) v2(43.55,21.94) v2(44.12,23.51) v2(44.12,22.88) v2(44.12,22.24) v2(44.65,23.21) v2(44.65,22.57) v2(44.65,21.94) v2(45.29,23.21) v2(45.29,22.57) v2(45.81,22.87) v2(45.81,22.24)
LX_+1.8VGS: length 0.8
  BOTTOM w0.114: 237.15,149.35 v1(236.35,149.35)
LX_CHG: length 15.9
  IN5 w1.016: 60.32,30.73 61.55,29.51 61.55,17.55 60.84,16.85 59.64,16.85
  vias: v2(53.1,20.36) v2(53.1,19.67) v2(53.8,20.36) v2(53.8,19.67) v2(54.5,20.36) v2(54.5,19.67) v2(55.19,20.36) v2(55.19,19.67) v2(56.71,17.89) v2(57.35,17.89) v2(57.98,17.89) v2(58.62,17.89) v2(59.32,31.86) v2(59.25,17.89) v2(59.7,31.4) v3(53.41,18.83)
LX_VCCIO:
  vias: v1(91.73,101.92) v2(90.86,104.08) v2(91.07,109.75) v2(91.07,109.14) v2(91.47,104.08)
M2_SLOT1_PEDET: length 82.3
  TOP w0.114: R363.1 225.33,28.21 v2(225.05,28.49) v1(224.54,28.49)
  IN2 w0.097: v2(216.35,26.66) 217.46,27.77 224.34,27.77 v2(225.05,28.49)
  IN5 w0.097: v2(172.16,34.63) 171.65,34.12 171.65,32.3 171.8,32.16 171.8,29.33 171.27,28.79 171.27,25.58 171.41,25.43 171.41,24.63 171.23,24.45 171.23,24.12 172.93,22.43 175.48,22.43 176.21,21.7 177.22,21.7 177.87,21.05 180.43,21.05 180.67,21.3 187.82,21.3 195.65,13.47 203.52,13.47 203.74,13.69 208.53,13.69 215.27,20.43 215.27,24.4 216.19,25.32 216.19,26.5 v2(216.35,26.66)
  BOTTOM w0.089: v2(172.16,34.63) 172.32,34.63 UH1.AG36
  BOTTOM w0.114: JSSD1.69 224.61,28.05 v2(225.05,28.49)
M2_SLOT2_PEDET: length 96.1
  TOP w0.114: v1(185.54,21.94) 185.94,22.35 v2(185.94,22.55) ; R365.1 v2(229.3,8)
  IN2 w0.104: v2(229.1,10.65) 228.47,11.28 224.53,11.28 224.2,11.6 218.94,11.6 213.99,6.65 212.64,6.65 212.33,6.34 203.12,6.34 201.38,8.09 193.59,8.09 188.82,12.87 188.82,17.32 185.94,20.2 v2(185.94,22.55)
  IN5 w0.097: v2(185.94,22.55) 185.22,22.55 184.22,21.55 180.61,21.55 180.33,21.27 177.92,21.27 177.3,21.89 176.3,21.89 175.56,22.63 173.01,22.63 171.43,24.21 171.43,24.37 171.64,24.58 171.64,25.52 171.46,25.69 171.46,28.68 172.16,29.37 172.16,31.98 172.8,32.62 172.8,35.46 v2(172.1,36.16)
  BOTTOM w0.089: v2(172.1,36.16) 171.74,35.8 UH1.AD35
  BOTTOM w0.114: JSSD2.69 228.17,4.15 228.6,4.59 228.6,7.04 229.3,7.73 v2(229.3,8) 229.3,10.45 v2(229.1,10.65)
M_CLK_DDR0: length 53.5
  IN5 w0.089: v2(121.67,78.63) 121.67,78.51 121.34,78.18 120.34,78.18 120.11,77.95 120.11,76.14 120.9,75.35 122.06,75.35 122.06,75.35 122.11,75.35
  IN5 w0.097: v2(115.95,47.34) 115.95,47.27 116.08,47.14 116.25,47.14 116.36,47.25 116.36,61.98 120.69,66.31 120.69,66.92 121.01,67.24 121.01,67.58 120.69,67.9 120.69,70.54 121.08,70.92 121.41,70.92 121.64,71.16 121.64,71.52 122.25,72.13 122.25,72.55 122.09,72.71 121.9,72.71 121.7,72.92 121.7,73.31 121.95,73.57 122.16,73.57 122.26,73.67 122.26,73.86 122.13,73.99 121.91,73.99 121.7,74.2 121.7,74.63 121.91,74.85 122.14,74.85 122.25,74.96 122.25,74.97 122.26,74.97 122.26,75.2 122.11,75.35
  BOTTOM w0.076: CPU1.AG1 124.29,85.21 124.29,85.39 124.36,85.46 124.66,85.46 124.79,85.33 124.79,84.67 124.65,84.53 124.65,82.63 124.29,82.26 124.29,78.6 124,78.31 122.77,78.31 122.67,78.21 121.96,78.21 121.67,78.5 v2(121.67,78.63)
  BOTTOM w0.114: JDIMM1.137 116.02,48.81 116.54,48.3 116.54,47.36 116.31,47.14 116.14,47.14 v2(115.95,47.34)
M_CLK_DDR1: length 56.2
  IN5 w0.089: 123.13,75.35 123.13,75.37 123.13,75.37 123.13,75.42 123.12,75.43 123.12,75.46 122.27,76.31 122.27,79.43 122.14,79.56 122.14,82.9 121.93,83.1 121.72,83.1 v2(121.52,83.3)
  IN5 w0.097: v2(115.95,43.58) 116.01,43.64 116.29,43.64 116.42,43.51 116.42,42.07 116.74,41.75 117.59,41.75 117.99,42.15 117.99,43.42 117.24,44.18 117.24,45.36 117.01,45.59 116.63,45.59 116.53,45.69 116.53,45.94 116.66,46.07 117,46.07 117.24,46.31 117.24,61.61 121.88,66.26 121.88,70.15 123.13,71.4 123.13,75.35
  BOTTOM w0.076: CPU1.AK2 121.9,85.73 121.65,85.49 121.6,85.49 121.44,85.33 121.44,84.78 122.14,84.09 122.14,83.25 121.96,83.07 121.75,83.07 v2(121.52,83.3)
  BOTTOM w0.114: v2(115.95,43.58) 116.17,43.8 116.42,43.8 116.59,43.63 116.59,43.23 116.4,43.04 116.4,42.7 116.28,42.58 JDIMM1.138
M_CLK_DDR2: length 67.8
  IN1 w0.091: 122.26,75.35 122.26,75.36 122.26,75.37 122.26,79.15 121.4,80.01 121.4,81.02 122.09,81.7 122.09,83.89 121.25,84.72 121.25,85.87 122.13,86.75 122.34,86.75 122.66,87.06 122.66,87.59 122.12,88.12 121.96,88.12 121.66,88.43 121.25,88.43 120.6,89.08 120.6,89.87 120.42,90.04 120.3,90.04 v2(120.23,89.98)
  IN1 w0.097: 122.26,75.35 122.26,75.34 122.26,67.37 116.35,61.47 116.35,51.82 116.23,51.71 116.23,50.34 115.34,49.45 115.34,34.14 115.58,33.9 115.75,33.9 v2(115.95,33.7)
  BOTTOM w0.076: v2(120.23,89.98) 120.55,90.3 CPU1.AM9
  BOTTOM w0.114: v2(115.95,33.7) 115.78,33.87 115.46,33.87 115.1,34.22 115.1,35.1 115.69,35.69 115.91,35.69 116.08,35.86 116.08,36.14 116.03,36.19 JDIMM2.137
M_CLK_DDR3: length 69.2
  IN1 w0.091: 123,75.58 123,75.6 123,75.6 123,77.99 123.31,78.3 123.31,84.58 123.02,84.86 123.02,87.98 122.25,88.76 121.88,88.76 121.56,89.08 121.56,89.39 121.46,89.48 121.3,89.48 v2(121.14,89.32)
  IN1 w0.097: 123,75.58 123,67.13 117.06,61.2 117.06,51.55 116.92,51.41 116.92,50.04 116.36,49.48 116.36,41.57 116.03,41.24 116.03,40.83 116.36,40.5 116.36,38.1 116.5,37.97 116.5,32.2 116.93,31.76 117.43,31.76 117.55,31.63 117.55,31.02 117.43,30.89 116.21,30.89 v2(115.95,31.16)
  BOTTOM w0.076: CPU1.AM7 v2(121.14,89.32)
  BOTTOM w0.114: JDIMM2.138 116.28,29.72 116.37,29.82 116.37,29.93 116.26,30.04 115.83,30.04 115.53,30.34 115.53,30.74 v2(115.95,31.16)
M_CLK_DDR#0: length 53.4
  IN5 w0.089: v2(121.67,78) 120.41,78 120.29,77.87 120.29,76.21 120.97,75.53 122.09,75.53 122.19,75.53 122.22,75.49 122.23,75.49 122.37,75.35
  IN5 w0.097: v2(115.95,46.7) 116.2,46.96 116.32,46.96 116.54,47.18 116.54,61.9 120.88,66.23 120.88,66.84 121.2,67.16 121.2,67.66 120.88,67.97 120.88,70.46 121.15,70.74 121.49,70.74 121.83,71.08 121.83,71.44 122.44,72.05 122.44,72.63 122.17,72.9 121.98,72.9 121.88,73 121.88,73.24 122.03,73.38 122.23,73.38 122.44,73.59 122.44,73.94 122.21,74.18 121.98,74.18 121.88,74.28 121.88,74.56 121.99,74.66 122.22,74.66 122.44,74.89 122.44,75.28 122.37,75.35
  BOTTOM w0.076: CPU1.AG2 124.48,85.67 124.71,85.67 124.95,85.42 124.95,84.6 124.82,84.46 124.82,82.56 124.45,82.19 124.45,78.53 124.07,78.15 122.84,78.15 122.69,78 v2(121.67,78)
  BOTTOM w0.114: JDIMM1.139 116.53,48.66 116.78,48.4 116.78,47.26 116.42,46.9 116.14,46.9 v2(115.95,46.7)
M_CLK_DDR#1: length 56.3
  IN5 w0.089: 122.95,75.35 122.95,75.38 122.09,76.24 122.09,79.35 121.96,79.48 121.96,82.82 121.86,82.92 121.66,82.92 121.52,82.78 v2(121.52,82.66)
  IN5 w0.097: v2(115.95,44.21) 115.95,44.15 116.26,43.84 116.35,43.84 116.6,43.59 116.6,42.15 116.82,41.93 117.52,41.93 117.81,42.23 117.81,43.35 117.05,44.1 117.05,45.28 116.93,45.4 116.56,45.4 116.35,45.61 116.35,46.02 116.58,46.26 116.93,46.26 117.05,46.38 117.05,61.69 121.7,66.34 121.7,70.23 122.95,71.47 122.95,75.35
  BOTTOM w0.076: CPU1.AK1 121.9,85.19 121.77,85.32 121.67,85.32 121.61,85.26 121.61,84.85 122.31,84.15 122.31,83.19 122.03,82.91 121.77,82.91 v2(121.52,82.66)
  BOTTOM w0.114: v2(115.95,44.21) 116.11,44.05 116.53,44.05 116.84,43.73 116.84,43.12 116.65,42.93 116.65,42.7 116.77,42.58 JDIMM1.140
M_CLK_DDR#2: length 67.8
  IN1 w0.091: 122.45,75.35 122.44,75.35 122.44,79.23 121.59,80.08 121.59,80.95 122.27,81.63 122.27,83.96 121.43,84.8 121.43,85.8 122.2,86.57 122.42,86.57 122.84,86.98 122.84,87.66 122.2,88.3 122.04,88.3 121.73,88.61 121.32,88.61 120.78,89.15 120.78,89.94 120.23,90.49 v2(120.23,90.61)
  IN1 w0.097: v2(115.95,34.33) 115.95,34.21 115.82,34.08 115.66,34.08 115.53,34.22 115.53,49.37 116.42,50.26 116.42,51.63 116.54,51.75 116.54,61.39 122.45,67.3 122.45,75.35
  BOTTOM w0.076: CPU1.AN9 119.87,90.3 119.88,90.3 119.91,90.3 v2(120.23,90.61)
  BOTTOM w0.114: JDIMM2.139 116.53,36.16 116.32,35.96 116.32,35.75 116.01,35.44 115.79,35.44 115.35,35 115.35,34.33 115.56,34.12 115.73,34.12 v2(115.95,34.33)
M_CLK_DDR#3: length 69
  IN1 w0.091: 123.18,75.58 123.18,75.64 123.18,75.64 123.18,77.92 123.49,78.23 123.49,84.65 123.2,84.94 123.2,88.06 122.32,88.94 121.95,88.94 121.74,89.15 121.74,89.46 121.54,89.66 121.27,89.66 121.14,89.79 v2(121.14,89.97)
  IN1 w0.097: v2(115.95,30.52) 116.13,30.7 116.21,30.7 116.21,30.71 117.5,30.71 117.74,30.94 117.74,31.71 117.5,31.95 117.01,31.95 116.68,32.27 116.68,38.04 116.54,38.18 116.54,40.58 116.22,40.91 116.22,41.16 116.55,41.49 116.55,49.41 117.11,49.97 117.11,51.34 117.25,51.47 117.25,61.12 123.18,67.06 123.18,75.58
  BOTTOM w0.076: CPU1.AM8 v2(121.14,89.97)
  BOTTOM w0.114: JDIMM2.140 116.78,29.72 116.64,29.86 116.64,30.04 116.37,30.31 116.06,30.31 115.95,30.42 v2(115.95,30.52)
M_ODT0: length 54.2
  IN5 w0.089: v2(125.3,80.09) 125.24,80.16 125.06,80.16 124.86,79.97 124.86,78.65 125.25,78.26 125.84,78.26 128.52,75.58 128.52,75.35
  IN5 w0.145: 128.52,75.35 128.52,75.35 128.52,60.71 123.65,55.84 123.65,51.88 124.12,51.41 124.38,51.41 124.49,51.29 124.49,49.45 124.34,49.3 123.8,49.3 123.65,49.15 123.65,48.85 123.8,48.7 124.34,48.7 124.49,48.55 124.49,47.82 124.28,47.61 123.86,47.61 123.64,47.39 123.64,45.81 v2(123.18,45.35)
  BOTTOM w0.076: v2(125.3,80.09) 126.34,80.09 126.79,80.54 126.79,84.73 126.65,84.87 126.65,86.11 CPU1.AD3
  BOTTOM w0.178: JDIMM1.155 122.53,46 v2(123.18,45.35)
M_ODT1: length 53.8
  IN5 w0.089: 127.61,75.35 127.41,75.55 127.2,75.55 124.51,78.25 124.51,84.02 124.73,84.24 124.96,84.24 v2(125.3,83.9)
  IN5 w0.145: v2(123.21,46.87) 123.04,46.71 122.86,46.71 122.74,46.84 122.74,56.22 126.36,59.83 126.36,60.41 126.5,60.56 127.08,60.56 127.21,60.69 127.21,60.94 127.08,61.07 126.48,61.07 126.36,61.19 126.36,61.53 126.51,61.68 127.46,61.68 127.61,61.83 127.61,62.13 127.46,62.28 126.51,62.28 126.36,62.43 126.36,68.3 126.88,68.82 127.4,68.82 127.61,69.03 127.61,75.35
  BOTTOM w0.076: v2(125.3,83.9) 125.75,84.35 125.75,86.69 126.09,87.04 CPU1.AE4
  BOTTOM w0.178: JDIMM1.161 124.02,48.78 124.39,48.42 124.39,47.23 124.04,46.87 v2(123.21,46.87)
M_ODT2: length 69.1
  IN1 w0.089: 128.79,75.35 128.79,78.41 126.77,80.43 126.77,85.51 126.01,86.27 126.01,89.06 v2(125.72,89.35)
  IN1 w0.145: 128.79,75.35 128.79,64.65 123.58,59.44 123.58,58.78 123.77,58.59 124.35,58.59 124.47,58.46 124.47,58.12 124.35,57.99 123.58,57.99 123.46,57.86 123.46,52.03 124.37,51.11 124.37,50.82 124.22,50.67 123.39,50.67 123.24,50.52 123.24,50.22 123.39,50.07 124.22,50.07 124.37,49.92 124.37,49.62 124.22,49.47 123.39,49.47 123.24,49.32 123.24,49.02 123.39,48.87 124.22,48.87 124.37,48.72 124.37,47.31 124.22,47.16 123.79,47.16 123.64,47.01 123.64,46.71 123.79,46.56 124.22,46.56 124.37,46.41 124.37,46.11 124.22,45.96 123.73,45.96 123.58,45.81 123.58,45.51 123.73,45.36 124.22,45.36 124.37,45.21 124.37,42.89 124.12,42.63 123.5,42.63 123.24,42.37 123.24,41.19 123.56,40.87 123.56,39.17 123.18,38.8 v2(123.18,35.47)
  BOTTOM w0.076: v2(125.72,89.35) CPU1.AF7
  BOTTOM w0.178: v2(123.18,35.47) 122.53,36.13 JDIMM2.155
M_ODT3: length 69.4
  IN1 w0.089: v2(126.6,89.22) 127,88.82 127,86.22 127.27,85.95 127.27,80.69 129.7,78.26 129.7,75.35
  IN1 w0.145: v2(123.18,32.55) 123.85,32.55 124.59,33.29 124.59,39.25 125.28,39.94 125.28,41 125.51,41.23 125.51,52.42 125.36,52.57 124.81,52.57 124.66,52.72 124.66,53.02 124.81,53.17 125.36,53.17 125.51,53.32 125.51,53.62 125.36,53.77 124.81,53.77 124.66,53.92 124.66,54.22 124.81,54.37 125.36,54.37 125.51,54.52 125.51,60.08 129.7,64.28 129.7,75.35
  BOTTOM w0.076: v2(126.6,89.22) CPU1.AE8
  BOTTOM w0.178: v2(123.18,32.55) 124.2,33.57 124.2,35.97 124.03,36.14 JDIMM2.161
MDP_AUX#_SDA: length 130.8
  TOP w0.114: v2(186.2,157.33) 186.32,157.45 186.57,157.45 187.29,156.73 188.66,156.73 188.93,156.46 189.91,156.46 v2(190.07,156.3)
  IN2 w0.097: v2(175.66,83.27) 175.85,83.47 175.85,84.66 171.77,88.73 171.77,104.81 170.45,106.13 170.45,133.17 166.13,137.49 166.13,148.32 167.88,150.07 171.85,150.07 172.48,150.71 172.48,155.24 174.3,157.06 175.12,157.06 178.74,160.68 185.46,160.68 185.88,160.25 185.88,159.16 186.83,158.21 186.83,157.77 186.58,157.53 186.4,157.53 v2(186.2,157.33)
  BOTTOM w0.114: v2(186.2,157.33) 186.01,157.52 185.86,157.52 185.76,157.42 185.76,153.45 185.89,153.32 186.14,153.32 186.37,153.55 RV618.2 RV665.1 ; UG9.BL8 178.76,84.55 178.26,84.05 176.18,84.05 175.83,83.7 175.83,83.45 v2(175.66,83.27) ; UV3.6 190.99,155.57 191.73,156.31 191.73,156.49 191.53,156.68 190.96,156.68 190.7,156.42 190.2,156.42 v2(190.07,156.3) 189.88,156.49 189.44,156.49 189.1,156.82 189.1,159.04 188.8,159.35 188.8,162.14 189.51,162.85 190.95,162.85 191.24,162.57 191.24,162.37 192.29,161.32 UV3.13
MDP_AUX_SCL: length 130
  TOP w0.114: v2(190.07,156.88) 189.91,156.73 189.04,156.73 188.77,157 187.4,157 186.68,157.72 186.4,157.72 v2(186.2,157.91)
  IN2 w0.097: v2(186.2,157.91) 186.39,157.72 186.5,157.72 186.63,157.85 186.63,158.13 185.68,159.07 185.68,160.17 185.37,160.48 178.82,160.48 175.2,156.86 174.38,156.86 172.68,155.16 172.68,150.63 171.93,149.88 167.96,149.88 166.33,148.24 166.33,137.57 170.65,133.25 170.65,106.22 171.97,104.89 171.97,88.81 176.05,84.74 176.05,83.47 v2(176.24,83.27)
  BOTTOM w0.114: UG9.BK8 179.54,84.55 179.17,84.19 178.78,84.19 178.37,83.78 176.29,83.78 176.1,83.59 176.1,83.41 v2(176.24,83.27) ; v2(186.2,157.91) 186.07,157.79 185.75,157.79 185.5,157.53 185.5,153.34 185.78,153.05 186.06,153.05 RV619.2 RV664.1 ; UV3.10 190.34,161.58 190.97,162.21 190.97,162.46 190.84,162.58 189.63,162.58 189.07,162.03 189.07,159.46 189.37,159.16 189.37,156.93 189.55,156.76 189.94,156.76 v2(190.07,156.88) 190.26,156.69 190.59,156.69 190.85,156.95 191.65,156.95 192,156.6 192,156.47 192.94,155.52 UV3.3
MDP_HPD: length 4.4
  BOTTOM w0.114: JDP.2 198.32,163.13 197.81,162.62 197.81,161.29 197.81,161.29 CX1.1 RX2.2
MDP_LANE_N0_C: length 5.2
  TOP w0.114: CV27.2 197.94,163.51 197.94,164.01 197.84,164.12 197.84,164.12 197.49,164.47 v4(197.49,165.56) 197.49,166.06 197.98,166.55 198.83,166.55 JDP.5
MDP_LANE_N1_C: length 3.9
  TOP w0.114: CV30.2 201.13,163.63 201.13,166.74 JDP.11
MDP_LANE_N2_C: length 5
  TOP w0.114: CV33.2 204.34,163.82 v4(204.34,164.29) 204.34,165.91 204,166.25 203.86,166.25 203.79,166.19 203.79,165.56 203.67,165.43 203.41,165.43 203.13,165.72 JDP.17
MDP_LANE_N3_C: length 3.9
  BOTTOM w0.114: CV31.2 200.82,160.74 200.82,160.92 201.16,161.26 v4(201.16,162.08) 201.16,162.89 201.32,163.05 JDP.12
MDP_LANE_P0_C: length 5.2
  TOP w0.114: JDP.3 198.92,165.67 198.7,165.45 198.45,165.45 198.32,165.57 198.32,166.22 198.26,166.28 198.09,166.28 197.75,165.95 197.75,164.58 v4(198.03,164.31) 198.21,164.12 198.21,163.75 CV26.2
MDP_LANE_P1_C: length 3.9
  TOP w0.114: JDP.9 200.86,166.81 v4(200.86,164.77) 200.86,163.63 CV28.2
MDP_LANE_P2_C: length 5
  TOP w0.114: CV32.2 v4(204.61,165.57) 204.61,166.02 204.11,166.52 203.25,166.52 JDP.15
MDP_LANE_P3_C: length 3.9
  BOTTOM w0.114: JDP.10 200.73,163.05 200.89,162.89 200.89,161.38 200.55,161.03 200.55,160.76 CV29.2
ME_EN: length 113.6
  TOP w0.089: v2(179.84,49.2) 179.84,49.75 179.47,50.13 179.47,50.41 179.15,50.72 179.15,51.63 179.47,51.95 179.47,52.34 RH16.1
  TOP w0.114: UE5.99 88.71,18.94 v2(89.43,18.21)
  IN2 w0.097: v2(179.84,49.2) 179.32,48.68 177.64,48.68 177.28,48.32 174.65,48.32 174.1,47.77 174.1,46.42 173.3,45.62 173.02,45.62 172.5,45.09 167.85,45.09 167.61,44.85 164.28,44.85 164.03,44.6 158.7,44.6 156.21,42.11 152.78,42.11 148.1,37.43 147.59,37.43 144.35,34.19 144.35,31.08 143.71,30.44 143.27,30.44 139.62,26.79 136.71,26.79 136.16,26.24 115.34,26.24 111.35,22.25 109.99,22.25 109.36,21.63 108.04,21.63 107.56,21.15 104.61,21.15 104.29,21.47 93.72,21.47 93.11,20.85 90.31,20.85 89.43,19.97 v2(89.43,18.21)
ME_SUS_PWR_ACK: length 119.9
  TOP w0.089: v2(183.41,42.86) 183.81,42.45 v1(184.49,42.45) 184.56,42.45
  TOP w0.114: UE5.71 98.67,19.5 98.48,19.31 98.48,17.72 97.87,17.11 97.87,14.5 98.73,13.64 v2(98.73,12.55) ; 184.67,42.45 184.56,42.45
  TOP w0.127: RH506.1 184.67,42.45
  IN2 w0.097: v2(183.41,42.86) 183.62,42.65 183.62,42.09 183.18,41.64 183.18,39.87 183.27,39.78 183.27,38.7 182.89,38.31 182.2,38.31 181.43,37.55 181.43,37.38 180.84,36.8 177.56,36.8 176.86,37.49 176.39,37.49 176.15,37.24 176.15,32.08 174.7,30.63 174.7,30.18 174.77,30.11 174.77,28.95 173.34,27.52 173.34,26.97 173.05,26.67 172.56,26.67 171.52,25.63 169.48,25.63 168.78,24.92 157.55,24.92 154.76,22.14 150.71,22.14 148.1,19.52 144.67,19.52 142.91,17.77 139.17,17.77 138.25,16.85 119.07,16.85 118.08,15.86 116.77,15.86 113.78,12.86 110.14,12.86 109.35,12.08 105.54,12.08 104.98,11.52 102.92,11.52 102.18,12.26 100.48,12.26 100.12,12.62 98.81,12.62 v2(98.73,12.55)
  BOTTOM w0.089: UH1.BD19 182.15,43.57 182.35,43.37 182.54,43.37 182.71,43.19 183.07,43.19 v2(183.41,42.86)
MEM_VDD_CTL: length 151.9
  TOP w0.114: v2(261.52,56.68) 261.71,56.49 v1(262.38,56.49)
  TOP w0.254: PR8214.1 v2(261.52,56.68)
  IN1 w0.097: v2(261.52,56.68) 257.46,56.68 256.17,55.4 256.17,50.11 255.6,49.54 255.6,46.82 251.22,42.44 251.22,39.33 250.78,38.89 236.53,38.89 235.41,37.77 222.76,37.77 217.69,32.7 217.69,29.86 218.54,29.01 218.54,26.85 217.5,25.81 207.85,25.81 207.09,26.56 199.03,26.56 198.07,27.52 198.07,28.09 194.67,31.48 194.67,33.65 188.91,39.41 188.91,41.15 188.3,41.75 188.3,52.01 187.62,52.69 187.31,52.69 186.34,53.67 186.34,62.99 181.97,67.35 181.97,70.03 180.62,71.39 180.62,74.73 181.18,75.28 181.18,81.07 v2(180.8,81.45)
  BOTTOM w0.114: UG9.BH4 v2(180.8,81.45)
MEM_VREF: length 210.2
  TOP w0.102: v2(194.96,143.34) 195.02,143.34 v1(195.4,143.72)
  TOP w0.381: v2(184.23,81.37) 184.13,81.47 RG24.1
  IN2 w0.381: v2(194.96,143.34) 195.53,143.92 197.18,143.92 197.69,143.41 233.25,143.41 237.43,139.23 v2(237.43,127.72)
  IN3 w0.508: v2(184.23,81.37) 183.45,82.14 182.6,82.14 182.1,82.64 182.1,82.96 181.67,83.39 181.07,83.39 180.5,82.83 178.64,82.83 177.08,84.38 177.08,88.38 178.58,89.88 178.58,96.54 172.92,102.2 172.92,112.93 178.58,118.58 178.58,135.53 178.94,135.89 178.94,143.03 179.64,143.74 194.56,143.74 v2(194.96,143.34)
  BOTTOM w0.305: UG9.BD3 183.91,81.05 v2(184.23,81.37)
  BOTTOM w0.381: QG2.2 195.85,137.99 195.85,138.77 195.51,139.11 195.51,142.29 195.15,142.65 195.15,143.15 v2(194.96,143.34) ; QG4.2 238.58,90.77 239.73,89.62 242.01,89.62 242.52,90.13 242.52,94.51 245.86,97.85 245.86,126.72 244.16,128.42 238.12,128.42 v2(237.43,127.72) 236.87,127.17 236.87,125.44 237.14,125.17 QG3.2
MIC1-VREFO_L: length 33.9
  IN4 w0.254: v2(18.81,17.57) 17.28,19.09 v2(17.28,20.36) 17.47,20.55 17.86,20.55 18.43,21.13 18.43,21.83 17.15,23.11 17.15,24.3 16.46,24.99 16.46,29.36 18.43,31.33 18.43,39.2 19.08,39.86 v2(20.4,39.86)
  BOTTOM w0.203: v2(20.4,39.86) 20.4,39.73 20.78,39.35 22.11,39.35 22.28,39.18 UA1.38
  BOTTOM w0.254: RA28.1 v2(18.81,17.57) ; v2(17.28,20.36) 18.77,20.36 19.09,20.69 v1(19.09,20.9) 19.09,21.58 RA26.1
MIC_CLK: length 202.3
  TOP w0.114: RV13.1 127.81,157.19 128.09,157.47 128.09,158.75 127.6,159.24 JEDP.23 127.6,160.44 127.78,160.62 127.78,160.72 v2(127.61,160.89)
  IN2 w0.097: v2(30.29,44.93) 30.29,46.69 33.22,49.62 33.22,51.08 39.89,57.75 42.43,57.75 47.61,62.92 62.21,62.92 65.13,65.84 65.13,67.3 65.9,68.07 67.42,68.07 68.09,68.73 68.09,71.4 78.18,81.5 78.18,82.76 84.56,89.15 84.56,116.02 84.56,142.42 85.8,143.66 92.3,143.66 93.29,142.67 93.3,142.67 93.84,142.13 114.78,142.13 118.79,146.14 129.85,146.14 130.48,146.77 130.48,148.48 131.32,149.33 131.32,154.47 129.14,156.65 129.14,158.23 127.74,159.62 127.74,160.76 v2(127.61,160.89)
  BOTTOM w0.114: v2(30.29,44.93) 30.29,45.04 29.93,45.4 CA34.1 LA6.1
MIC_DATA: length 198.8
  TOP w0.114: v2(128.19,160.89) 128.02,160.72 128.02,160.58 128.1,160.5 JEDP.22
  IN2 w0.097: v2(31.5,45.4) 30.92,45.4 30.52,45.81 30.52,46.59 33.45,49.53 33.45,50.99 39.99,57.52 42.53,57.52 47.7,62.7 62.31,62.7 65.36,65.75 65.36,67.21 65.99,67.84 67.51,67.84 68.31,68.64 68.31,71.31 78.41,81.4 78.41,82.67 84.79,89.05 84.79,116.11 84.79,142.33 85.9,143.44 92.2,143.44 93.2,142.45 93.2,142.45 93.74,141.91 114.87,141.91 118.88,145.91 129.94,145.91 130.7,146.67 130.7,148.39 131.55,149.24 131.55,154.56 129.36,156.75 129.36,158.32 127.97,159.71 127.97,160.67 v2(128.19,160.89)
  BOTTOM w0.114: v2(31.5,45.4) CA35.1 RA19.1
MUX_EDP_A0N: length 104.6
  TOP w0.089: v2(116.07,156.12) 115.85,156.12 115.72,156.25 115.72,156.47 115.93,156.68 115.93,157.1 CV2.2
  IN1 w0.089: v2(116.07,156.12) 115.82,156.12 115.67,156.27 115.67,156.67 117.13,158.13 123.05,158.13 124.44,156.74 126.67,156.74 128.66,154.75 128.66,151.43 131.03,149.05 131.85,149.05 139.1,141.79 149.76,141.79 150.47,141.08 159.29,141.08 164.58,135.8 164.58,126.62 165.45,125.75 165.77,125.75 165.85,125.67 165.94,125.67 166,125.61 v2(166,125.35)
  BOTTOM w0.089: UV21.45 161.22,105.64 161.38,105.48 164.72,105.48 170.22,110.98 170.22,123.55 167.99,125.78 166.28,125.78 166.17,125.67 166.05,125.67 166,125.62 v2(166,125.35)
MUX_EDP_A0P: length 104.6
  TOP w0.089: CV1.2 115.69,157.22 115.69,156.78 115.48,156.57 115.48,156.23 v2(115.34,156.09)
  IN1 w0.089: v2(115.34,156.09) 115.41,156.17 115.41,156.77 117.03,158.39 123.16,158.39 124.55,157 126.77,157 128.92,154.85 128.92,151.54 131.14,149.31 131.95,149.31 139.21,142.05 149.87,142.05 150.58,141.34 159.4,141.34 164.84,135.91 164.84,126.73 165.56,126.01 165.98,126.01 v2(166.01,126.04)
  BOTTOM w0.089: UV21.46 164.82,105.24 170.46,110.88 170.46,123.65 168.09,126.02 166.03,126.02 v2(166.01,126.04)
MUX_EDP_A1N: length 99.3
  TOP w0.089: CV4.2 116.95,155.64 116.95,155.37 117.08,155.24 v2(117.3,155.24)
  IN1 w0.089: v2(166.02,123.37) 166.02,123.58 165.75,123.84 165.14,123.84 163.93,125.05 163.93,135.53 159.02,140.43 150.2,140.43 149.49,141.14 138.83,141.14 136.28,143.69 135.37,143.69 133.43,145.64 132.74,145.64 127.97,150.41 127.97,153.45 125.38,156.04 122.47,156.04 121.46,157.05 117.92,157.05 116.95,156.08 116.95,155.37 117.07,155.24 v2(117.3,155.24)
  BOTTOM w0.089: v2(166.02,123.37) 166.02,123.57 166.31,123.86 167.96,123.86 169.41,122.41 169.41,112.16 164.33,107.09 162.04,107.09 161.64,106.68 161.26,106.68 161.11,106.84 UV21.42
MUX_EDP_A1P: length 99.3
  TOP w0.089: CV3.2 116.71,155.75 116.71,155.37 v2(116.59,155.24)
  IN1 w0.089: v2(116.59,155.24) 116.69,155.34 116.69,156.19 117.81,157.31 121.57,157.31 122.58,156.3 125.49,156.3 128.23,153.56 128.23,150.51 132.84,145.9 133.54,145.9 135.48,143.95 136.39,143.95 138.94,141.4 149.6,141.4 150.31,140.69 159.13,140.69 164.19,135.63 164.19,125.16 165.24,124.1 166.02,124.1 v2(166.02,124.1)
  BOTTOM w0.089: v2(166.02,124.1) 168.06,124.1 169.65,122.51 169.65,112.06 164.43,106.84 162.14,106.84 161.74,106.44 UV21.43
MUX_EDP_A2N: length 95.5
  TOP w0.089: CV6.2 135.31,157.48 135.31,157.26 134.43,156.39 133.66,156.39 133.43,156.15 133.27,156.15 133.15,156.27 v2(133.15,156.43)
  IN1 w0.089: v2(166,121.54) 166,121.54 166.34,121.88 166.42,121.88 166.7,122.15 166.7,127 166.42,127.28 165.94,127.28 165.49,127.73 165.49,136.18 159.67,142 154.33,142 153.62,142.71 144.19,142.71 143.67,143.22 138.97,143.22 132.17,150.02 132.17,150.16 130.77,151.57 130.77,156.54 132.34,158.12 133.65,158.12 134.32,157.45 134.32,156.63 133.8,156.11 133.27,156.11 133.15,156.23 v2(133.15,156.43)
  BOTTOM w0.089: UV21.39 161.22,108.04 161.36,107.9 161.68,107.9 161.82,108.04 162.04,108.04 162.18,107.9 162.39,107.9 162.53,108.04 162.75,108.04 162.89,107.9 163.11,107.9 163.25,108.04 163.46,108.04 163.6,107.9 163.99,107.9 168.59,112.5 168.59,115.65 168.48,115.76 168.48,116 168.59,116.12 168.59,116.36 168.48,116.47 168.48,116.72 168.59,116.83 168.59,117.24 168.48,117.35 168.48,117.59 168.59,117.71 168.59,117.95 168.48,118.06 168.48,118.3 168.59,118.42 168.59,118.66 168.48,118.77 168.48,119.01 168.59,119.13 168.59,119.37 168.48,119.48 168.48,119.72 168.59,119.84 168.59,120.08 168.48,120.19 168.48,120.44 168.59,120.55 168.59,120.79 168.48,120.91 168.48,121.15 168.59,121.26 168.59,121.53 168.24,121.88 167.78,121.88 167.66,121.75 167.42,121.75 167.3,121.88 167.07,121.88 166.94,121.75 166.71,121.75 166.59,121.88 166.25,121.88 166,121.62 v2(166,121.54)
MUX_EDP_A2P: length 95.5
  TOP w0.089: v2(133.15,155.74) 133.32,155.91 133.53,155.91 133.76,156.15 134.53,156.15 135.55,157.16 135.55,157.58 CV8.2
  IN1 w0.089: v2(133.15,155.74) 133.26,155.85 133.9,155.85 134.58,156.53 134.58,157.55 133.76,158.38 132.23,158.38 130.51,156.65 130.51,151.46 131.91,150.06 131.91,149.91 138.86,142.96 143.56,142.96 144.08,142.45 153.52,142.45 154.23,141.74 159.57,141.74 165.23,136.07 165.23,127.62 165.83,127.02 166.32,127.02 166.44,126.89 166.44,122.26 166.32,122.13 166.01,122.13 v2(166,122.15)
  BOTTOM w0.089: UV21.40 161.22,107.64 161.24,107.66 164.09,107.66 168.84,112.4 168.84,121.63 168.34,122.12 166.03,122.12 v2(166,122.15)
MUX_EDP_A3N: length 86
  TOP w0.089: v2(133.35,156.98) 133.58,157.21 133.58,157.35 133.69,157.47 133.69,157.58 CV11.2
  IN1 w0.089: v2(133.35,156.98) 133.51,157.14 133.51,157.32 133.36,157.47 132.63,157.47 131.52,156.35 131.52,152.58 132.85,151.25 132.85,150.29 139.22,143.91 146.71,143.91 147.26,143.36 153.9,143.36 154.61,142.65 159.94,142.65 166.2,136.39 166.2,133.5 166.66,133.03 166.66,127.96 167.35,127.27 167.35,120.69 166.57,119.91 165.93,119.91 165.81,119.78 165.81,119.6 v2(166,119.4)
  BOTTOM w0.089: v2(166,119.4) 165.99,119.42 165.99,119.77 166.27,120.06 167.31,120.06 167.58,119.79 167.58,112.64 164.02,109.08 161.38,109.08 161.22,109.24 UV21.36
MUX_EDP_A3P: length 86
  TOP w0.089: v2(133.94,156.98) 133.81,157.11 133.82,157.11 133.82,157.25 133.94,157.36 133.94,157.48 CV7.2
  IN1 w0.089: v2(166.01,120.33) 166.18,120.17 166.46,120.17 167.1,120.8 167.1,127.16 166.4,127.85 166.4,132.92 165.94,133.39 165.94,136.29 159.84,142.39 154.5,142.39 153.79,143.1 147.16,143.1 146.6,143.66 139.11,143.66 132.59,150.18 132.59,151.14 131.26,152.48 131.26,156.46 132.52,157.73 133.47,157.73 133.77,157.43 133.77,157.15 v2(133.94,156.98)
  BOTTOM w0.089: UV21.37 164.12,108.84 167.82,112.54 167.82,119.89 167.41,120.3 166.05,120.3 v2(166.01,120.33)
MUX_EDP_AUXN: length 81
  TOP w0.114: v2(131.94,156.14) 132.1,156.3 132.1,157.1 132.28,157.28 132.28,157.48 CV13.2
  IN1 w0.104: v2(162.43,112.22) 162.43,112.27 163.15,112.99 165.1,112.99 167.84,115.74 167.84,127.52 167.14,128.22 167.14,136.22 160.21,143.15 154.89,143.15 154.13,143.92 147.46,143.92 146.83,144.55 139.31,144.55 134.23,149.64 134.23,150.59 132.94,151.87 132.94,154.19 132.13,155 132.13,155.95 v2(131.94,156.14)
  BOTTOM w0.114: RV19.2 161.72,113.75 161.72,113.47 161.98,113.21 162.23,113.21 162.61,112.83 162.61,112.45 162.43,112.27 v2(162.43,112.22) 162.64,112.01 162.64,111.66 162.13,111.15 161.33,111.15 161.24,111.24 UV21.31
MUX_EDP_AUXP: length 81.1
  TOP w0.114: v2(132.53,156.14) 132.32,156.34 132.32,157.01 132.5,157.19 132.5,157.53 CV12.2
  IN1 w0.104: v2(163.01,112.22) 163.01,112.53 163.28,112.8 165.18,112.8 168.04,115.66 168.04,127.6 167.33,128.3 167.33,136.3 160.29,143.35 154.97,143.35 154.21,144.11 147.54,144.11 146.91,144.74 139.39,144.74 134.42,149.72 134.42,150.67 133.14,151.95 133.14,154.27 132.32,155.08 132.32,155.94 v2(132.53,156.14)
  BOTTOM w0.114: RV20.1 161.94,113.74 161.94,113.56 162.07,113.44 162.32,113.44 162.83,112.92 162.83,112.4 v2(163.01,112.22) 162.86,112.07 162.86,111.56 162.22,110.93 161.33,110.93 161.24,110.84 UV21.32
NC_B4: length 5.7
  TOP w0.089: UT1.B4 145.49,160.16 145.72,160.38 145.72,160.92 145.71,160.93
  TOP w0.114: 145.71,160.93 145.49,161.15 145.49,161.82 145.24,162.08 145.24,162.72 RT45.1 145.49,162.72 145.49,162.58 v2(145.94,162.14)
  BOTTOM w0.114: v2(145.94,162.14) 146.2,162.14 v1(146.45,161.9) RT86.2
NC_B5: length 3.2
  TOP w0.089: 146.19,160.81 146.19,160.41 145.95,160.17 UT1.B5
  TOP w0.127: RT46.1 146.79,162.56 v1(146.79,161.62) 146.79,161.41 146.19,160.81
NC_G2: length 5
  TOP w0.089: 143.66,156.5 143.77,156.61 143.77,157.43 143.93,157.6 144.35,157.6 UT1.G2
  TOP w0.114: 143.66,156.5 142.94,155.78 142.94,154.79 v1(143.03,154.7) 142.96,154.63 RT47.1
Net_259:
  vias: v2(200.74,75.14) v2(200.74,73.49) v2(202.39,75.14) v2(202.39,73.49)
NVVDD1_EN: length 220.6
  TOP w0.114: RG549.2 185.5,56.74 DG7.1 186.36,57.87 CG442.1 187.23,57.67 v2(187.28,57.62)
  TOP w0.254: v2(202.9,30.82) 203.15,30.82 203.4,31.08 203.77,31.08 PR6102.1 202.58,28.99 v2(202.58,28.98) 202.58,27.33 204.52,25.39 213.34,25.39 v2(214.14,26.19) 215.28,27.33 219.09,27.33 220.11,28.35 221.12,28.35 221.32,28.15 QG509.2 ; v2(120.53,16.24) 120.59,16.18 RG568.1
  IN3 w0.254: v2(232.61,15.65) 230.17,13.2 216.79,13.2 214.33,10.73 194.49,10.73 190.41,14.81 186.4,14.81 185.72,15.48 179.35,15.48 178.68,14.81 167.7,14.81 167.15,14.26 165.33,14.26 163.22,16.37 140.04,16.37 138.06,18.35 125.64,18.35 124.01,16.72 120.87,16.72 120.53,16.37 v2(120.53,16.24)
  IN4 w0.254: v2(202.58,28.98) 201.25,28.98 200.36,28.09 197.63,28.09 195.4,30.31 195.4,33.43 194.16,34.67 193.05,34.67 189.56,38.15 189.56,42.06 189.17,42.45 189.17,53.01 188.76,53.42 188.76,54.21 188.41,54.57 188.41,56.49 v2(187.28,57.62)
  BOTTOM w0.203: PU6100.3 202.19,31.2 202.57,30.82 v2(202.9,30.82) 203.52,30.82 203.77,31.08
  BOTTOM w0.254: v2(232.61,15.65) 232.3,15.65 231.79,16.15 231.79,20.26 231.25,20.8 231.25,23.66 230.45,24.46 221.2,24.46 221.12,24.38 218.61,24.38 218.14,24.85 v1(216.75,24.85) 215.47,24.85 v2(214.14,26.19) ; PR6103.2 203.77,31.33 203.77,31.08
NVVDD1_PGOOD: length 78.2
  TOP w0.254: v2(185.05,61.05) 184.67,61.05 184.67,61.05 DG4.1
  IN2 w0.254: v2(194.26,33.36) 194.26,31.14 196.04,29.36 201.37,29.36 202.26,28.47 207.98,28.47 208.68,27.77 214.52,27.77 217.96,31.22 v2(218.72,31.22)
  IN3 w0.254: v2(185.05,61.05) 185.33,61.05 186.07,61.78 186.07,66.89 186.76,67.58 187.47,67.58 v2(187.48,67.59)
  IN4 w0.254: v2(194.26,33.36) 193.35,33.36 188.8,37.91 188.8,41.74 188.46,42.08 188.46,52.62 186.32,54.77 186.32,57.09 185.05,58.35 v2(185.05,61.05)
  BOTTOM w0.203: PU6100.13 198.01,31.2 197.82,31.01 196.64,31.01 PR6107.1
  BOTTOM w0.254: v2(194.26,33.36) v1(194.26,32.31) 194.5,32.07 195.57,32.07 196.36,31.28 PR6107.1 ; UG29.2 187.4,67.66 v2(187.48,67.59) ; v2(218.72,31.22) 218.72,31.58 PR6201.1
NVVDD1_PSI: length 5.6
  BOTTOM w0.114: v1(206.59,29.25) PR6132.2
  BOTTOM w0.203: PR6108.2 202.78,30.18 202.16,30.8 PU6100.4
  BOTTOM w0.254: PR6132.2 PR6133.2 204.69,29.25 204.17,29.77 204.03,29.77 203.76,30.03 PR6108.2
NVVDD2_EN: length 266.6
  TOP w0.114: v2(89.1,66.57) 89.45,66.23 89.45,66 89.68,65.77 91.06,65.77 91.22,65.93 UG28.4 ; RG569.1 116.42,12.99 v2(116.74,13.31)
  TOP w0.254: PR6202.1 216.37,30.69 v2(216.1,30.69) ; v2(186.96,46.7) 187.47,46.7 v3(187.53,46.76) 188.04,47.27 188.04,50.13 188.16,50.25 QG507.2 189.24,50.25 189.77,50.77 PR8217.2
  IN3 w0.254: v2(116.74,13.31) 117.36,13.93 117.36,15.26 120.47,18.38 123.65,18.38 124.8,19.53 138.69,19.53 140.54,17.68 154.26,17.68 156.52,19.94 177.13,19.94 177.17,19.9 179.65,19.9 180.6,20.85 188.29,20.85 189.12,21.68 189.12,24.03 189.87,24.78 190.82,24.78 191.66,25.61 193.94,25.61 194.77,24.79 203.09,24.79 204.04,25.74 205.69,25.74 v2(205.82,25.87)
  IN4 w0.137: v2(89.1,66.57) 89.1,66.51 89.68,65.94 89.68,64.4 88.42,63.14 87.45,63.14 83.26,58.95 83.26,57.99 80.73,55.45 80.73,48 80.09,47.36 79.83,47.1 79.83,35.66 77.67,33.5 77.67,26.12 79.96,23.84 79.96,18.5 79.58,18.12 78.82,18.12 78.06,17.36 v2(77.87,17.36)
  IN4 w0.254: v2(186.96,46.7) 186.96,44.41 185.61,43.07 185.61,30.29 190.6,25.3 195.25,25.3 195.92,24.63 202.99,24.63 204.1,25.74 205.69,25.74 v2(205.82,25.87) 205.94,25.74 212.61,25.74 216.11,29.24 216.11,30.69 v2(216.1,30.69)
  BOTTOM w0.114: v2(77.87,17.36) 77.87,17.49 78.12,17.74 79.9,17.74 80.44,17.2 82.09,17.2 83.14,16.15 84.33,16.15 84.63,15.85 86.53,15.85 86.83,16.15 90.82,16.15 92.85,14.12 94.25,14.12 95.58,12.79 97.04,12.79 97.2,12.95 116.38,12.95 v2(116.74,13.31)
  BOTTOM w0.203: 216.16,30.73 216.12,30.69 v2(216.1,30.69) 215.46,30.69 215.08,31.07 PU6200.3
  BOTTOM w0.254: 216.16,30.73 216.16,30.76 216.82,31.42 217.01,31.42 PR6201.2
NVVDD2_PGOOD: length 189.6
  TOP w0.114: QG502.4 185.8,62.33 v2(185.41,61.94) 185.01,62.33 184.6,62.33 DG4.2 183.9,62.45 RG506.2
  IN2 w0.254: v2(174.39,65.68) 171.44,65.68 167.02,70.1 164.57,70.1 163.9,70.78 163.9,78 164.53,78.64 164.53,91.22 163,92.75 163,97.48 163.91,98.39 163.91,102.38 164.54,103.01 164.54,107.05 168.33,110.84 168.33,133.64 163.21,138.76 163.21,153.12 162.23,154.11 162.23,156.65 161.99,156.88 160.11,156.88 159.53,156.3 v2(159.53,155.15)
  IN4 w0.254: v2(210.64,31.52) 210.64,32.85 209.88,33.62 207.49,33.62 206.72,32.84 205.17,32.84 203.75,31.42 203.75,29.37 202.11,27.73 197.48,27.73 195.02,30.19 195.02,33.3 194.01,34.31 192.9,34.31 189.17,38.05 189.17,41.89 188.82,42.23 188.82,52.77 186.67,54.91 186.67,57.23 185.56,58.34 185.56,61.78 v2(185.41,61.94)
  IN5 w0.254: v2(174.39,65.68) 175.25,64.82 177.94,64.82 179.51,63.26 182.31,63.26 182.72,63.66 183.72,63.66 184.23,63.16 184.23,62.78 185.07,61.94 v2(185.41,61.94)
  BOTTOM w0.203: PR6205.1 210.18,31.99 v2(210.64,31.52) 210.64,31.39 210.97,31.07 PU6200.13
  BOTTOM w0.254: v2(159.53,155.15) 158.7,155.15 158.32,155.54 158.32,157.31 v1(158.35,157.34) 158.64,157.63 PR801.2
NVVDD2_PSI: length 5.9
  BOTTOM w0.203: PR6228.2 217.02,30.89 216.4,30.26 v1(215.8,30.26) 215.46,30.26 215.05,30.67 PU6200.4
  BOTTOM w0.254: PR6228.2 PR6229.2 217.4,29.79 PR6230.1
NVVDD_B+:
  vias: v2(191.72,46.13) v2(191.72,45.49) v2(192.23,46.44) v2(192.23,45.81) v2(192.23,45.17) v2(192.23,41.81) v2(192.23,41.17) v2(192.23,40.54) v2(192.23,39.9) v2(192.23,39.27) v2(210.26,46.32) v2(210.26,45.68) v2(210.26,45.05) v2(210.26,44.41) v2(210.26,43.78) v2(210.33,41.36) v2(210.33,40.73) v2(210.33,40.09) v2(210.33,39.46) v2(210.33,38.82) v2(229,51.33) v2(229.63,51.33) v2(230.27,51.33) v2(230.9,51.33) v2(231.54,51.33) v2(233.31,51.33) v2(233.95,51.33) v2(234.58,51.33) v2(235.22,51.33) v3(209.36,39.13)
NVVDD_BST1: length 1.8
  BOTTOM w0.114: PR6104.1 203.63,32.31 v1(204.8,33.49)
NVVDD_BST2: length 0.9
  BOTTOM w0.114: v1(195.49,32.65) 195.81,32.33 196.31,32.33
NVVDD_COMP: length 6
  TOP w0.114: v1(196.42,32.21) PC6109.2
  TOP w0.254: PR6109.2 198.46,31.47 197.56,30.57 v2(197.5,30.57) 197.18,30.57 196.47,31.28 PC6109.2
  BOTTOM w0.203: v2(197.5,30.57) 197.81,30.57 198.04,30.8 PU6100.12
  BOTTOM w0.254: PR6112.2 197.19,30.38 197.37,30.57 v2(197.5,30.57)
NVVDD_HG1: length 15.9
  IN1 w1.016: 209.32,47.07 209.32,43.45 ; 209.39,41.42 209.39,38.14 203.6,32.35
  BOTTOM w0.114: v2(209.51,48.02) v1(209.51,48.86)
  vias: v2(202.52,31.52) v2(203.15,31.52) v2(208.88,48.02) v2(209.07,42.43) v2(209.7,42.43)
NVVDD_HG2: length 10.1
  IN1 w1.016: 194.13,36.79 197.37,33.55 197.37,32.54 ; 192.93,42.32 193.5,41.74 193.5,38.7
  BOTTOM w0.114: v2(193.23,37.49) v1(193.23,36.81)
  vias: v2(192.42,43.14) v2(193.05,43.14) v2(193.86,37.49) v2(197.05,31.52) v2(197.69,31.52)
NVVDD_LG1: length 11.2
  IN1 w1.016: 203.48,46.88 203.48,43.39 ; 203.67,41.23 203.67,36.8 201.79,34.92
  BOTTOM w0.114: v2(203.23,48.09) v1(203.23,48.73)
  vias: v2(200.93,34.38) v2(200.93,33.74) v2(203.23,42.37) v2(203.85,48.09) v2(203.85,42.38)
NVVDD_LG2: length 5.9
  IN1 w1.016: 199.09,35.39 199.09,35.9 198.39,36.6 ; 198.39,42.06 198.39,38.31
  BOTTOM w0.114: v2(198.75,37.49) v1(198.75,36.82)
  vias: v2(198.13,43.14) v2(198.11,37.49) v2(198.77,43.14) v2(199.29,34.34) v2(199.29,33.74)
NVVDD_PSI: length 75.1
  TOP w0.114: v2(183.85,74.22) 183.59,74.47 183.59,77.82 RG565.1
  IN4 w0.137: v2(205.31,30.11) 204.8,29.61 204.8,29.14 202.48,26.82 196.55,26.82 196.17,27.2 195.59,27.2 195.21,27.58 193.31,27.58 192.93,27.2 190.96,27.2 190.13,28.03 190.13,36.16 188.48,37.81 188.48,41.55 188.16,41.87 188.16,52.09 185.35,54.91 185.35,55.86 185.55,56.06 185.55,57.44 183.59,59.39 183.59,62.25 184.77,63.43 184.77,64.76 183.6,65.93 183.6,68.13 183.99,68.52 183.99,72.82 183.4,73.4 183.4,73.77 v2(183.85,74.22)
  BOTTOM w0.114: RG566.2 183.93,75.36 RG15.1 184.05,75.34 184.41,74.98 184.41,74.5 v1(184.33,74.42) 184.13,74.22 v2(183.85,74.22)
  BOTTOM w0.254: v2(205.31,30.11) 205.25,30.18 PR6108.1
NVVDD_SW1:
  vias: v1(206.22,36.09) v2(204.6,48.94) v2(204.6,48.36) v2(204.64,47.02) v2(204.64,46) v2(204.64,44.99) v2(204.64,43.97) v2(204.64,41.37) v2(204.64,40.35) v2(204.64,39.34) v2(204.64,38.32) v2(205.18,48.94) v2(205.18,48.36) v2(205.37,36.22) v2(205.37,35.58) v2(205.71,47.01) v2(205.71,45.99) v2(205.71,44.97) v2(205.71,43.96) v2(205.78,48.92) v2(205.78,48.34) v2(206.36,48.92) v2(206.36,48.34) v2(206.42,41.37) v2(206.42,40.35) v2(206.42,39.34) v2(206.42,38.32)
NVVDD_SW2:
  vias: v1(196.7,36.51) v2(195.61,49) v2(195.61,48.41) v2(195.66,41.61) v2(195.66,40.6) v2(195.66,39.58) v2(195.66,38.57) v2(195.98,36.16) v2(196.24,49) v2(196.24,48.41) v2(196.3,47.3) v2(196.3,46.29) v2(196.3,45.27) v2(196.3,44.25) v2(196.88,49) v2(196.88,48.41) v2(197.44,47.26) v2(197.44,46.25) v2(197.44,45.23) v2(197.44,44.22) v2(197.44,41.61) v2(197.44,40.6) v2(197.44,39.58) v2(197.44,38.57) v2(197.51,49) v2(197.51,48.41) v2(197.56,36.16)
NVVDD_VCC_SENSE: length 122.8
  IN1 w0.381: v2(173.67,91.59) 173.67,90.54 169.88,86.75 169.88,84.16 169.47,83.76 169.47,78.51 170.51,77.47 170.51,76.77 171.22,76.06 171.22,70.31 177.63,63.9 178.98,63.9 182.58,60.3 182.58,58.32 184.76,56.14 184.76,53.67 184.93,53.5 184.93,52.47 185.3,52.1 185.3,46.83 187.48,44.65 187.48,41.33 187.72,41.09 187.72,39.34 193.18,33.87 193.18,31.81 197.12,27.88 197.12,27.01 196.84,26.73 v2(195.85,26.73)
  BOTTOM w0.127: 177.62,111.21 178.44,111.21 178.85,110.8 179.2,110.8 179.55,110.45 UG9.BK45
  BOTTOM w0.254: v2(173.67,91.59) 173.37,91.3 166.87,91.3 163.36,94.81 163.36,99.93 164.45,101.02 164.45,102.93 171.74,110.22 v1(171.74,111.68) 173.2,113.14 174.15,113.14 174.43,113.42 PR6126.2 175.41,113.42 177.62,111.21 ; PR6123.1 v2(195.85,26.73)
NVVDD_VID: length 74.8
  TOP w0.114: v2(204.14,27.62) v1(204.55,28.03)
  IN5 w0.097: v2(184.2,82.85) 183.54,82.19 183.54,79.16 183.08,78.7 182.32,78.7 181.56,77.94 181.56,74.62 184.57,71.61 184.57,68.5 183.63,67.56 183.63,64.43 184.72,63.33 185.32,63.33 185.82,62.84 185.82,61.49 185.5,61.17 185.5,56.53 185.14,56.17 185.14,54.84 185.64,54.34 185.87,54.34 189.41,50.8 189.41,43.16 190.77,41.8 190.77,38.02 192.55,36.24 192.55,31.18 194.55,29.17 195.35,29.17 196.37,28.15 198.71,28.15 199.59,27.27 202.13,27.27 202.48,27.62 v2(204.14,27.62)
  BOTTOM w0.114: v2(204.14,27.62) 203.79,27.96 PR6110.1 ; v2(184.2,82.85) 184.2,82.85 UG9.BD6
