# Allegro board LAD581PR10-0906.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UC1  -  [74AUP1G07GW_TSSOP5]  97.07 75 90 top
UE1  C8051F383-GQ_LQFP32_7X7  [C8051F347-GQ_LQFP32_7X7]  263.02 37.85 0 top
UE2  EN25Q80A-100HIP_SO8  [EN25F80-75HCP_SO8]  72.01 4.48 180 bottom
UE3  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  185.02 154.39 180 top
UE4  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  175.4 19.74 270 bottom
UE5  -  [KB9022QD_LQFP128_14X14]  88.67 5.71 90 top
UE6  KC3810_QFN24_4X4  [KC3810_QFN24_4X4-S]  69.15 8.91 180 top
UE7  -  [SY6288D20AAC_SOT23-5]  169.31 163.55 90 top
UE9  -  [SY6288C20AAC_SOT23-5]  74.54 1.89 0 top
UE10  KC3810_QFN24_4X4  [KC3810_QFN24_4X4-S]  119.16 9.67 0 top
UG1  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  209.81 142.38 180 bottom
UG2  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  180.74 129.58 0 bottom
UG3  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  243.08 109.57 90 bottom
UG4  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  215.41 129.58 0 bottom
UG5  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  241.05 74.71 90 bottom
UG6  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  228.25 103.95 270 bottom
UG9  N17E-G1_BGA2152~D  [N17E-G1_BGA_2152P]  214 79.65 90 bottom
UG10  -  [NL17SZ08DFT2G_SC70-5]  186.1 59.87 180 bottom
UG11  INA3221AIRGVR_VQFN16_4X4  [INA3221AIRGVR_VQFN16_4X4-S]  202.54 72.34 180 bottom
UG12  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  195.78 70.31 180 bottom
UG13  -  [W25Q80EWSSIG_SO8]  168.67 78.06 180 bottom
UG14  -  [TPS22961DNYR_WSON8]  192.63 77.89 180 top
UG15  -  [W25Q80EWSSIG_SO8]  167.08 71.15 0 bottom
UG16  -  [PI5A3158BZAEX_TDFN12_1X3]  168.44 76.27 270 bottom
UG22  -  [NL17SZ08DFT2G_SC70-5]  182.7 60.97 90 top
UG23  -  [BSS138DW_SC88-6]  187.96 80.74 0 top
UG24  -  [BSS138DW_SC88-6]  164.65 59.72 0 top
UG25  -  [74LVC1G32GW_TSSOP5]  92.96 65.36 0 top
UG26  -  [NL17SZ08DFT2G_SC70-5]  95.5 64.99 0 top
UG27  -  [74LVC1G32GW_TSSOP5]  189.13 79.11 180 top
UG28  -  [NL17SZ08DFT2G_SC70-5]  89.92 64.35 0 top
UG29  -  [NL17SZ08DFT2G_SC70-5]  186.75 68.88 0 bottom
UH1  SKL-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  160.14 52.5 90 bottom
UH3  -  [TC7SH08FU_SSOP5]  180.8 36.97 180 top
UH4  -  [W25Q128FVSIQ_SO8]  177.57 23.34 90 bottom
UH5  AH1806-W-7 SC59 3P OMNIPOLAR SW  [S-5711ACDL-M3T1S_SOT23-3]  318.49 82.96 90 top
UL1  S IC E2400-BL3A-R QFN 40P E-LAN CTRL  [E2201-BL3A-R_QFN40_5X5-S]  199.09 151.85 0 bottom
UL2  -  [SY6288D20AAC_SOT23-5]  194.31 152.03 270 bottom
UM3  -  [TC7SH08FU_SSOP5]  128.43 166 180 bottom
UM4  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  92.07 144.4 180 bottom
UM7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  116.51 167.78 0 bottom
UM8  DS80PCI402SQNOPB_WQFN54_10X5P5  [DS80PCI402_WQFN54_10X5P5-S]  106.59 147.1 180 bottom
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  144.11 160.58 0 top
UT2  -  [W25Q80DVSSIG_SO8]  137.8 150.58 0 bottom
UT4  TPS65982_BGA96  [TPS65982_BGA_96P]  123.55 148.58 0 bottom
UU1  TPS2546RTER_QFN16_3X3  [TPS2540RTER_QFN16_3X3-S]  19.38 47.5 0 top
UU3  -  [SY6288C20AAC_SOT23-5]  302 61.68 90 top
UU5  TC7SZ14FU_SSOP5~D  [TC7SZ14FU_SSOP5]  67.26 59.44 90 top
UU7  TPS25810RVCR_QFN20_4X3  [TPS25810RVCR_QFN20_4X3-S]  294.11 43.17 270 top
UV3  -  [SN74CBT3257CPWR_TSSOP16]  194.24 154.92 180 bottom
UV17  -  [SY6288C20AAC_SOT23-5]  140.4 164.86 270 bottom
UV21  PS8331BQFN60GTR-A2_QFN60_5X9  [PS8331BQFN60GTR-A0_QFN60_5X9-S]  155.58 103.64 90 bottom
UV22  -  [SN74CBT3257CPWR_TSSOP16]  164.7 128.37 90 bottom
UX1  -  [NL17SZ08DFT2G_SC70-5]  194.45 154.92 270 top
UX2  -  [NL17SZ08DFT2G_SC70-5]  167.77 164.05 270 bottom
UZ21  -  [APE8937GN2_DFN8_2X2]  99.58 89.3 180 bottom
YG1  27MHZ 16PF +-30PPM 7M27070004F50Q5  [Y_5YEA27000163IF50Q5_4P]  172.57 82.47 270 bottom
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  186.69 51.11 270 bottom
YH2  24MHZ 12PF +-10PPM 7M24090001  [Y_X3G024000DC1H_4P]  158.35 59.54 0 bottom
YL1  25MHZ_12PF_7V25000012  [Y_FSX3M-25PM20FDO_4P]  203.16 155.23 180 bottom
YT1  25MHZ 20PF +-10PPM 7M25000153  [Y_7V25000012_4P]  162.01 160.82 180 top

## Library data of the parts
C2-C4 C6 C7 C10 C11 C29 C258 C263 C265 C268 C270 C617 C618 C620-C625 C627 C628 C635-C638 C2498 C2500 C2502 C2504-C2511 C2516 C2518-C2525 CA1 CA2 CA4 CA6 CA8 CA10-CA13 CA15 CA16 CA18-CA21 CA23-CA28 CA30 CA34-CA41 CA53 CA54 CA56-CA60 CA62-CA66 CA71 CA74 CA77 CA78 CA80 CA81 CA83-CA85 CA87-CA92 CA254-CA259 CD1-CD4 CD12 CD16 CD18-CD22 CD29-CD32 CD34 CD69 CD74-CD83 CD91 CD92 CE1 CE3 CE4 CE6-CE9 CE13-CE20 CE24 CE25 CE27-CE36 CE38 CE40-CE46 CE51 CE55-CE65 CG2-CG4 CG13 CG17-CG19 CG23 CG40 CG47-CG49 CG51 CG53 CG54 CG56-CG61 CG64-CG66 CG75 CG76 CG78 CG79 CG83-CG91 CG100-CG106 CG113 CG114 CG118-CG126 CG135-CG141 CG148 CG149 CG153-CG161 CG170-CG176 CG192-CG215 CG230 CG233-CG238 CG240 CG241 CG291 CG292 CG295-CG300 CG308-CG310 CG312-CG318 CG322 CG323 CG325-CG343 CG345-CG363 CG365-CG386 CG391-CG403 CG407-CG419 CG423-CG437 CG442 CG443 CG487 CH1-CH4 CH45-CH49 CH70 CH80 CH82 CH100 CH101 CH105-CH110 CH173-CH176 CH179 CH180 CH183 CH185-CH195 CH197 CH200 CI38 CI39 CL1-CL9 CL11-CL13 CL16-CL21 CL23-CL25 CL27-CL29 CL31-CL39 CL41-CL44 CM9 CM10 CM13 CM15-CM18 CM20 CM21 CM23 CM30 CM32-CM36 CM70 CM98 CM99 CN9 CN23-CN25 CT37 CT38 CT50-CT53 CT81 CT82 CT88 CT94-CT97 CT101 CT103 CT104 CU4 CU5 CU7 CU12 CU13 CU16-CU21 CU26 CU28-CU31 CU34 CU35 CU38 CU39 CU45-CU48 CV9 CV15 CV17 CV19 CV20 CV34 CV372-CV375 CV436-CV438 CV484 CV1056 CX1 CX2 PC1-PC4 PC6-PC9 PC11-PC13 PC100 PC103 PC105-PC107 PC115 PC200 PC201 PC208 PC210 PC211 PC213 PC214 PC216-PC218 PC300-PC302 PC309-PC311 PC500-PC503 PC505-PC538 PC540 PC546 PC547 PC549 PC554 PC555 PC557 PC562 PC563 PC566 PC571-PC573 PC578 PC579 PC581 PC582 PC588-PC590 PC594 PC701-PC704 PC708 PC709 PC715-PC724 PC726 PC727 PC801-PC803 PC806 PC807 PC809 PC811 PC820 PC1019 PC1036-PC1041 PC1045-PC1096 PC1112-PC1122 PC1301 PC5002 PC5005-PC5011 PC5013-PC5026 PC6101-PC6104 PC6109-PC6114 PC6117-PC6121 PC6201-PC6204 PC6209-PC6215 PC6300-PC6358 PC6364-PC6369 PC8201 PC8202 PC8205 PC8209 PC8211 PC8215-PC8222 = C_0402
C256 C257 C260-C262 C264 C266 C267 C269 C2512-C2515 CA3 CA5 CA7 CA9 CA14 CA17 CA29 CA31-CA33 CA52 CA55 CA61 CA67-CA70 CA79 CA82 CD5-CD10 CD13-CD15 CD17 CD23-CD28 CD35 CD70-CD73 CD84-CD90 CE22 CG5 CG6 CG11 CG12 CG14 CG20 CG21 CG42 CG43 CG62 CG63 CG80-CG82 CG97-CG99 CG115-CG117 CG132-CG134 CG150-CG152 CG167-CG169 CG183-CG191 CG216-CG228 CG231 CG243 CG245 CG288-CG290 CG311 CG320 CG324 CG344 CG364 CG388-CG390 CG404-CG406 CG420-CG422 CH52 CH53 CH102-CH104 CH118-CH128 CL14 CL15 CL22 CM12 CM14 CM19 CM29 CM31 CT73-CT75 CT90-CT93 CT98-CT100 CT106 CU3 CU11 CU27 CU32 CU33 CU42 CU44 CV14 CV18 CV1068 PC10 PC14 PC101 PC109-PC112 PC204 PC207 PC212 PC305 PC308 PC504 PC541 PC548 PC550 PC556 PC558 PC564 PC567 PC570 PC574 PC580 PC586 PC587 PC591 PC593 PC596-PC599 PC707 PC710 PC711 PC725 PC804 PC805 PC808 PC810 PC812-PC819 PC1020-PC1035 PC1300 PC1303-PC1307 PC5003 PC6100 PC6107 PC6108 PC6125 PC6126 PC6200 PC6207 PC6218 PC6379-PC6387 PC6392-PC6414 PC8200 PC8206 PC8212 = C_0603
CA42-CA46 CA48 CA50 CA51 CC1-CC24 CG1 CG8-CG10 CG16 CG22 CG25-CG36 CG246 CG293 CG294 CG301-CG307 CG438-CG440 CG444 CG483 CH201-CH217 CM62-CM69 CT1-CT16 CT18 CT21 CT23-CT36 CT39-CT49 CT54-CT72 CT77-CT80 CT83-CT86 CT102 CT108-CT113 CV1-CV4 CV6-CV8 CV11-CV13 CV23-CV33 CV35 CV416-CV435 CV1057-CV1064 CV1069 PC1042-PC1044 PC1097-PC1111 PC1123-PC1238 = C_0201
CA47 CA49 CG242 = C_D2E
CD11 CD33 PC1000 PC1008-PC1010 = C_EEFSS0D221R
CF4 CF5 CG7 CG24 CG55 CG232 CG239 CG247 CH129-CH132 CH177 CH178 CH181 CH182 CH184 CL40 CM11 CU2 CU10 CU37 CV5 CV10 CV21 PC102 PC104 PC113 PC114 PC202 PC203 PC205 PC206 PC303 PC304 PC543-PC545 PC551-PC553 PC559-PC561 PC565 PC568 PC569 PC575-PC577 PC583-PC585 PC592 PC705 PC706 PC712-PC714 PC800 PC1003-PC1006 PC1011-PC1016 PC1018 PC6105 PC6106 PC6115 PC6116 PC6130-PC6135 PC6205 PC6206 PC6219-PC6221 PC6359-PC6362 PC6370-PC6378 PC8203 PC8204 PC8213 PC8214 = C_0805
CG244 PC6129 PC6363 PC6388-PC6391 PC6415 = C_D1
CL30 = C_1808
CLRP1 = SHORTPADS: User Part Number: PART#
CPU1 = SKL-H_BGA_1440P-T
CU6 CU40 CU43 = C_B15G
DA1 = BAT54C-7-F_SOT23-3
DA2 DA3 = BAT54AW_SOT323-3
DA4-DA8 = AZ5125-02SPR7G_SOT23-3
DE1 DF1 DF2 DU8 DU9 = SDMK0340L-7-F_SOD323-2
DE2-DE4 DH1 DV1 = RB751V-40_SOD323-2
DG1 = BAT54A-7-F_SOT23-3
DG2-DG4 DG6-DG9 = RB751S40T1G_SOD523-2
DT1 DV12 DV13 = SDM10U45-7_SOD523-2
DT2-DT9 DT11-DT14 = ESD108-B1-CSP0201_WLL-2-1-2
DT10 DU2 DU5 = TVWDF1004AD0_DFN9
DT15 = PESD24VS2UT_SOT23-3
DU1 DU4 DU11 = L30ESDL5V0C3-2_SOT23-3
DU12 DU13 = L05ESDL5V0NA-4_SLP2510P8-10-9
DU20 DU21 = PSOT24C_SOT23-3
DV2 = L03ESDL5V0CG3-2_SOT-523-3
DV4 PD2 PD3 = TVNST52302AB0_SOT523-3
FD1-FD4 = FIDUCIAL_C40M80
FV2 FV3 = F_SPR-P110
H1-H7 = H_3P8
H8-H18 H20 H22 H23 = H_2P8-G
H19 = H_2P4X2P8
H21 = H_2P9-G
H24 = H_2P6-G
H25 = H_2P8X3P3
H26 = H_3P2X2P7
H27 = H_5P5
H28 H29 = H_3P2
H30 = H_3P1X3P5
H31-H34 = H_5P0N
J4-J6 PJP801 PJP803 PJP1300 PJP1301 = JUMP_43X79
JACK1 JACK2 = YUQIU_PJ741-F07J1BE-C_6P-T
JCDRA = TE_2260531-1_46P-T
JDIMM1 = DEREN_40-42271-26001RHF_260P-T
JDIMM2 = DEREN_40-42261-26001RHF_260P-T
JDP = ACON_MAR2F-20K1800_20P
JEC = ACES_50521-0084N-P01_8P
JEDP = ACES_50473-0400M-002_40P-T
JELC = AMPHE_G846A06201EU_6P-T
JFAN1 JFAN2 = CVILU_CI1804M1VRA-NH_4P
JHDMI = ACON_HMRA3-AK1L0C_19P
JKB = ACES_51522-03001-P01_30P
JKBBL = ACES_51522-02001-P02_20P
JLAN = SDAN_601029-013231_13P
JLOGO = ACES_50228-01071-001_10P
JP1 JP2 PJ800 PJP103 PJP202 PJP203 PJP301 PJP504 PJP700 PJP802 PJP8200 = JUMP_43X39
JPCMC = INTEL_CMC_PRIMARY_36P-T
JPWR = ACES_85203-0602N-10_6P
JRTC1 = ACES_50271-00201-001_2P
JSPK = ACES_50278-00601-001_6P-T
JSSD1 JSSD2 = LCN_DAN05-67406-0103_75P-T
JTAG = ACES_50228-0067N-001_6P
JTP = ACES_51522-01601-P01_16P
JUSB1 = SDAN_608015-010232_10P
JUSB2 = TAITW_PUBAUE-09FLBS1FF4H0_9P-T
JUSBC1 JUSBC2 = JAE_DX07S024JJ2_24P-T
JWDB = ACES_50207-00471-P01_4P-T
JWLAN = LCN_DAN05-67306-0102_67P
LA3-LA5 LL1 = MURAT_BLM15AG121SN1D_L0402_2P
LA6 = MURAT_BLM15BB221SN1D_2P
LA7 LA8 LA11 LA12 = MURAT_BLM15BD601SN1D_2P
LA9 LA10 = KC_FBMA-L10-160808-800LMT_2P
LA50-LA53 = MURAT_BLM15PX121SN1D_2P
LE1 LE2 = KC_FBMA-L11-160808-800LMT_2P
LG1-LG6 = CHILI_PBY160808T-300Y-N_2P
LM1 LT2 LT3 LU1-LU11 LV2 = INPAQ_MCM1012B900F06BP_4P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LV3-LV6 = INPAQ_HCM1012GH900BP_4P-NPM
LX1-LX8 = CHILI_PBY100505T-300Y-N_2P
PBATT1 = ACES_50493-0110N-001_11P
PC108 PC118 PC209 PC215 PC306 PC307 PC1001 PC1002 PC1007 PC1017 PC8207 PC8208 = C_D2
PC539 PC542 PC5012 PC6122-PC6124 PC6217 = C_EEFCX1E330R
PD1 = TP0610K-T1-E3_SOT23-3
PD5 PD100 = BAS40CW_SOT323-3
PD101 = LL4148_LL34-2
PD700 = BAT54CW_SOT323-3
PH1 PH500-PH504 PR2-PR4 PR6 PR8 PR9 PR12-PR14 PR16 PR19 PR21-PR26 PR28 PR101-PR107 PR113 PR115 PR116 PR201 PR205-PR207 PR209 PR210 PR212-PR215 PR301 PR303 PR306-PR308 PR500-PR503 PR505 PR508 PR512-PR519 PR521 PR522 PR524 PR525 PR527-PR551 PR553 PR558-PR562 PR568-PR572 PR578-PR582 PR587-PR589 PR596-PR599 PR700 PR701 PR709-PR711 PR714-PR716 PR718 PR719 PR722-PR726 PR728-PR734 PR801 PR802 PR804 PR805 PR808 PR810-PR812 PR820 PR821 PR823 PR1300 PR1302 PR1304 PR1305 PR5004 PR5008 PR5011 PR5012 PR5014-PR5016 PR5019-PR5033 PR6102 PR6103 PR6107 PR6109 PR6112 PR6113 PR6115 PR6117-PR6120 PR6125-PR6128 PR6132 PR6133 PR6201 PR6202 PR6205 PR6207 PR6210 PR6211 PR6213-PR6217 PR6222-PR6225 PR6228-PR6230 PR8201 PR8202 PR8204 PR8206 PR8208 PR8209 PR8211 PR8215 PR8217 PR8220 PR8221 R144-R147 R150 R154 R174 R179-R181 R307 R325 R363 R365 R367 RA2 RA9 RA10 RA12 RA13 RA15-RA18 RA22 RA24 RA27 RA29-RA37 RA42 RA43 RA50 RA52 RA53 RA58 RA59 RA61-RA67 RA70 RA73-RA82 RC2 RC9 RC30 RC35 RC62 RC63 RC65 RC66 RC348 RC353-RC355 RD35 RE1 RE2 RE7-RE17 RE20 RE21 RE23 RE25-RE32 RE37 RE40 RE42-RE44 RE63 RE64 RE66 RE70 RE74-RE76 RE79 RE83-RE85 RE89 RE91 RE100 RE101 RE153-RE158 RE530 RE639 RE642-RE645 RE647 RE650 RE651 RF1-RF6 RG11 RG12 RG17-RG20 RG23 RG36-RG38 RG47-RG71 RG74-RG95 RG98 RG99 RG101-RG134 RG137 RG138 RG146-RG149 RG509-RG515 RG523-RG528 RG541-RG545 RG549 RG550 RG555-RG557 RG562 RH1 RH2 RH4 RH5 RH9 RH16 RH38 RH39 RH57-RH59 RH70-RH73 RH75 RH78 RH79 RH83-RH85 RH88-RH90 RH104 RH109 RH111 RH135 RH148-RH156 RH158 RH163-RH167 RH184-RH187 RH192 RH193 RH197 RH199 RH201 RH203 RH206 RH207 RH209-RH212 RH453 RH460-RH463 RH466 RH469 RH472 RH484 RH485 RH489 RH493-RH497 RH501 RH502 RH506 RH512 RH513 RH515 RH516 RH518 RH519 RH521 RH525 RH531 RH533 RH545 RH571 RH580 RH581 RH584 RH585 RL1-RL5 RL8-RL15 RM5 RM6 RM17 RM18 RM20 RM21 RM25 RM27-RM29 RM31 RM38 RM41 RM42 RM61 RM89-RM94 RM96-RM100 RN5 RN16 RT5 RT19 RT25 RT48-RT51 RT75 RU1-RU7 RU14-RU21 RU23 RV9 RV12 RV13 RV18-RV24 RV27-RV30 RV33 RV34 RV500-RV503 RV622-RV631 RV634 RV635 RV638-RV643 RV645 RV646 RV648-RV653 RV655 RV659 RV664 RV665 RV673 RV674 RX1 RX2 RX4-RX8 = R_0402
PJP100-PJP102 PJP104 PJP200 PJP201 PJP300 PJP302 PJP505 PJP8201 PJP8202 = JUMP_43X118
PJPDC1 = ACES_51202-00901-001_9P-T
PL1 PL3-PL5 = CHENG_SMB3025500YA_2P
PL2 = MURAT_BLM15HG601SN1D_2P
PL101 PL102 PL201 PL300 PL8200 PL8201 = L_7X7X3_M_2P
PL500 = KC_FBMA-L11-453215800LMA90T_2P
PL501-PL503 PL505 PL506 = CYNTE_PCME064T-R15MS0R667_2P
PL508 = CYNTE_PCMB053T-R47MS_2P
PL509 PL800 = CYNTE_PCMB042T-1R0MS_2P
PL700 = CYNTE_PCMB104T-2R2MS_2P
PL801 = TOKO_1239AS-H-1R0M-P2_2P
PL6100 PL6101 PL6200 = L_10X10X4_M
PQ2 = RHU002N06_SOT323-3
PQ3 QV1 = SI3457CDV-T1-GE3_TSOP6
PQ4 PQ8 PQ700 PQ705 Q2410 = SSM3K7002FU_SC70-3
PQ7 = FDV301N_NL_SOT23-3
PQ100 PQ102 PQ706 = AON7518_DFN8-5
PQ101 PQ103 = AON7534_DFN3X3-8-5
PQ200 PQ300 = AON7408L_DFN8-5
PQ201 PQ301 PQ703 = AON7506_DFN33-8-5
PQ202 PQ710 PQ8202 QG6 QG7 QG501-QG505 QG507 QG509 QV96 QV97 = 2N7002DW-7-F_SOT363-6
PQ701 PQ702 PQ707 = MDU1512RH_POWERDFN56-8-5
PQ704 = AON6414AL_DFN8-5
PQ6100-PQ6103 PQ6200 PQ6201 PQ8200 PQ8201 = AON6970_DFN5X6D-8-7
PR17 PR100 PR112 PR114 PR208 PR211 PR300 PR504 PR506 PR507 PR509-PR511 PR520 PR523 PR526 PR552 PR556 PR563 PR566 PR573 PR576 PR585 PR590 PR591 PR594 PR703 PR704 PR717 PR720 PR721 PR727 PR807 PR813 PR1301 PR5001 PR5006 PR5007 PR5017 PR5018 PR5034 PR6108 PR6110 PR6122 PR6123 PR6208 PR6219 PR6220 PR8214 PR8216 PR8219 R185 R368 RA19 RA25 RA51 RA55 RA56 RD5 RD28-RD30 RD38 RD40 RE78 RT53 RT97 RV47 RV81 RV618 RV619 = R0402_0OHM
PR108 PR109 PR200 PR203 PR204 PR302 PR554 PR557 PR564 PR567 PR574 PR577 PR583 PR586 PR592 PR595 PR705 PR706 PR708 PR803 PR806 PR809 PR5003 PR5005 PR5010 PR6104 PR6105 PR6203 PR8200 PR8205 PR8207 RA1 RA4-RA7 RH6 RH7 = R_0603
PR110 PR111 PR202 PR305 PR555 PR565 PR575 PR584 PR593 PR707 PR713 PR5002 PR5009 PR8203 PR8210 = R_1206
PR702 PR712 = R_1206_4P-D
PR6100 PR6101 PR6200 = RL-3264-9W-R005-FNH_2512_2512
PR6129 PR6130 PR6226 RA57 RA60 = R_0805
PT1-PT6 T2 T6 T7 T9-T13 T19 T21 T41 T43 T44 T62-T71 T73-T76 T81 T82 T85 T88 T89 T112-T114 T120-T122 TC24 = TPC12
PU100 = TPS51225CRUKR_QFN20_3X3-S
PU201 = RT8207PGQW_WQFN20_3X3-S
PU300 = TPS51212DSCR_SON10_3X3-S
PU500 = ISL95855HRTZ-T_TQFN48_6X6-S
PU502-PU504 PU507 PU510 = SIC632CDT1GE3_POWERPAK31_5X5
PU509 PU800 = SY8286RAC_QFN20_3X3
PU511 = SIC531CDT1GE3_POWERPAK22_4X3
PU700 = BQ24780RUYR_WQFN28_4X4-S
PU802 = RT8061AZQW_WDFN10_3X3
PU1300 = RT9059GSP_SO8
PU6100 PU6200 = NCP81278MNTXG_QFN20_3X3
PU8200 = RT8812AGQW_WQFN20_3X3-S
Q7-Q9 = DMN65D8LDW-7_SOT363-6
Q28 Q29 Q34 QE1 QE3 QE4 QE13 QE21 QE22 QE49-QE53 QE57 QG500 QH5 QM2 = DMN66D0LDW-7_SOT363-6
Q2407 Q2408 Q2411 QX2 QX3 = MMST3904-7-F_SOT323-3
Q2409 = SI3456DDV-T1-GE3_TSOP6
QE2 QE5 QG5 QU1 QV2 = 2N7002W-T-R7_SOT323-3
QE8 QM1 QM3 = SI2301CDS-T1-GE3_SOT23-3
QE29 QE39-QE48 = MMDT3904-7-F_SOT363-6
QE54-QE56 = BC857BS_SOT363-6
QG2-QG4 QG506 QG510 QG511 = MESS138W-G_SOT323-3
QL3 = 2N7002K_SOT23-3
QX1 = BSS138-G_SOT23-3
R2 RA3 RA8 RA11 RA68 RA69 RE24 = R0603_0OHM
RA21 RA26 RA28 RA40 RA41 RA44 RA45 RA85 RE92-RE95 RE396-RE401 RE449 RE451-RE510 RE512 RE513 RE531-RE547 RE640 RE641 RG1-RG3 RG6-RG9 RG13-RG16 RG21 RG22 RG24-RG26 RG150 RG151 RG500-RG506 RG516-RG519 RG522 RG529 RG535-RG539 RG546 RG551-RG554 RG558 RG559 RG561 RG563-RG570 RH23-RH26 RH537 RM14 RM23 RM26 RM62 RM64 RM66 RM70 RM72 RM75 RM76 RM79 RM81 RM82 RM84-RM87 RN15 RN17 RT2-RT4 RT6-RT9 RT11 RT12 RT14 RT16-RT18 RT20-RT22 RT24 RT26-RT47 RT57 RT58 RT61-RT73 RT76-RT80 RT83 RT86 RT94 RT102 RT107-RT109 RU24-RU26 RV1 RV8 RV15-RV17 RV45 RV600 RV669-RV672 RX31-RX38 = R_0201
RA38 RA39 RA46 RA47 RA84 RE646 RT1 RT10 RT13 RT15 RT23 RT59 RT60 RT74 RT98-RT101 = R0201_0OHM
RA83 RH12 RT95 = R0805_0OHM
RP2 RP3 RP5 RPH5 RPH6 RPT1 = RP_0804_8P4R
SW1 SW2 = SW_TST71-N-220-T170-S017_2P
TL1 = MHPC_NS692417_24P
U16 U19 U20 UG14 = TPS22961DNYR_WSON8
U17 UG12 = TPS22966DPUR_SON14_2X3
U18 UE9 UU3 UV17 = SY6288C20AAC_SOT23-5
U2407 = F75305M_MSOP10
UA1 = ALC3266-CG_QFN56_7X7-S
UA2 UA3 = MAX9892ERTLFT_UCSP_6P
UA4 = ALC1309-CG_QFN56_7X7-S
UC1 = 74AUP1G07GW_TSSOP5
UE1 = C8051F347-GQ_LQFP32_7X7
UE2 = EN25F80-75HCP_SO8
UE3 UE4 = TLC59116FIRHBR_VQFN32_5X5-S
UE5 = KB9022QD_LQFP128_14X14
UE6 UE10 = KC3810_QFN24_4X4-S
UE7 UL2 = SY6288D20AAC_SOT23-5
UG1-UG6 = H5GQ1H24AFR-T2L_BGA_170P
UG9 = N17E-G1_BGA_2152P
UG10 UG22 UG26 UG28 UG29 UX1 UX2 = NL17SZ08DFT2G_SC70-5
UG11 = INA3221AIRGVR_VQFN16_4X4-S
UG13 UG15 = W25Q80EWSSIG_SO8
UG16 = PI5A3158BZAEX_TDFN12_1X3
UG23 UG24 = BSS138DW_SC88-6
UG25 UG27 = 74LVC1G32GW_TSSOP5
UH1 = SKY-S-PCH_BGA_837P-T
UH3 UM3 UM7 = TC7SH08FU_SSOP5
UH4 = W25Q128FVSIQ_SO8
UH5 = S-5711ACDL-M3T1S_SOT23-3
UL1 = E2201-BL3A-R_QFN40_5X5-S
UM4 = PI6CEQ20200LIEX_TSSOP20
UM8 = DS80PCI402_WQFN54_10X5P5-S
UT1 = ALPINE-RIDGE_BGA_337P
UT2 = W25Q80DVSSIG_SO8
UT4 = TPS65982_BGA_96P
UU1 = TPS2540RTER_QFN16_3X3-S
UU5 = TC7SZ14FU_SSOP5
UU7 = TPS25810RVCR_QFN20_4X3-S
UV3 UV22 = SN74CBT3257CPWR_TSSOP16
UV21 = PS8331BQFN60GTR-A0_QFN60_5X9-S
UZ21 = APE8937GN2_DFN8_2X2
YG1 = Y_5YEA27000163IF50Q5_4P
YH1 = Y_CM31532768DZFT_2P
YH2 = Y_X3G024000DC1H_4P
YL1 = Y_FSX3M-25PM20FDO_4P
YT1 = Y_7V25000012_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74LVC1G32GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50228-01071-001_10P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0) 7(-6,0) 8(-7,0) 9(-8,0) 10(-9,0)
  rect 1.194x1.803 smd: 11(-10.3,2.525) 12(1.3,2.525)
ACES_50271-00201-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50278-00601-001_6P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0)
  rect 1.295x3.353 smd: 7(-2.85,-4.925) 8(9.1,-4.925)
ACES_50473-0400M-002_40P-T
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.559x1.092 smd: 41(-0.9,0) 42(20.4,0)
  rect 1.397x1.905 smd: 43(22.6,-2.92) 44(-3.1,-2.92)
ACES_50493-0110N-001_11P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
ACES_50521-0084N-P01_8P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0)
  rect 0.406x0.787 smd: 9(1,-2.65) 10(-4.5,-2.65)
ACES_51202-00901-001_9P-T
  rect 0.66x5.004 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0)
  rect 2.489x2.997 smd: 10(-2.5,-4.45) 11(14.5,-4.45)
ACES_51522-01601-P01_16P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0)
  rect 2.489x1.905 smd: 17(-2.15,-3.3) 18(9.65,-3.3)
ACES_51522-02001-P02_20P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 2.489x1.905 smd: 21(-2.15,-3.3) 22(11.65,-3.3)
ACES_51522-03001-P01_30P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 2.489x1.905 smd: 31(-2.15,-3.3) 32(16.65,-3.3)
ACES_85203-0602N-10_6P
  oval 0.61x1.854 smd: 1(0,0) 3(1,0) 5(2,0) 7(3,0) 9(4,0) 11(5,0)
  oval 0.61x1.651 smd: 2(0,-3.75) 4(1,-3.75) 6(2,-3.75) 8(3,-3.75) 10(4,-3.75) 12(5,-3.75)
ACON_HMRA3-AK1L0C_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-2.75,1.7) 21(-4.65,-6.5) 22(11.75,1.7) 23(13.65,-7.75)
ACON_MAR2F-20K1800_20P
  round 1.194 hole 1.194 unplated: (-6.95,-0.5) (1.55,-0.5)
  round 0.813 hole 0.508: 1(0,0) 3(-0.6,-1.2) 5(-1.1,0) 7(-1.7,-1.2) 9(-2.2,0) 11(-3.2,0) 13(-3.7,-1.2) 15(-4.3,0) 17(-4.8,-1.2) 19(-5.4,0)
  oval 0.406x1.88 smd: 2(0,-2.995) 4(-0.6,-2.995) 6(-1.2,-2.995) 8(-1.8,-2.995) 10(-2.4,-2.995) 12(-3,-2.995) 14(-3.6,-2.995) 16(-4.2,-2.995) 18(-4.8,-2.995) 20(-5.4,-2.995)
  oval 1.194x2.261 hole 0.711x1.753: 21(-8.2,2.96) 22(-8.2,-2.04) 23(2.8,2.96) 24(2.8,-2.04)
ALC1309-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALC3266-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AMPHE_G846A06201EU_6P-T
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,1.45) 8(5.3,1.45)
AON6414AL_DFN8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
AON6970_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7408L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7506_DFN33-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7518_DFN8-5
  oval 0.356x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.4)
AON7534_DFN3X3-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40CW_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54A-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54AW_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54C-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BC857BS_SOT363-6
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
BQ24780RUYR_WQFN28_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
BSS138-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BSS138DW_SC88-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
C8051F347-GQ_LQFP32_7X7
  oval 0.457x1.753 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 17(5.6,8.654) 18(4.8,8.654) 19(4,8.654) 20(3.2,8.654) 21(2.4,8.654) 22(1.6,8.654) 23(0.8,8.654) 24(0,8.654)
  oval 1.753x0.457 smd: 9(7.127,1.527) 10(7.127,2.327) 11(7.127,3.127) 12(7.127,3.927) 13(7.127,4.727) 14(7.127,5.527) 15(7.127,6.327) 16(7.127,7.127) 25(-1.527,7.127) 26(-1.527,6.327) 27(-1.527,5.527) 28(-1.527,4.727) 29(-1.527,3.927) 30(-1.527,3.127) 31(-1.527,2.327) 32(-1.527,1.527)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_B15G
  rect 1.6x2.692 smd: 1(0,0) 2(3,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D2E
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_EEFCX1E330R
  rect 2.388x2.794 smd: 1(0,0) 2(-6.4,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CHENG_SMB3025500YA_2P
  rect 2.997x1.803 smd: 1(0,0) 2(4,0)
CHILI_PBY100505T-300Y-N_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CVILU_CI1804M1VRA-NH_4P
  oval 0.508x0.991 smd: 1(0,-0.05) 2(-0.8,-0.05) 3(-1.6,-0.05) 4(-2.4,-0.05)
  rect 1.194x1.702 smd: 5(-3.7,1.4) 6(1.3,1.4)
CYNTE_PCMB042T-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCMB053T-R47MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PCMB104T-2R2MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYNTE_PCME064T-R15MS0R667_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
DEREN_40-42261-26001RHF_260P-T
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,-16.1) 262(-67.175,-16.1)
DEREN_40-42271-26001RHF_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,-7.9) 262(67.175,-7.9)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DS80PCI402_WQFN54_10X5P5-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 28(8.5,5.6) 29(8,5.6) 30(7.5,5.6) 31(7,5.6) 32(6.5,5.6) 33(6,5.6) 34(5.5,5.6) 35(5,5.6) 36(4.5,5.6) 37(4,5.6) 38(3.5,5.6) 39(3,5.6) 40(2.5,5.6) 41(2,5.6) 42(1.5,5.6) 43(1,5.6) 44(0.5,5.6) 45(0,5.6)
  oval 0.889x0.254 smd: 19(9.3,0.8) 20(9.3,1.3) 21(9.3,1.8) 22(9.3,2.3) 23(9.3,2.8) 24(9.3,3.3) 25(9.3,3.8) 26(9.3,4.3) 27(9.3,4.8) 46(-0.8,4.8) 47(-0.8,4.3) 48(-0.8,3.8) 49(-0.8,3.3) 50(-0.8,2.8) 51(-0.8,2.3) 52(-0.8,1.8) 53(-0.8,1.3) 54(-0.8,0.8)
  rect 7.493x3.505 smd: 55(4.25,2.8)
E2201-BL3A-R_QFN40_5X5-S
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.975) 22(3.2,4.975) 23(2.8,4.975) 24(2.4,4.975) 25(2,4.975) 26(1.6,4.975) 27(1.2,4.975) 28(0.8,4.975) 29(0.4,4.975) 30(0,4.975)
  oval 1.016x0.203 smd: 11(4.288,0.688) 12(4.288,1.088) 13(4.288,1.488) 14(4.288,1.888) 15(4.288,2.288) 16(4.288,2.688) 17(4.288,3.088) 18(4.288,3.488) 19(4.288,3.888) 20(4.288,4.288) 31(-0.688,4.288) 32(-0.688,3.888) 33(-0.688,3.488) 34(-0.688,3.088) 35(-0.688,2.688) 36(-0.688,2.288) 37(-0.688,1.888) 38(-0.688,1.488) 39(-0.688,1.088) 40(-0.688,0.688)
  rect 3.302x3.302 smd: 41(1.8,2.488)
EN25F80-75HCP_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
ESD108-B1-CSP0201_WLL-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
F75305M_MSOP10
  oval 0.254x1.626 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,4.3) 7(1.5,4.3) 8(1,4.3) 9(0.5,4.3) 10(0,4.3)
  rect 1.6x1.727 smd: 11(1,2.15)
F_SPR-P110
  rect 0.991x1.499 smd: 1(0,0) 2(2.2,0)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
H5GQ1H24AFR-T2L_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_2P4X2P8
  oval 2.896x3.302 hole 2.388x2.794: 1(0,0)
H_2P6-G
  round 3.099 hole 2.591: 1(0,0)
H_2P8-G
  round 3.302 hole 2.794: 1(0,0)
H_2P8X3P3
  oval 3.302x3.81 hole 2.794x3.302: 1(0,0)
H_2P9-G
  round 3.404 hole 2.896: 1(0,0)
H_3P1X3P5
  oval 3.607x4.013 hole 3.099x3.505: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P2X2P7
  oval 3.708x3.2 hole 3.2x2.692: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_5P0N
  round 5.004 hole 5.004 unplated: (0,0)
H_5P5
  round 6.02 hole 5.512: 1(0,0)
INA3221AIRGVR_VQFN16_4X4-S
  oval 0.457x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 9(1.95,3.95) 10(1.3,3.95) 11(0.65,3.95) 12(0,3.95)
  oval 1.041x0.457 smd: 5(2.95,1) 6(2.95,1.65) 7(2.95,2.3) 8(2.95,2.95) 13(-1,2.95) 14(-1,2.3) 15(-1,1.65) 16(-1,1)
  rect 2.108x2.108 smd: 17(0.975,1.975)
INPAQ_HCM1012GH900BP_4P-NPM
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INTEL_CMC_PRIMARY_36P-T
  round 0.889 hole 0.889 unplated: (-0.876,-0.658) (0.774,-6.054)
  round 0.368 smd: 1(0,0) 2(0.477,-0.275) 3(0.885,0.093) 4(1.268,-0.302) 5(1.763,-0.062) 6(2.021,-0.547) 7(2.563,-0.452) 8(2.677,-0.99) 9(3.224,-1.048) 10(3.186,-1.596) 11(3.696,-1.803) 12(3.509,-2.32) 13(3.942,-2.659) 14(3.619,-3.104) 15(3.942,-3.549) 16(3.509,-3.888) 17(3.696,-4.405) 18(3.186,-4.611) 19(3.224,-5.16) 20(2.677,-5.218) 21(2.563,-5.756) 22(2.021,-5.661) 23(-0.491,-5.652) 24(-1.034,-5.743) 25(-1.145,-5.205) 26(-1.691,-5.143) 27(-1.649,-4.595) 28(-2.157,-4.385) 29(-1.966,-3.869) 30(-2.397,-3.527) 31(-2.071,-3.084) 32(-2.391,-2.637) 33(-1.955,-2.301) 34(-2.139,-1.782) 35(-1.631,-1.578)
  round 4.597 hole 2.286: 36(0.774,-3.104)
ISL95855HRTZ-T_TQFN48_6X6-S
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
JAE_DX07S024JJ2_24P-T
  round 0.61 hole 0.61 unplated: (-0.975,-2.7)
  oval 0.838x0.508 hole 0.838x0.508 unplated: (6.225,-2.635)
  oval 1.295x2.591 hole 0.711x2.007: 1(-1.695,-5.75) 3(6.945,-5.75)
  oval 1.194x2.311 hole 0.61x1.905: 2(-1.695,-0.7) 4(6.945,-0.7)
  oval 1.651x1.092 hole 1.245x0.711: 5(-1.37,-1.3) 6(6.62,-1.3)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KB9022QD_LQFP128_14X14
  oval 1.753x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.203x1.753 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
