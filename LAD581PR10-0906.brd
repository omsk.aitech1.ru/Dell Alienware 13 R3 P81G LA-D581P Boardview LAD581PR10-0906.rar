# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VALW_LED: length 203.8
  TOP w0.508: QE8.1 112.41,13.79 v1(113.58,14.97) 115.06,16.45 116.89,16.45 v2(118.12,17.68) ; JPWR.2 173.66,162.47 172.58,163.55 UE7.1
  IN3 w0.508: v2(174.24,158.62) 174.26,158.63 v2(174.26,159.82)
  IN4 w0.508: v2(174.24,158.62) 173.62,157.99 173.62,155.87 173.11,155.36 173.11,153.59 172.4,152.87 171.08,152.87 170.83,153.12 167.21,153.12 166.89,152.81 166.89,150.46 166.64,150.2 164.23,150.2 163.5,149.47 163.5,146.17 168.92,140.74 168.92,101.5 170.14,100.28 170.14,92.87 168.86,91.59 162.38,91.59 159.91,89.11 157.37,89.11 151.14,82.89 151.14,75.61 149.94,74.4 149.94,71.05 147.78,68.9 147.78,65.12 145,62.34 140.22,62.34 135.9,58.02 135.9,50.27 136.54,49.64 136.54,42.97 135.52,41.95 135.52,37.89 134.76,37.13 134.76,29.7 133.55,28.49 133.55,26.97 129.11,22.52 122.7,22.52 118.12,17.94 v2(118.12,17.68)
+5VALWP: length 45.6
  IN1 w0.254: v2(39.01,17.84) 38.65,18.2 33.41,18.2 32.4,19.22 32.4,24.43 31.06,25.76 v2(29.81,25.76)
  IN1 w0.508: v2(36.91,27.15) 35.94,27.15 35.11,26.31 32.59,26.31 31.74,27.17 29.83,27.17 29.16,26.5 29.16,25.42 28.49,24.76 28.49,24.12 29.48,23.14 29.48,18.12 29.99,17.61 35.27,17.61 36.16,16.72 38.11,16.72 v2(38.68,17.3)
  BOTTOM w0.203: v2(36.91,27.15) PU100.14 ; v1(38.68,16.59) v2(38.68,17.3)
  BOTTOM w0.254: v2(29.81,25.76) 30.16,25.76 PR102.2
  vias: v2(39.32,17.3) v2(39.64,17.81) v2(40.02,17.3) v2(40.33,17.81) v2(40.65,17.3) v2(40.97,17.81) v2(41.29,17.3) v2(41.6,17.81) v2(41.92,17.3) v2(42.24,17.81) v2(42.56,17.3) v2(42.87,17.81)
+5VS: length 870.6
  TOP w0.508: v2(136.85,136.19) 136.85,134.22 137.15,133.92 PR5011.2 137.85,133.92 138.41,133.36 PR5029.1 ; PR505.1 94.42,127.42 94.76,127.09 v2(94.76,126.71) ; PR5032.1 121.79,133.35 121.14,134 PR5023.2 120.57,134 120.22,134.35 v2(120.22,136.19) ; 150.13,138.83 150.32,138.64 163.46,138.64 164.23,137.88 164.23,118.97 v3(164.48,118.72) 164.16,118.4 164.16,106.91 162.22,104.96 162.22,102.43 160.89,101.11 160.89,89.35 164.67,85.57 164.67,76.8 165.51,75.96 165.51,70.08 164.37,68.93 CG386.1 164.71,67.72 165.15,67.27 v2(165.15,66.98) ; PR5031.1 113.46,133.36 112.91,133.91 PR5021.2 112.41,133.91 111.99,134.33 v2(111.71,134.33) ; PR5026.1 152.86,130.73 v2(154.44,132.31) ; v2(212.87,33.43) 212.74,33.55 PC6200.1 ; v2(60.15,56.78) 58.74,56.78 56.49,59.04 52.59,59.04 51.73,59.9 47.88,59.9 44.72,56.74 44.72,52.16 42.56,50 40.34,50 39.83,49.49 39.83,47.33 38.66,46.16 34.14,46.16 34.04,46.06 33.03,46.06 30.66,43.68 30.66,42.68 30.06,42.09 28.53,42.09 28.38,41.93 27.12,41.93 27.05,42 25.94,42 25.54,42.4 25.54,43.22 24.96,43.8 RA8.2 24.96,45.35 RA3.2 ; v2(128.35,136.19) 128.35,134.22 128.66,133.91 PR599.2 129.23,133.91 129.9,133.23 PR5028.1 ; PR5030.1 146.36,133.39 PR5019.2 145.5,133.95 145.11,134.35 145.11,136.12 v2(145.24,136.25) 145.24,136.7 143.34,138.59 ; PC6100.1 v2(200.1,33.55)
  TOP w1.016: v2(114.6,138.58) 115.46,138.58 116.35,139.46 122.02,139.46 122.5,138.98 v2(122.5,138.6) 124.85,138.6 125.68,139.43 130.27,139.43 v2(131.06,138.64) 131.75,138.64 132.73,139.62 138.56,139.62 ; 178.51,162.9 175.21,162.9 174.68,163.43 173.97,163.43 172.64,164.76 171.5,164.76 170.79,165.47 170.79,166.9 170.14,167.56 166.23,167.56 165.84,167.18 165.84,166.31 163.71,164.17 163.71,158.19 163.15,157.63 163.15,156.55 161.93,155.33 161.93,154.29 164.8,151.42 164.8,149.44 162.32,146.96 162.32,144.17 161.41,143.25 151.6,143.25 150.13,141.78 150.13,138.83 149.43,138.14 147.56,138.14 147.14,138.56 v2(147.13,138.56) 147.08,138.6 147.08,139.3 146.7,139.68 142.7,139.68
  IN1 w0.508: v2(187.3,56.93) 187.73,56.5 187.73,54.98 187.4,54.65 187.4,54.1 187.78,53.72 188.03,53.72 189.3,52.44 189.3,42.97 189.89,42.38 190.31,42.38 191.04,41.66 191.04,38.37 195.28,34.12 195.28,31.77 199.59,27.46 203.02,27.46 203.88,28.31 205.53,28.31 v2(206.94,29.72) ; v2(154.44,132.31) 154.57,132.44 154.57,134.41 151.8,137.18 145.66,137.18 145.24,136.76 v2(145.24,136.25) 144.73,136.25 144.25,135.77 138.16,135.77 137.74,136.19 v2(136.85,136.19) 134.95,136.19 134.57,135.81 129.93,135.81 129.55,136.19 v2(128.35,136.19) 127.27,136.19 127.14,136.06 123.39,136.06 123.01,135.68 121.87,135.68 121.36,136.19 v2(120.22,136.19) 118.63,136.19 117.28,134.83 113.12,134.83 112.61,134.33 v2(111.71,134.33)
  IN2 w0.508: v2(165.15,66.98) 166.52,65.61 169.25,65.61 175.53,59.33 176.16,59.33 177.37,58.13 177.37,57.68 177.75,57.3 178.51,57.3 178.72,57.51 183.99,57.51 184.43,57.95 186.09,57.95 187.11,56.93 v2(187.3,56.93) 187.68,56.93 188.16,57.42 188.16,63.21 190.42,65.46 191.52,65.46 194.15,68.1 v2(194.58,68.1) ; v2(206.94,29.72) 206.86,29.72 206.52,30.06 206.52,30.95 206.51,30.96 206.51,31.44 206.52,31.45 206.52,32.6 206.33,32.79 ; v2(200.1,33.55) 200.86,32.79 206.33,32.79 ; 206.33,32.79 207.21,33.68 212.61,33.68 v2(212.87,33.43)
  IN3 w0.508: 110,135.66 103.77,129.44 101.17,129.44 99.26,127.53 95.58,127.53 94.76,126.71 v2(94.76,126.71)
  IN3 w2.032: 58.89,59.96 58.89,62.79 59.76,63.66 64.32,63.66 65.67,65 66.46,65 67.36,65.9 67.36,67.44 68.53,68.6 68.53,70.95 82.25,84.67 82.25,89.81 84.85,92.41 84.85,138.73 86.11,139.99 88.97,139.99 90.04,138.92 101.21,138.92 102.06,138.07 107.71,138.07
  IN4 w0.508: 62.88,59.84 63.96,60.92 63.96,62.19 65.22,63.45 65.22,67.45 65.42,67.65 v2(65.42,68.48)
  IN4 w1.016: 218.52,23.07 219.03,23.07 219.28,23.33 219.28,27.77 219.98,28.47 221.79,28.47 223.45,30.12 225.59,30.12 229.53,34.06 229.53,35.21 235.09,40.77 240.53,40.77 249.31,49.55 253.35,49.55 255.37,51.57 255.37,55.65 258.41,58.69 258.41,66.17 256.17,68.41 252.17,68.41 248.62,71.96 248.62,76.16 243.66,81.11 243.66,91.59
  IN5 w1.016: 196.42,144.17 196.42,148.87 195.34,149.95 195.34,151.66 198.67,155 198.67,156.9 197.44,158.14 197.44,160.04 196.8,160.68 195.77,160.68 v2(194.82,161.62) 192.66,161.62 191.72,160.68 187.91,160.68 187.34,161.25 185.43,161.25 184.42,162.27
  BOTTOM w0.203: v2(200.1,33.55) 200.07,33.52 PU6100.18 ; UG12.4 v2(194.58,68.1) ; PU6200.18 213.02,33.27 v2(212.87,33.43)
  BOTTOM w0.381: PR5024.2 122.93,138.17 v2(122.5,138.6) ; v2(147.13,138.56) 147.15,138.56 147.19,138.52 147.24,138.52 147.54,138.22 PR5020.2 ; UV22.16 170.5,128.35 CV484.1 ; UV3.16 194.24,161.36 194.5,161.62 v2(194.82,161.62) 195.05,161.4 CV23.1
  BOTTOM w0.508: CV484.1 174.37,128.35 175.02,128.99 175.02,132.49 173.24,134.26 167.46,134.26 164.99,136.74 158.76,136.74 154.44,132.42 v2(154.44,132.31) 154.44,132.04 154.63,131.85 PR5025.2 ; JFAN1.4 66.18,65.11 65.79,65.11 65.22,65.68 65.22,68.27 v2(65.42,68.48) ; v2(114.6,138.58) PR5022.2 ; v2(139.21,138.52) 139.59,138.14 PR5004.2 ; v2(131.06,138.64) PR553.2
  BOTTOM w0.762: 197.44,143.28 198.45,143.28 198.71,143.53 205.56,143.53 205.75,143.72 209.75,143.72 209.88,143.85 223.28,143.85 223.72,144.3 231.34,144.3 246.64,129.01 246.64,97.04 243.66,94.07
  BOTTOM w1.016: 216.55,22.12 214.39,19.96 214.39,17.58 210.03,13.22 203.9,13.22 203.6,12.91 188.41,12.91 187.77,12.28 187.77,10.62
  vias: v2(60.15,58.06) v2(60.15,57.43) v2(60.72,57.75) v2(60.72,57.05) v2(61.23,58.06) v2(61.23,57.43) v2(61.74,57.75) v2(61.74,57.05) v2(62.24,58.06) v2(62.24,57.43) v2(62.82,57.75) v2(181.1,8.92) v2(181.71,8.92) v2(182.39,162.65) v2(182.7,161.82) v2(195.72,142.9) v2(196.23,143.28) v2(217.63,23.33) v2(217.59,22.69) v2(243.35,92.98) v2(243.93,92.96) v2(246.9,85.56) v2(247.16,84.99)
+5VS_TP_LED: length 45.1
  TOP w0.508: v2(220.5,19.14) 217.48,16.12 215.93,16.12 213.59,13.78 v2(213.59,12.58)
  TOP w1.016: 205.69,6.69 204,6.69 202.73,7.96 199.34,7.96 198.59,7.21 C2508.1
  IN1 w0.508: v2(223.29,19.2) 222.77,19.72 221.08,19.72 v2(220.5,19.14)
  BOTTOM w0.381: R150.1 220.8,16.93 221.11,17.23 221.11,18.27 220.5,18.88 v2(220.5,19.14) 220.5,19.81 R145.1 ; R144.1 224.17,19.7 223.7,19.23 223.32,19.23 v2(223.29,19.2) ; R154.1 218.72,18.52 217.81,17.6 R147.1
  BOTTOM w0.508: R150.1 220.07,17.28 220.07,17.51 219.06,18.52 R154.1 218.57,18.78 218.57,21.3 219.71,22.44 R146.1
  BOTTOM w1.016: 207.28,4.85 211.41,4.85 213.12,6.56 213.12,8.28
  vias: v2(205.75,4.72) v2(206.39,4.72) v3(205.98,5.54)
+AVDDH: length 22.3
  TOP w0.203: v2(202.44,153.12) v1(202.44,153.69)
  TOP w0.508: CL5.1 202.12,152.67 202.44,152.99 v2(202.44,153.12) 203.01,152.55 CL6.1
  IN4 w0.508: v2(202.44,153.12) 202.44,153.58 202.96,154.09 205.23,154.09 206.39,152.93 206.39,147.17 205.73,146.52 203.45,146.52 202.1,145.18 v2(201.68,145.18)
  BOTTOM w0.203: UL1.22 202.29,145.55 CL7.1 ; UL1.9 202.29,152.57 202.32,152.59 202.32,152.8 202.44,152.92 v2(202.44,153.12)
  BOTTOM w0.381: v2(201.68,145.18) 202.02,145.52 CL7.1
+AVDDL: length 15
  TOP w0.508: v2(204.28,150.37) 203.93,150.72 CL24.1 ; v2(204.28,147.97) 204.28,147.83 204.75,147.36 v1(204.75,146.8) 204.34,146.39 CL25.1 ; CL22.1 196.74,149.21 197.17,148.77 v2(197.49,148.77) 198.1,148.77 CL20.1 ; v2(201.06,153.25) 201.06,153.08 201.24,152.9 CL18.1 CL19.1 ; CL23.1 197.55,146.59 v2(197.55,147.4) 197.89,147.73 CL21.1
  BOTTOM w0.203: v2(201.06,153.25) 201.06,152.6 201.09,152.57 UL1.6 ; v2(204.28,150.37) UL1.13 ; v2(197.55,147.4) 197.72,147.57 UL1.31 ; v2(197.49,148.77) UL1.34 ; v2(204.28,147.97) UL1.19
+DVDDL: length 3.1
  TOP w0.508: CL43.1 198.32,151.36 198.32,150.21 CL44.1 197.53,150.01 v2(197.49,149.97)
  BOTTOM w0.203: v2(197.49,149.97) UL1.37
+PVDD:
  vias: v1(25.99,16.7) v2(21.25,20.46) v2(21.41,17.04) v2(21.52,21.01) v2(21.86,17.42) v2(25.27,16.86) v2(25.27,16.28) v2(26.57,16.85) v2(26.57,16.27) v2(31.6,16.28) v2(32.27,16.28)
+V18R: length 0.8
  TOP w0.203: 84.24,8.88 v1(83.43,8.88)
+VCC_CORE: length 70.5
  TOP w0.254: PR561.1 131,123.92 131.01,123.91 PR560.1 PR559.2 v2(133.17,124.84) ; v2(148.28,125.01) 148.11,124.83 PR579.2 147.55,124.83 PR580.1 PR581.1 ; PR570.1 PR571.1 139.86,124.96 PR569.2 140.36,124.96 v2(140.54,125.14)
  TOP w0.381: PC1213.1 128.33,93.1 v2(128.46,93.22)
  BOTTOM w0.203: v2(132.14,93.88) 131.8,93.55 CPU1.V14 CPU1.V13 ; v2(127.87,106.84) CPU1.AC31 ; v2(127.87,106.84) CPU1.AC30 CPU1.AC29 127.52,105.81 ; v2(127.87,106.84) CPU1.AB30 CPU1.AB29 128.24,105.81 ; v2(136.73,93.23) 137.05,93.55 CPU1.L14 ; CPU1.AD13 127.18,92.9 v2(127.51,93.22) 127.18,93.55 CPU1.AD14 ; CPU1.AE32 v2(125.51,107.48) ; CPU1.W36 v2(131.02,110.73) CPU1.W37 ; CPU1.AE14 126.31,93.55 v2(126.65,93.21) 126.34,92.9 CPU1.AE13 ; CPU1.AC32 v2(127.87,108.13) CPU1.AC33 ; CPU1.V36 v2(131.8,110.08) CPU1.V35 ; CPU1.AA34 v2(129.44,109.43) CPU1.AA35 ; CPU1.AB37 v2(128.66,111.39) CPU1.AB38 ; CPU1.AF35 v2(125.51,110.08) CPU1.AF36 ; CPU1.AB32 v2(128.66,107.48) ; v2(128.66,107.48) CPU1.AB31 ; v2(128.66,107.48) CPU1.AA31 ; CPU1.AD36 v2(127.08,110.08) ; v2(127.08,110.08) CPU1.AD35 ; v2(127.08,110.08) CPU1.AC36 ; CPU1.AA37 v2(129.44,110.73) CPU1.AA36 ; CPU1.P30 CPU1.P29 134.54,105.79 ; CPU1.N36 v2(134.95,110.08) CPU1.N35 ; v2(133.95,93.22) 134.27,92.9 CPU1.P13 ; v2(133.95,93.22) 133.62,92.9 CPU1.R13 ; v2(133.95,93.22) 134.27,93.55 CPU1.P14 ; v2(128.46,93.22) 128.78,92.9 CPU1.AA13 ; v2(128.46,93.22) 128.13,92.9 CPU1.AC13 ; v2(128.46,93.22) 128.13,93.55 CPU1.AC14 ; CPU1.T38 v2(133.38,111.39) CPU1.T37 ; CPU1.AD31 v2(127.08,107.48) CPU1.AD32 ; v2(137.7,93.01) 137.58,92.9 CPU1.L13 ; v2(137.7,93.01) 137.81,93.12 CPU1.K14 ; v2(137.7,93.01) 137.75,92.96 CPU1.K13 ; CPU1.Y31 v2(130.23,107.48) ; v2(130.23,107.48) CPU1.Y32 ; v2(130.23,107.48) CPU1.W32 ; CPU1.U36 v2(132.59,110.73) ; CPU1.N14 135.18,93.55 v2(134.84,93.21) 135.15,92.9 CPU1.N13 ; CPU1.AD33 v2(127.08,108.78) CPU1.AD34 ; 129.84,105.8 CPU1.Y29 CPU1.Y30 ; CPU1.AC34 v2(127.87,109.43) CPU1.AC35 ; CPU1.AF38 125.18,111.71 v2(125.51,111.39) 125.18,111.06 CPU1.AF37 ; CPU1.U29 CPU1.U30 v2(132.59,106.84) ; CPU1.AD38 v2(127.08,111.39) CPU1.AD37 ; CPU1.T36 v2(133.38,110.08) CPU1.T35 ; v2(130.31,93.88) 130.64,93.55 CPU1.W14 CPU1.W13 ; CPU1.V33 v2(131.8,108.78) CPU1.V34 ; CPU1.U33 v2(132.59,108.13) CPU1.U32 ; CPU1.Y36 v2(130.23,110.08) CPU1.Y35 ; CPU1.V31 v2(131.8,107.48) CPU1.V32 ; CPU1.T30 v2(132.59,106.84) ; v2(132.59,106.84) CPU1.U31 ; CPU1.R37 v2(134.17,110.73) CPU1.R36 ; CPU1.U35 v2(132.59,109.43) CPU1.U34 ; CPU1.AB36 v2(128.66,110.08) CPU1.AB35 ; v2(126.29,109.43) CPU1.AE35 ; v2(131.02,109.43) CPU1.W35 ; CPU1.AE37 v2(126.29,110.73) CPU1.AE36 ; CPU1.AA32 v2(129.44,108.13) CPU1.AA33
  BOTTOM w0.254: PL501.1 132.54,124.2 v2(133.17,124.84) ; v2(148.28,125.01) 147.9,124.63 PL503.1 ; CPU1.N30 135.41,106.46 v2(135.78,106.83) 135.45,107.16 CPU1.N31 ; CPU1.T30 CPU1.T29 ; PL502.1 140.22,124.82 v2(140.54,125.14)
  vias: v2(125.25,105.26) v2(125.5,99.99) v2(125.5,95.16) v2(125.69,98.84) v2(125.69,97.64) v2(125.88,105.26) v2(125.88,101.89) v2(126.13,99.99) v2(126.13,95.16) v2(126.29,112.04) v2(126.58,112.69) v2(126.89,113.24) v2(126.9,101.89) v2(127.21,112.69) v2(127.27,115.47) v2(127.27,114.39) v2(127.52,113.24) v2(127.59,114.91) v2(127.59,113.83) v2(127.66,105.26) v2(127.85,112.69) v2(127.9,115.47) v2(127.9,114.39) v2(127.91,99.99) v2(127.91,95.16) v2(128.04,98.84) v2(128.04,97.64) v2(128.23,114.91) v2(128.23,113.83) v2(128.16,113.24) v2(128.29,105.26) v2(128.54,115.47) v2(128.54,114.39) v2(128.48,112.69) v2(128.55,99.99) v2(128.55,95.16) v2(128.79,113.24) v2(128.86,114.91) v2(128.86,113.83) v2(129.12,112.69) v2(129.17,115.47) v2(129.17,114.39) v2(129.43,113.24) v2(129.44,112.04) v2(129.5,114.91) v2(129.5,113.83) v2(129.63,101.89) v2(129.81,115.47) v2(129.81,114.39) v2(129.75,112.69) v2(130.13,114.91) v2(130.13,113.83) v2(130.06,113.24) v2(130.07,105.26) v2(130.24,108.77) v2(130.21,106.84) v2(130.33,99.99) v2(130.33,95.16) v2(130.44,115.47) v2(130.44,114.39) v2(130.39,112.69) v2(130.39,98.84) v2(130.39,97.64) v2(130.64,101.89) v2(130.7,113.24) v2(130.71,105.26) v2(130.77,114.91) v2(130.77,113.83) v2(131.02,112.69) v2(131.02,112.04) v2(130.96,99.99) v2(130.96,95.16) v2(131.08,115.47) v2(131.08,114.39) v2(131.33,113.24) v2(131.4,114.91) v2(131.4,113.83) v2(131.71,115.47) v2(131.71,114.39) v2(131.66,112.69) v2(131.8,112.04) v2(131.8,111.39) v2(132.04,114.91) v2(132.04,113.83) v2(131.97,113.24) v2(132.35,115.47) v2(132.35,114.39) v2(132.29,112.69) v2(132.48,105.26) v2(132.6,113.24) v2(132.74,99.99) v2(132.74,98.84) v2(132.74,97.64) v2(132.71,95.16) v2(132.93,112.69) v2(133.03,93.9) v2(133.12,105.26) v2(133.12,101.89) v2(133.24,113.24) v2(133.31,119.55) v2(133.35,95.16) v2(133.38,112.04) v2(133.38,107.48) v2(133.37,99.99) v2(133.62,120.1) v2(133.56,112.69) v2(133.94,119.55) v2(133.87,113.24) v2(133.93,93.89) v2(134.14,110.1) v2(134.2,112.69) v2(134.17,109.43) v2(134.16,108.76) v2(134.17,108.13) v2(134.18,107.46) v2(134.25,120.1) v2(134.58,119.55) v2(134.89,120.1) v2(134.94,108.14) v2(134.95,112.05) v2(134.97,110.74) v2(135.09,95.16) v2(135.21,119.53) v2(135.59,118.96) v2(135.59,118.32) v2(135.59,117.69) v2(135.72,95.16) v2(135.9,119.53) v2(136.22,118.96) v2(136.22,118.32) v2(136.22,117.69) v2(136.29,95.99) v2(136.42,97.38) v2(136.92,117.69) v2(137.56,117.69) v2(138.19,117.69) v2(143.33,121.06) v2(143.35,120.44) v2(143.35,119.8) v2(143.35,119.17) v2(143.35,118.53) v2(143.91,120.77) v2(143.91,120.13) v2(143.91,119.5) v2(143.91,118.86) v2(144.48,121.09) v2(144.48,120.45) v2(144.5,119.8) v2(144.5,119.17) v2(146.32,117.26) v2(148.22,117.26) v2(150.13,117.26) v3(124.77,107.59)
+VCCGT: length 16.9
  TOP w0.254: PR598.1 124.09,124.93 PR597.2 124.68,124.93 v2(124.85,124.76) ; v2(117.3,124.88) 116.73,124.88 PR588.2 116.6,124.81 PR589.1
  BOTTOM w0.203: CPU1.BN36 104.46,110.4 v2(104.3,110.24) ; v2(112,93.86) 112.31,93.55 CPU1.BB14 ; CPU1.AN14 119.49,93.83 119.14,93.83 CPU1.AP14 ; v2(119.31,93.22) 118.99,92.9 CPU1.AP13 ; CPU1.AW14 115.33,93.55 v2(115.66,93.87) ; v2(111.09,93.22) 110.76,93.55 CPU1.BD14 110.5,93.55 v2(110.17,93.87) 109.85,93.55 CPU1.BF14 ; CPU1.AN13 119.9,92.9 v2(120.23,93.22) 120.55,93.55 CPU1.AM14
  BOTTOM w0.254: PL506.1 124.92,124.69 v2(124.85,124.76) ; PL505.1 v2(117.3,124.88)
  BOTTOM w0.508: RH203.1 121.88,113.38 v2(121.86,113.36)
  vias: v2(103.9,115.47) v2(103.9,114.88) v2(104.19,114.34) v2(104.38,113.63) v2(104.48,115.47) v2(104.48,114.88) v2(104.77,114.34) v2(104.96,113.63) v2(105.07,115.47) v2(105.07,114.88) v2(105.36,114.34) v2(105.55,113.63) v2(105.65,115.47) v2(105.65,114.88) v2(105.94,114.34) v2(106.13,113.63) v2(106.23,115.47) v2(106.23,114.88) v2(106.53,114.34) v2(106.72,113.63) v2(106.87,113.07) v2(107.15,115.53) v2(107.15,114.95) v2(107.44,114.4) v2(107.4,112.06) v2(107.51,113.07) v2(107.63,113.69) v2(107.73,115.53) v2(107.73,114.95) v2(107.84,112.5) v2(108.02,114.4) v2(108.14,113.07) v2(108.09,97.84) v2(108.21,113.69) v2(108.18,111.39) v2(108.18,110.08) v2(108.18,109.43) v2(108.18,107.48) v2(108.32,115.53) v2(108.32,114.95) v2(108.61,114.4) v2(108.8,113.69) v2(108.78,113.07) v2(108.9,115.53) v2(108.9,114.95) v2(108.97,109.43) v2(108.97,108.13) v2(108.97,106.84) v2(108.99,104.81) v2(109.19,114.4) v2(109.24,101.32) v2(109.38,113.69) v2(109.41,113.07) v2(109.48,115.53) v2(109.48,114.95) v2(109.62,99.23) v2(109.62,95.5) v2(109.78,114.4) v2(109.76,111.39) v2(109.76,110.08) v2(109.76,107.48) v2(109.97,113.69) v2(110.05,113.07) v2(110.32,95.5) v2(110.54,112.04) v2(110.54,110.73) v2(110.54,109.43) v2(110.54,108.13) v2(110.63,121.33) v2(110.55,112.62) v2(110.64,97.51) v2(110.64,96.24) v2(110.77,104.81) v2(110.87,113.13) v2(111.19,112.62) v2(111.33,110.08) v2(111.33,108.78) v2(111.33,107.48) v2(111.33,106.84) v2(111.51,113.13) v2(111.47,104.81) v2(111.53,101.32) v2(111.82,112.62) v2(111.97,99.23) v2(112.14,113.13) v2(112.12,112.04) v2(112.12,110.73) v2(112.1,95.5) v2(112.31,121.32) v2(112.46,112.62) v2(112.74,95.5) v2(112.78,113.13) v2(112.91,111.39) v2(112.91,110.08) v2(112.91,108.78) v2(112.91,107.48) v2(112.93,97.57) v2(112.93,96.3) v2(112.88,93.88) v2(112.9,93.27) v2(113.09,112.62) v2(113.24,104.81) v2(113.41,113.13) v2(113.56,113.74) v2(113.73,112.62) v2(113.69,109.43) v2(113.69,108.13) v2(113.69,106.84) v2(113.94,104.81) v2(113.88,101.32) v2(114.05,113.13) v2(114.09,121.32) v2(114.15,113.74) v2(114.26,99.23) v2(114.36,112.62) v2(114.48,111.39) v2(114.48,110.08) v2(114.48,107.48) v2(114.51,95.5) v2(114.73,113.74) v2(114.68,113.13) v2(115,112.62) v2(115.15,97.57) v2(115.15,96.3) v2(115.31,113.74) v2(115.32,113.13) v2(115.27,112.04) v2(115.27,110.73) v2(115.27,109.43) v2(115.27,108.13) v2(115.34,95.5) v2(115.63,112.62) v2(115.72,104.81) v2(115.66,93.22) v2(115.9,113.74) v2(115.95,113.13) v2(116.06,110.08) v2(116.06,108.78) v2(116.06,107.48) v2(116.07,106.85) v2(116.27,112.62) v2(116.29,101.32) v2(116.36,104.81) v2(116.48,113.74) v2(116.59,113.12) v2(116.67,99.23) v2(116.84,112.04) v2(116.84,110.73) v2(116.9,112.62) v2(117.07,115.07) v2(117.07,114.38) v2(117.07,113.74) v2(117.12,95.5) v2(117.25,113.1) v2(117.54,112.61) v2(117.5,97.57) v2(117.5,96.3) v2(117.63,111.39) v2(117.63,110.08) v2(117.63,108.78) v2(117.63,107.48) v2(117.65,115.07) v2(117.65,114.38) v2(117.65,113.74) v2(117.75,95.54) v2(117.89,113.1) v2(118.23,115.07) v2(118.23,114.38) v2(118.23,113.74) v2(118.2,112.6) v2(118.2,104.84) v2(118.42,109.43) v2(118.42,108.13) v2(118.42,106.84) v2(118.53,113.1) v2(118.82,115.07) v2(118.82,114.38) v2(118.82,113.74) v2(118.85,112.6) v2(118.77,101.32) v2(118.9,104.88) v2(119.02,99.23) v2(119.21,111.39) v2(119.21,110.08) v2(119.21,107.48) v2(119.56,95.54) v2(119.85,97.57) v2(119.85,96.3) v2(119.99,112.04) v2(119.99,110.73) v2(119.99,109.43) v2(119.99,108.13) v2(119.98,107.5) v2(120.17,95.54) v2(120.27,93.88) v2(120.64,104.88) v2(120.67,103.23) v2(120.78,112.04) v2(120.78,110.08) v2(120.78,107.48) v2(121.24,104.88) v2(121.31,103.23) v2(121.57,111.39) v2(121.57,110.73) v2(121.57,109.43) v2(121.57,108.13) v2(121.75,101.89) v2(121.75,100.56) v2(121.75,99.29) v2(121.94,95.54) v2(122.07,97.51) v2(122.07,96.24) v2(122.36,110.08) v2(122.36,108.78) v2(122.36,107.48) v2(123.14,109.43) v2(123.14,108.13) v2(123.14,106.84) v2(123.09,104.88) v3(107,104.93)
+VCCIO: length 54.9
  BOTTOM w0.254: CPU1.G17 139.24,96.17 v2(139.24,96.06) ; v2(139.24,98.49) 138.86,98.1 CPU1.H19 ; v2(139.24,98.49) 138.88,98.85 CPU1.H20 CPU1.J20 ; v2(139.24,98.49) 139.24,98.39 CPU1.G19 139.9,97.72 v2(139.9,97.7) ; CPU1.AG12 123.9,92.69 123.9,94.02 124.28,94.4 136.79,94.4 137.24,94.85 ; CPU1.H26 CPU1.J26 138.14,103.58 v2(137.76,103.96) 138.16,104.36 CPU1.J27 CPU1.H27
  BOTTOM w0.305: CPU1.H17 CPU1.J17 ; CPU1.J21 CPU1.H21 CPU1.G21 ; CPU1.H19 CPU1.J19
  BOTTOM w0.508: v2(144.67,108.48) 145.68,109.49 145.68,110.15 147.52,111.99 147.52,113.97 147.16,114.33 RC30.2 ; RC2.1 141.43,80.37 142.21,79.59 147.88,79.59 148.98,80.69 v2(148.98,94.39)
  vias: v2(90.18,92.06) v2(90.5,92.56) v2(90.82,92.06) v2(91.13,92.56) v2(91.45,92.06) v2(91.77,92.56) v2(92.09,92.06) v2(92.4,92.56) v2(92.7,92.04) v2(93.01,92.55) v3(93.91,91.72)
+VCCIOP: length 26.5
  IN5 w0.254: v2(92.41,93.58) 92.87,93.12 94.29,93.12 97.08,95.9 97.08,103.26 94.88,105.45 94.88,110.77 v2(92.52,113.13)
  BOTTOM w0.254: PC820.1 92.52,113.79 v2(92.52,113.13) PR5014.1
  vias: v2(91.16,95.55) v2(91.16,94.85) v2(91.82,95.55) v2(91.82,94.85) v2(91.82,94.21) v2(91.82,93.58) v2(92.4,95.55) v2(92.4,94.85) v2(92.41,94.21) v2(93.17,95.17) v2(93.17,94.47) v3(89.36,96)
+VCCSA: length 2.7
  BOTTOM w0.381: 144.5,114.58 v2(144.55,114.53)
  BOTTOM w0.508: 156.57,118.32 156.57,118.33 PR5027.2 ; RH201.2 144.18,114.9 144.5,114.58
  vias: v2(136.08,103.01) v2(136.08,102.44) v2(136.54,111.4) v2(136.54,110.77) v2(136.53,110.08) v2(136.54,109.43) v2(136.53,108.78) v2(136.54,108.1) v2(136.53,107.48) v2(136.54,106.83) v2(136.6,112.17) v2(137.3,111.4) v2(137.32,110.73) v2(137.3,110.07) v2(137.35,109.44) v2(137.32,108.13) v2(137.32,107.48) v2(138.13,110.07) v2(138.13,108.8) v2(138.1,108.13) v2(152.02,116.6) v2(152.02,115.97) v2(152.22,117.69) v2(152.66,117.24) v2(152.66,116.6) v2(152.66,115.97) v2(153.33,120.42) v2(153.33,119.79) v2(153.32,119.14) v2(153.32,118.51) v2(153.29,117.87) v2(153.29,117.24) v2(153.29,116.6) v2(153.29,115.97) v2(153.94,120.42) v2(153.94,119.79) v2(153.93,119.14) v2(153.93,118.51) v2(154.45,120.1) v2(154.45,119.47) v3(135.84,107.83)
+VCCST: length 113.3
  TOP w0.381: RH164.1 144.74,90.14 v2(144.1,89.51)
  TOP w0.508: v2(96.5,77.15) 96.98,77.62 96.98,103.51 98.81,105.34 v2(98.81,106.5) ; PR503.1 PR502.1 PR501.1 PC502.1 90.14,125.01 88.91,123.78 v2(88.76,123.78)
  IN2 w0.508: 140.28,80.31 140.28,79.36 136.7,75.77 98.25,75.77 98.18,75.84 97.82,75.84 96.52,77.15 v2(96.5,77.15) ; v2(88.76,123.78) 91.09,121.46 95.44,121.46 96.65,120.25 96.65,110.4 v2(96.56,110.31) 97.07,110.31 97.74,109.64 97.74,106.79 98.02,106.5 v2(98.81,106.5)
  BOTTOM w0.203: CPU1.H28 CPU1.J28 v2(137.83,104.77)
  BOTTOM w0.254: CPU1.H30 138.91,106.81 v2(139.27,107.17)
  BOTTOM w0.508: RH156.1 99.2,105.62 98.81,106.02 v2(98.81,106.5) ; RH152.1 RH151.1 v2(96.56,110.31)
  vias: v2(143.66,84.24) v2(144.04,83.79) v2(144.42,83.35) v2(144.93,82.97) v2(145.37,82.52) v3(145.89,78.02)
+VCCSTG: length 128.9
  TOP w2.54: 152.03,79.77 152.03,97.75 150.95,98.83 150.95,104.32 148.73,106.53 147.27,106.53
  IN2 w0.508: v2(90.67,74.21) 91.26,73.62 92.72,73.62 92.74,73.61 93.22,73.61 93.23,73.62 94.31,73.62 95.86,75.16 137.05,75.16 138.86,76.97 v2(150.29,76.97)
  BOTTOM w0.254: v2(139.28,105.53) 138.91,105.9 CPU1.H29 138.91,105.99 v2(139.27,106.34) 139.56,106.64 CPU1.G30
  BOTTOM w0.381: RH165.1 96.95,107.33 96.59,106.97 96.59,105.38 96.79,105.18
  BOTTOM w0.508: 96.47,104.82 96.47,102.66 97.36,101.77 97.36,94.21 95.16,92.02 95.16,78.73 90.67,74.25 v2(90.67,74.21)
  vias: v3(145.25,105.24)
+VDD_TOUCH: length 4.5
  TOP w0.254: JEDP.33 122.6,160.47 122.9,160.77 v2(122.9,161)
  BOTTOM w0.127: v2(122.9,161) 122.1,161.8 v1(121.71,161.8)
  BOTTOM w0.508: v2(122.9,161) 122.9,160.22 CV19.1 RV81.2
+VDDCT_L: length 18.6
  TOP w0.508: CL35.1 CL32.2 211.59,146.01 v2(211.66,145.95) 211.73,146.01 CL34.2 CL33.1 213.65,146.39 v1(215.09,146.39) 216.74,146.39 217.16,145.98 CL39.1 CL38.2 v2(219.41,145.98) CL37.1 CL36.2
  BOTTOM w0.508: TL1.4 218.71,146.33 219.06,145.98 v2(219.41,145.98) 219.69,145.98 219.98,146.26 TL1.3 ; TL1.9 212.36,146.26 212.04,145.95 v2(211.66,145.95) 211.47,145.95 211.09,146.33 TL1.10
GND: length 7527
  TOP w0.089: 242,86.38 CG427.2 ; CG432.2 239.17,86.38 ; 239.99,92.23 CG176.2 ; CG425.2 237.72,73.43 ; CG429.2 241.14,86.38
  TOP w0.102: UT1.B14 UT1.A14 150.09,160.69 v2(149.61,161.18) ; UT1.B18 UT1.A18 151.93,161.22 v2(151.91,161.25) ; v2(152.97,161.26) 152.85,161.14 UT1.A20 UT1.B20 ; UT1.B16 UT1.A16 151.01,161.11 150.83,161.3 v2(150.83,161.3)
  TOP w0.178: v2(143.58,149.42) 144.11,149.96 UT1.AC1 UT1.AC2 ; v2(147.16,161.14) 147.33,160.96 UT1.A8 UT1.B8 ; v2(148.92,161.12) 149.17,160.87 UT1.A12 UT1.B12 ; UT1.G22 UT1.G23 155.13,157.82 v2(155.26,157.95) ; v2(154.76,155.97) 154.75,155.98 UT1.L23 UT1.L22 ; UT1.AB22 UT1.AC22 153.77,150.37 154.07,150.07 v2(154.57,150.07) ; UT1.AB12 UT1.AC12 149.17,149.97 v2(148.99,149.78) ; UT1.AB18 UT1.AC18 151.93,149.88 v2(152.03,149.78) ; UT1.AB20 UT1.AC20 152.85,150.06 153.27,149.65 v2(153.27,149.44) ; v2(151.08,149.78) 151.01,149.84 UT1.AC16 UT1.AB16 ; UT1.AB10 UT1.AC10 148.25,150.2 147.97,149.91 v2(147.97,149.74) ; v2(154.68,151.2) 154.5,151.38 UT1.AA23 UT1.AA22 ; UT1.B22 153.81,160.16 153.81,160.54 UT1.A22 153.77,160.64 154.19,161.06 ; UT1.B10 UT1.A10 148.25,160.77 v2(147.87,161.15) ; v2(143.52,155.02) 143.56,155.02 143.97,154.6 UT1.P1 UT1.P2 ; UT1.AC6 UT1.AB6 ; v2(150.01,149.77) 150.09,149.85 UT1.AC14 UT1.AB14 ; UT1.M1 UT1.M2 ; v2(154.78,158.9) 154.62,158.74 UT1.E23 UT1.E22 ; UT1.W23 UT1.W22 ; UT1.N22 UT1.N23 ; UT1.K2 UT1.K1 143.97,156.44 143.59,156.05 143.59,155.78 v2(143.49,155.68) ; UT1.AB2 UT1.AB1 143.9,150.92 143.75,150.77 143.75,150.22 v2(143.55,150.02) ; v2(154.96,156.98) 154.87,156.9 UT1.J23 UT1.J22 ; UT1.U22 UT1.U23 ; v2(154.73,154.05) 154.64,154.14 154.23,154.14 UT1.R23 UT1.R22 ; UT1.H1 UT1.H2 ; UT1.T2 UT1.T1 ; UT1.A6 UT1.B6 ; UT1.AB8 UT1.AC8
  TOP w0.203: UT1.AB6 146.41,150.97 146.68,151.24 147.02,151.24 UT1.AB8 147.33,151.08 UT1.Y9 ; v2(92.55,8.66) 92.55,8.39 92.67,8.27 UE5.11 ; v2(89.37,12.87) 89.37,12.92 88.95,13.34 UE5.113 ; v2(30.33,19.61) 30.12,19.82 UA4.4 ; v2(255.06,60.04) 254.8,60.04 254.62,60.22 PU8200.5 ; UE5.35 104.26,8.14 CE31.1 ; UA4.39 21.77,19.82 21.58,19.63 v2(21.38,19.63) ; DT14.2 158.29,173.43 157.35,173.43 CT97.2 ; UT1.E4 144.94,159.1 144.94,159.56 145.13,159.75 145.59,159.75 UT1.D5 ; v2(154.19,161.19) 154.19,161.06 ; UT1.Y9 147.77,151.72 147.77,152.16 UT1.W9 147.76,152.38 147.76,152.8 UT1.V9 ; UT1.Y9 148.25,151.24 UT1.AB10 ; PU8200.10 255.82,62.98 255.98,63.14 v2(256.36,63.14) ; UE5.94 89.47,22.54 89.41,22.61 89.41,22.78 v2(89.41,22.79) ; UE5.24 v2(97.87,4.34)
  TOP w0.229: v2(161.12,166.97) DT7.2
  TOP w0.254: v2(131.26,158.46) 131.26,158.94 131.6,159.28 JEDP.15 ; v2(203.2,98.9) v2(203.2,97.5) v2(203.2,96.1) ; v2(199,98.9) v2(199,99.6) 199,99.66 PC6313.2 199.63,100.37 v2(199,101) 199.62,101.62 PC6333.2 ; v2(193.3,96.1) 192.99,96.41 PC6413.2 193.3,97.11 v2(193.3,97.5) ; CG202.2 193.18,106.02 v2(193.3,105.9) ; CG202.2 CG200.2 CG201.2 ; CG202.2 193.11,106.58 CG54.2 ; v2(104.46,98.23) 104.32,98.09 RH186.2 ; v2(184.76,150.34) 184.52,150.1 UE3.23 ; UE6.12 64.46,5.68 v2(64.28,5.87) ; v2(134.22,160.93) 133.58,160.93 133.1,160.45 JEDP.12 ; CG54.2 191.9,106.55 v2(191.9,105.9) 192.56,105.24 PC6339.2 191.9,104.52 v2(191.9,104.5) v2(191.9,103.8) ; CG54.2 191.92,107.44 CG197.2 ; PC6333.2 199.63,101.63 v2(200.4,102.4) ; PC6333.2 199,102.26 v2(199,102.4) 199.63,103.03 PC6301.2 200.35,103.8 v2(200.4,103.8) v2(200.4,105.2) ; v2(201.8,105.2) 201.8,104.52 PC6337.2 201.8,104.44 v2(201.8,103.8) 201.8,103.44 PC6368.2 201.8,102.61 v2(201.8,102.4) 201.8,102.04 PC6364.2 201.8,101.21 v2(201.8,101) 201.8,100.71 PC6312.2 201.8,99.88 v2(201.8,99.6) v2(201.8,98.9) ; v2(163.69,166.97) 163.68,166.97 DT6.2 ; UE3.7 182.02,154.92 181.77,155.16 v2(181.75,155.16) ; v2(203.2,105.2) 203.2,104.73 PC6314.2 202.95,104.05 v2(203.2,103.8) 203.16,103.76 PC6346.2 203.16,102.44 v2(203.2,102.4) 203.2,101.66 PC6322.2 203.2,101.59 v2(203.2,101) 203.2,100.31 PC6334.2 203.2,100.27 v2(203.2,99.6) ; CG201.2 194.96,106.16 v2(194.7,105.9) 194.77,105.83 194.77,105.21 PC6316.2 194.79,104.57 v2(194.73,104.5) 194.65,104.43 v2(194.65,103.8) 194.65,102.29 PC6390.2 ; CG201.2 CG212.2 CG59.2 197.6,106.15 v2(197.6,105.9) ; PC6390.2 194.7,100.76 v2(194.7,99.6) ; PC6390.2 196.23,102.29 196.23,103.21 196.8,103.78 v2(196.8,103.8) ; PC6390.2 196.2,100.74 v2(196.2,99.55) ; v2(121.4,12.64) 121.55,12.79 121.81,12.79 121.91,12.89 UE10.12 ; JEDP.3 137.6,157.75 v2(137.97,157.38) ; v2(182.25,39.32) 181.88,39.32 CH70.2 ; CG307.2 190.96,88.64 v2(190.5,89.1) v2(190.5,89.8) 190.39,89.91 190.39,91.09 v2(190.5,91.2) 190.5,91.81 PC6305.2 190.5,92.01 v2(190.5,92.6) 190.5,93.21 PC6310.2 190.5,93.41 v2(190.5,94) 190.5,94.6 PC6311.2 190.4,95.3 v2(190.5,95.4) v2(190.5,96.1) 190.5,96.37 PC6414.2 190.5,97.23 v2(190.5,97.5) ; CG440.2 188.97,76.03 v2(188.58,75.65) ; v2(77.57,67.49) 77.57,67.49 JPCMC.19 ; v2(199,105.2) 199,104.66 PC6315.2 199,104.31 v2(199,103.8) ; v2(179.98,90.03) 179.97,90.02 RG38.2 ; CG158.2 239.87,73.81 239.85,73.83 v2(239.85,74.31) ; v2(184.84,83.6) 184.84,83.22 RG150.2 ; RU2.1 17.67,49.22 UU1.14 ; v2(199,105.9) 199,106.32 CG203.2 ; DT11.2 158.82,165.64 v2(159.28,165.64) ; CG199.2 189.82,106.92 PC6347.2 190.5,106.24 v2(190.5,105.9) ; v2(197.6,105.2) 197.6,104.76 PC6338.2 197.6,104.2 v2(197.6,103.8) 197.88,103.52 PC6367.2 197.88,102.68 v2(197.6,102.4) 197.88,102.12 PC6325.2 197.88,101.28 v2(197.6,101) 197.88,100.72 PC6326.2 197.6,100.01 v2(197.6,99.6) v2(197.6,98.9) ; v2(102.06,108.01) 102.12,107.95 102.12,107.34 102.52,106.95 CH195.2 ; v2(193.3,104.5) v2(193.3,103.8) ; v2(197.6,92.6) 197.65,92.55 v2(197.65,91.2) v2(197.65,90.5) 197.65,90.14 PC6320.2 ; v2(201.8,89.8) v2(201.8,91.2) 201.8,92.51 PC6391.2 ; JEDP.9 134.6,160.44 134.77,160.62 134.77,161.25 v2(134.52,161.5) ; JEDP.6 136.1,159.34 v2(136.37,159.07) ; PC6391.2 203.2,92.95 v2(203.2,91.2) 203.01,91.01 PC6342.2 203.01,89.99 v2(203.2,89.8) ; PC6391.2 203.2,93.91 v2(203.2,95.4) ; PC6391.2 201.8,94.35 v2(201.8,95.4) v2(201.8,96.1) 201.8,96.46 PC6411.2 201.8,97.13 v2(201.8,97.5) ; v2(191.9,97.5) v2(191.9,96.1) ; PC6317.2 189,103.9 v2(189.1,103.8) ; v2(200.4,92.6) v2(200.4,94) ; RG116.2 214.5,136.56 v2(214.76,136.83) ; CG19.2 192.54,85.48 v2(192.66,85.6) ; v2(195.1,86.65) 195.1,87.93 PC6331.2 195.5,88.5 v2(195.5,89.1) ; v2(197.6,97.5) 197.6,96.89 PC6412.2 197.6,96.71 v2(197.6,96.1) ; v2(140.53,152.85) RT34.2 ; v2(194.7,91.2) 194.7,90.52 PC6319.2 ; v2(199,96.1) v2(199,97.5) ; v2(193.3,89.1) 193.3,89.09 CG213.2 ; v2(183.5,102.35) 183.71,102.14 CG13.2 183.71,101.54 v2(184.2,101.05) ; v2(203.2,89.1) 203.2,88.54 CG214.2 202.27,87.62 CG58.2 ; v2(199,89.1) 198.34,88.44 CG210.2 ; CH194.2 102.59,104.74 v2(102.06,104.74) ; v2(200.4,98.9) v2(200.4,99.6) ; v2(200.4,91.2) 200.4,90.63 ; v2(181.77,150.34) 182.02,150.1 UE3.18 ; v2(117.58,10.75) 117.58,10.76 117.71,10.89 UE10.23 ; v2(200.4,97.5) 200.4,97.01 PC6410.2 200.4,96.59 v2(200.4,96.1) ; v2(194.7,96.1) v2(194.7,97.5) v2(194.7,98.9) ; CG234.2 197.2,87.55 v2(197.2,86.65) ; CG20.2 192.74,88.54 192.46,88.54 v2(191.9,89.1) ; v2(193.3,95.4) 193.3,94.96 PC6351.2 193.3,94.44 v2(193.3,94) 193.3,93.56 PC6348.2 193.3,93.05 v2(193.3,92.6) 193.04,92.34 PC6307.2 193.04,91.46 v2(193.3,91.2) 193.3,90.91 PC6336.2 193.3,90.11 v2(193.3,89.8) ; RT47.2 141.17,154.63 141.05,154.76 v2(141.05,154.93) 141.32,155.2 RT4.2 ; CG294.2 183.59,87.78 v2(182.83,87.78) ; v2(160.62,169.58) 161.11,169.09 DT13.2 ; v2(183.5,96.05) 183.89,96.05 CG306.2 184.2,96.36 v2(184.2,96.85) 183.76,97.29 CG17.2 183.5,97.75 v2(183.5,98.15) ; v2(180.01,87.84) 179.93,87.93 v2(179.43,87.93) ; v2(196.1,97.45) 196.29,97.26 PC6409.2 195.47,96.8 v2(195.47,96.8) ; JEDP.30 124.1,159.29 v2(124.33,159.05) 124.6,159.32 JEDP.29 ; v2(203.8,112.25) 204.05,112.25 RG69.2 ; v2(184.42,80.8) 184.9,80.8 RG22.2 ; CG198.2 PC6345.2 PC6353.2 201.8,89 v2(201.8,89.1) ; RT17.2 138.59,156.22 v2(138.53,156.29) ; UU7.12 v2(298.02,41.17) ; RG68.2 204.92,110.75 v2(205.3,110.75) ; v2(199,92.6) v2(199,94) ; v2(191.9,95.4) 192.19,95.11 PC6356.2 192.19,94.29 v2(191.9,94) 191.9,93.6 PC6349.2 191.9,93.02 v2(191.9,92.6) 191.9,92.2 PC6306.2 191.9,91.62 v2(191.9,91.2) 191.81,91.11 PC6340.2 191.81,89.89 v2(191.9,89.8) ; v2(190.5,103.8) 190.5,104.6 PC6321.2
  TOP w0.279: DT12.2 160.03,173.72 161.71,173.72 v2(162.25,173.18)
  TOP w0.3: 200.4,90.63 v2(200.4,90.5) ; v2(197.6,92.6) v2(197.6,94) v2(197.6,95.4) v2(197.6,96.1) ; v2(200.4,92.6) 200.49,92.51 200.49,91.29 v2(200.4,91.2) ; v2(193.3,96.1) v2(193.3,95.4) ; v2(191.9,103.8) 191.82,103.72 191.82,102.48 v2(191.9,102.4) ; v2(203.2,89.8) v2(203.2,89.1) ; v2(199,91.2) 198.91,91.29 198.91,92.51 v2(199,92.6) ; v2(203.2,105.2) v2(203.2,105.9) ; v2(200.4,96.1) v2(200.4,95.4) 200.53,95.27 200.53,94.13 v2(200.4,94) ; v2(194.7,96.1) v2(194.7,95.4) 194.83,95.27 194.83,94.13 v2(194.7,94) 194.83,93.87 194.83,92.73 v2(194.7,92.6) 194.83,92.47 194.83,91.33 v2(194.7,91.2) ; v2(194.7,98.9) v2(194.7,99.6) ; v2(201.8,105.9) v2(201.8,105.2) ; v2(193.3,99.6) v2(193.3,98.9) ; v2(191.9,95.4) v2(191.9,96.1) ; v2(200.4,105.2) v2(200.4,105.9) ; v2(193.3,105.9) v2(193.3,104.5) ; v2(195.5,89.1) v2(195.5,89.8) ; v2(191.9,98.9) v2(191.9,99.6) ; v2(189.1,96.1) v2(189.1,95.4) ; v2(201.8,89.8) v2(201.8,89.1) ; v2(199,96.1) v2(199,95.4) 199.02,95.38 199.02,94.02 v2(199,94) ; v2(189.1,89.1) v2(189.1,89.8) 189.4,90.1 189.4,90.9 v2(189.1,91.2) ; v2(191.9,89.1) v2(191.9,89.8) ; v2(199,105.2) v2(199,105.9) ; v2(203.2,98.9) v2(203.2,99.6) ; v2(197.6,105.2) v2(197.6,105.9) ; v2(193.3,89.1) v2(193.3,89.8)
  TOP w0.305: U19.5 149.76,77.11 149.76,77.11 C6.2 ; U20.5 153.7,76.89 153.89,77.08 C10.2 ; CG303.2 189.14,88.2 PC6303.2 189.3,88.9 v2(189.1,89.1) ; v2(193.5,74.38) 192.61,74.38 192.33,74.66 191.22,74.66 191.17,74.7 191.09,74.7 190.68,75.1 UG14.5
  TOP w0.356: RV8.2 136.82,156.45 v2(136.84,156.48) ; UG28.3 91.22,63.6 90.76,63.14 89.85,63.14 89.04,63.95 v2(89.04,64.6) ; CG438.2 94.57,68.41 94.88,68.1 94.88,66.57 95.2,66.25 ; v2(126.29,108.13) 126.31,108.15 127.13,108.15 PC1161.2 ; QE51.4 134.08,17.25 134.23,17.4 RE535.2 v2(134.77,17.74) ; RU25.2 301.77,36.85 302.02,37.11 v2(302.02,37.24) ; PC1162.2 131.87,108.13 v2(131.02,108.13) 130.74,108.13 PC1207.2 ; v2(184.32,51.39) 185.02,52.09 187.78,52.09 188.74,51.14 QG507.1 ; 95.2,66.25 96.23,66.25 96.3,66.32 ; 95.2,66.25 94.69,66.25 94.26,65.83 UG25.3 ; v2(89.1,67.84) 89.17,67.91 90.12,67.91 90.25,68.04 91.26,68.04 91.37,67.94 CG444.2 ; RE512.2 126.25,11.37 126.01,11.13 QE49.4 ; UG27.3 187.83,80.27 187.97,80.42 187.97,80.72 UG23.1 187.96,81.1 188.29,81.43 188.82,81.43 v2(188.92,81.33) 189.26,81.67 UG23.4 ; 96.3,66.32 96.3,67.95 96.32,67.97 CG439.2 96.32,71.8 94.95,73.17 93.1,73.17 92.91,72.99 v2(92.85,72.99) ; 96.3,66.32 96.3,65.99 96.8,65.48 UG26.3 ; RT11.2 RT38.2 v2(139.98,149.37) ; v2(180.8,80.05) 180.78,80.07 RG151.2 ; RE537.2 140.79,17.68 141.11,17.99 141.11,18.75 v2(141.17,18.82) ; v2(164.73,59.02) 164.65,59.09 UG24.1 ; v2(222.2,31.1) 222.2,30.06 221.97,29.83 QG509.4 ; PC6320.2 197.39,89.37 v2(197.65,89.1) ; v2(161.19,158.14) 161.01,157.96 CT83.2 ; v2(138.76,154.87) 138.8,154.83 RT36.2 ; v2(176.42,74.64) 176.8,75.02 RG519.2 ; v2(174.91,40.5) 174.93,40.47 RH24.2 ; QG509.1 220.67,26.94 v2(220.3,26.57) ; v2(199,91.2) v2(199,90.5) 199.16,90.34 PC6343.2 199.16,89.27 v2(199,89.1) ; v2(145.04,147.47) RT18.2 ; v2(57.13,49.4) 56.78,49.05 PQ202.1 ; RT41.2 RT35.2
  TOP w0.381: v2(207.01,129.98) 206.99,130 CG90.2 ; v2(127.54,91.96) 127.75,92.16 PC1213.2 ; CT82.2 CT81.2 ; UE9.2 75.49,2.03 75.95,2.49 75.99,2.49 76.13,2.63 76.91,2.63 v2(76.98,2.56) ; v2(109.62,99.8) 110.01,99.8 PC1029.2 ; CG311.2 179.6,129.36 v2(180.31,129.36) ; v2(132.74,98.21) 133.18,98.21 PC1027.2 ; v2(144.14,4.58) 144.14,4.83 144.37,5.06 QE39.4 144.37,5.5 144.64,5.78 RE456.2 ; QE46.1 137.85,2.94 137.64,2.73 RE496.2 ; v2(53.54,46.78) 53.68,46.65 55.36,46.65 55.48,46.52 PQ202.4 ; v2(182.32,34.89) 182.29,34.86 CH201.2 ; CH124.2 114.85,92.71 v2(114.75,92.61) ; RE465.2 132.37,2.84 132.61,3.08 QE41.1 ; PC1021.2 128.48,98.21 v2(128.04,98.21) ; CG187.2 214.5,96.37 v2(214.5,97.2) ; v2(203.16,137.98) 203.37,138.19 CG86.2 ; 202.21,133.97 202.36,133.83 CG89.2 ; CG159.2 235.85,74.51 v2(235.49,74.14) ; RE497.2 139.37,5.78 139.15,5.56 QE46.4 ; v2(130.39,99.42) 129.94,99.42 PC1025.2 ; RG127.2 235.08,106.27 235.28,106.07 235.28,104.82 v2(235.5,104.6) ; CG124.2 240.7,116.14 v2(240.68,116.17) ; CH53.2 184.16,50.57 183.15,51.58 v2(183.15,51.75) ; QE44.4 141.76,5.63 142,5.87 RE484.2 ; v2(236.17,92.8) 235.8,93.17 RG131.2 ; CT104.2 125.23,152.82 v2(125.23,152.54) ; RG54.2 210.95,134.44 210.43,134.96 ; DT1.2 159.28,166.37 v2(159.28,165.64) ; v2(133.03,91.96) 132.93,92.06 132.93,92.53 PC1097.2 ; v2(181.42,82.77) 181.42,83.24 RG101.2 ; v2(128.52,4.65) 128.66,4.79 QE45.4 128.66,5.61 128.89,5.84 RE490.2 ; v2(184.42,80.8) 183.75,80.8 RG24.2 ; CG156.2 235.99,77.78 v2(236.65,78.43) 236.65,79.04 236.35,79.34 RG58.2 ; v2(102.19,103.48) 102.51,103.16 RH184.2 ; QE53.4 130.92,17.39 130.99,17.46 RE541.2 ; v2(212.75,106.8) 213.47,106.8 CG219.2 ; PC1032.2 119.4,99.8 v2(119.02,99.8) ; v2(238.68,113.24) 238.61,113.31 CG125.2 238.03,113.3 CG122.2 ; RE532.2 131.5,11.43 131.28,11.22 QE50.4 ; PC1026.2 133.18,99.42 v2(132.74,99.42) ; CG190.2 213.41,108.9 v2(212.75,108.9) ; v2(240.28,109.17) 239.61,109.83 CG123.2 ; v2(154.59,149.44) 154.79,149.24 CT77.2 ; v2(212.81,104.69) 213.48,104.69 CG189.2 ; UC1.3 96.54,76.3 v2(96.18,76.66) ; CA40.2 31.53,40.02 v2(31.19,39.68) ; v2(207.01,133.98) 206.9,134.09 CG91.2 ; CG121.2 234.69,112.36 v2(234.68,112.37) 234.65,112.4 234.65,112.99 234.96,113.31 RG117.2 ; QE40.4 146.93,5.59 147.28,5.94 RE462.2 ; v2(193.24,153.19) 193.37,153.19 193.8,153.62 UX1.3 ; PC1024.2 129.94,98.21 v2(130.39,98.21) ; RE485.2 140.25,2.78 140.46,2.99 QE44.1 ; v2(219.01,138.78) 219.17,138.93 CG139.2 ; RT35.2 138.31,153.43 138.53,153.66 v2(138.74,153.66) ; v2(201.8,105.9) 201.8,106.2 CG196.2 CG206.2 ; RE501.2 124.5,2.78 124.74,3.02 QE47.1 124.74,3.81 v2(125,4.07) ; v2(125.69,98.21) 125.25,98.21 PC1023.2 ; v2(124.59,149.68) 124.28,149.68 124.07,149.9 RT83.1 RT62.2 ; QE43.4 125.75,16.98 126.04,17.27 RE478.2 ; CG104.2 187.08,138.31 v2(187.54,138.78) ; v2(111.97,99.8) 112.35,99.8 PC1028.2 ; CG237.2 203.2,106.11 v2(203.2,105.9) ; RG105.2 180.02,136.75 v2(180.09,136.83) ; CH118.2 116.5,92.67 v2(116.56,92.61) ; RT3.2 156.12,148.8 156.12,149.36 v2(156.06,149.43) ; QE29.4 131.28,5.63 131.52,5.87 RE397.2 ; R180.2 202.39,1.68 202.1,1.38 199.32,1.38 198.92,1.77 Q2410.3 ; RE401.2 129.77,2.78 129.98,2.99 QE29.1 129.98,4.04 v2(130.14,4.2) ; CG106.2 180.12,132.16 v2(180.34,132.38) ; RE479.2 124.18,14.16 124.45,14.43 QE43.1 ; v2(200.4,89.1) 200.4,89.69 PC6341.2 200.4,90.06 v2(200.4,90.5) ; RE508.2 121.83,3.03 122.15,3.35 QE48.1 ; CU29.2 68.04,61.66 68.04,61.01 67.77,60.74 UU5.3 ; QE39.1 142.85,3.18 RE453.2 ; PC1031.2 114.7,99.8 v2(114.26,99.8) ; RE504.2 126.25,5.74 126.04,5.53 QE47.4 126,5.26 126,4.68 v2(126.04,4.64) ; RG56.2 236.16,110.65 v2(236.28,110.77) ; QE48.4 123.45,5.48 123.64,5.66 RE509.2 ; RG107.2 187.02,137.45 v2(187.54,137.98) ; v2(167.21,61.49) 166.08,61.49 UG24.4 ; PC1134.2 135.68,92.62 CH127.2 135.73,91.98 v2(135.78,91.93) ; CG175.2 235.79,94.75 v2(235.15,94.75) ; QE52.4 140.36,16.99 140.58,17.21 RE537.2 ; v2(200.4,105.9) 200.4,106.29 PC6300.2 CG204.2 ; v2(199.01,134.78) 198.39,135.39 RG108.2 ; v2(125.69,99.42) 125.25,99.42 PC1022.2 ; v2(193.24,152.55) 193.24,152.3 193.44,152.11 193.92,152.11 194.25,152.44 QV97.4 ; v2(201.41,130.78) v2(202.21,130.78) ; RE458.2 145.39,2.73 145.63,2.97 QE40.1 145.63,3.92 v2(145.85,4.15) ; CH106.2 142.47,103.99 v2(142.49,104.01) 142.52,103.98 CH105.2 ; v2(214.45,101.3) 214.45,100.57 CG188.2 ; v2(128.04,99.42) 128.48,99.42 PC1020.2 ; v2(191.79,137.03) 191.94,136.88 RG109.2 ; RE473.2 136.72,5.79 136.53,5.6 QE42.4 ; RG91.1 177.94,78.6 v2(178.64,79.3) ; v2(180.77,36.02) 179.79,36.02 179.5,36.31 UH3.3 ; v2(206.21,141.98) 205.86,141.98 CG84.2 ; RE472.2 134.98,2.78 135.23,3.03 QE42.1 ; v2(127.52,4.07) 127.36,3.9 QE45.1 127.36,3.04 127.1,2.78 RE491.2 ; v2(183.15,58.95) 182.58,58.95 182.17,59.36 CG246.2 ; RH199.2 178.93,34 v2(178.66,34.27) ; v2(183.5,100.25) 183.5,100.08 183.77,99.81 CG296.2 ; QE41.4 133.91,5.58 134.16,5.84 RE468.2 ; v2(116.67,99.8) 117.05,99.8 PC1030.2 ; v2(202.21,133.98) 202.2,133.99 RG106.2 ; v2(170.38,152.49) 171.08,152.49 171.52,152.93 QE21.1
  TOP w0.4: v2(202.21,133.98) 202.21,133.97 ; v2(179.43,92.13) 179.43,93.07 RG37.2 ; 210.43,134.96 v2(210.36,135.03) ; v2(204.6,92.6) 204.6,92.77 205.08,93.25 205.95,93.25
  TOP w0.406: v2(173.18,60.77) 173.32,60.91 QG505.4 ; QE51.1 v2(132.78,15.69) ; v2(259.79,60.5) 260.17,60.88 PQ8202.1 ; UG22.3 183.08,62.65 v2(183.08,62.82) ; v2(171.72,58.89) 172.02,59.19 QG505.1 ; PQ8202.4 v2(262.99,59.58) ; v2(139.4,15.58) 139.06,15.25 QE52.1 ; QG504.1 174.81,59.38 174.58,59.14 174.58,58.7 v2(174.45,58.57) ; QG503.4 178.91,61.76 v2(179.21,62.06) ; DV2.1 131.22,157.21 131.51,157.5 131.51,158.2 v2(131.26,158.46) ; QG504.4 176.11,62.02 176.13,62.03 176.13,62.09 v2(176.14,62.09) ; DU2.3 v2(16.49,55.7) ; v2(176.99,59.35) 177.43,59.35 QG503.1 ; v2(303.85,65.86) DU5.3
  TOP w0.432: v2(140.47,4.06) 140.46,4.06 QE44.1 ; QE42.1 135.23,3.92 v2(135.4,4.09) ; QE48.4 123.45,4.69 v2(123.36,4.61) ; QE41.4 133.91,4.82 133.77,4.68 v2(133.77,4.6) ; QE50.4 131.28,10.68 v2(132.09,9.87) ; PQ710.4 91.55,70.66 v2(91.04,71.16) ; QE48.1 122.15,3.98 v2(122.25,4.09) ; QE3.1 262.16,50.77 v2(262.41,50.52) ; QE46.4 139.15,4.92 139.01,4.78 v2(139.01,4.61) ; QE49.4 126.01,10.56 v2(126.44,10.13) ; QE44.4 141.76,4.81 v2(141.49,4.53) ; Q9.4 119.75,4.2 119.96,3.99 120.24,3.99 v2(120.38,4.12) ; v2(117.33,4.1) 116.93,4.1 116.8,4.24 Q8.4 ; v2(146.93,4.64) QE40.4 ; v2(187.4,60.54) 187.44,60.54 187.91,61.01 QG502.1 ; QE50.1 v2(129.98,9.58) ; QE53.4 130.92,15.87 v2(131.01,15.78) ; QE43.1 124.45,15.44 v2(124.39,15.5) ; v2(136.4,4.63) 136.53,4.75 QE42.4 ; v2(131.28,4.64) QE29.4 ; v2(132.61,4.07) QE41.1 ; v2(130.06,15.71) 129.62,15.27 QE53.1 ; v2(137.85,4.07) QE46.1 ; v2(143.07,4.07) QE39.1 ; v2(124.41,9.55) 124.41,9.42 124.71,9.12 QE49.1 ; Q9.1 118.45,3.15 117.92,3.68 v2(117.92,4.1) ; PQ710.1 v2(91.04,71.96) ; QE43.4 125.75,16.1 125.98,15.87 v2(125.99,15.87)
  TOP w0.457: v2(205.5,80.8) 205.37,80.67 CG218.2 ; v2(183.15,51.75) 183.15,52.42 CH187.2 ; CG222.2 201.4,80.13 v2(201.4,80.86) ; v2(264.62,39.71) UE1.3 ; CG227.2 211.53,80.02 v2(211.5,80.05) ; v2(199.2,80.76) 199.21,80.75 CG228.2 ; v2(105.42,8.61) 104.73,8.61 CE31.1 ; CG230.2 CG235.2 184.05,86.12 183.58,85.65 v2(182.9,85.65) ; CG238.2 CG236.2 182.11,88.34 v2(182.1,88.35) ; CH186.2 178.36,43.89 v2(178.68,44.2) ; v2(194.77,80) 194.81,80.03 CG216.2 ; v2(127.54,91.96) 127.43,92.07 CH125.2 126.63,92.05 v2(126.63,91.32) ; v2(213.9,79.2) 214.21,78.89 CG221.2 214.64,79.27 214.55,79.37 v2(214.55,79.8) ; CG185.2 213.56,90.25 v2(212.87,90.25) ; v2(216.02,81.46) 216.05,81.43 CG226.2 ; CG186.2 213.56,94.2 v2(212.75,94.2) ; CG224.2 203.4,80.74 v2(203.35,80.8) ; v2(212.93,79.34) CG225.2 ; v2(191.54,141.18) 192.45,141.18 CG102.2 ; v2(146.49,92.6) 146.49,91.87 CH193.2 146.92,91.44 v2(146.92,90.65) ; CG184.2 213.22,87.88 v2(212.74,87.88) ; CG243.2 213.44,85.81 v2(213.6,85.65) ; RG53.2 182.08,135.44 v2(181.94,135.58) ; CU26.2 63.9,60.54 64.58,61.23 v2(64.78,61.23) ; CG220.2 v2(212.75,92.1)
  TOP w0.508: PC8222.2 v2(262.14,58.38) ; v2(200.55,158.39) 200.55,159.47 201.16,160.08 JLOGO.12 ; CD14.2 147.12,38.64 CD12.2 ; v2(111.56,121.3) 111.56,121.71 PC1013.2 ; v2(100.28,4.36) 100.28,3.09 100.64,2.73 CE44.2 RE75.2 ; RG119.2 237.9,120.89 v2(237.68,120.67) ; CT96.2 160.83,170.46 160.83,169.79 v2(160.62,169.58) ; PR6202.2 217.71,31.79 v2(218.58,32.66) ; v2(113.33,121.3) 113.33,121.71 PC1015.2 ; CG161.2 238.03,90.5 CG318.2 238.04,91.34 v2(237.89,91.49) ; v2(46.93,13.11) 47.85,13.11 PC11.2 ; v2(219.67,140.18) 219.73,140.23 CG345.2 CG135.2 ; v2(57.13,49.4) 57.86,48.67 57.86,45.81 57.23,45.17 PC217.2 ; CL6.2 204.05,152.33 v2(203.66,151.94) ; CH183.2 168.02,38.75 v2(168.24,38.98) ; CG417.2 235.1,98.83 CG415.2 235.9,100.13 CG377.2 CG126.2 236.61,101.12 v2(236.65,101.15) ; v2(239.85,93.15) 239.99,93 CG176.2 ; CG359.2 222.35,134.64 v2(223.01,133.98) ; v2(128.52,40.43) 128.27,40.68 CD77.2 ; v2(133.74,47.8) 133.74,48.65 133.48,48.92 CD2.2 ; v2(191.37,51.19) 191.37,49.87 191.1,49.6 QG507.4 ; v2(238.73,127.72) 238.77,127.67 CG381.2 238.69,124.43 CG354.2 ; v2(198.64,4.72) 198.64,4.95 198.41,5.18 C29.2 197.69,6.04 C2508.2 ; PR8220.1 PC8211.2 256.57,58.05 v2(256.88,58.37) ; CH107.2 139.29,104.63 CH110.2 139.76,103.81 v2(139.9,103.95) ; RE31.2 188.04,152.48 v2(188.04,151.79) 188.05,151.78 CE24.2 ; CU28.2 70.13,63.09 v2(70.5,63.46) ; Q8.1 115.5,2.78 114.82,3.45 v2(114.82,4.22) 114.82,5.04 116.27,6.49 Q7.1 ; v2(90.25,48.49) 89.99,48.75 89.98,48.75 89.86,48.88 CD79.2 ; v2(216.35,83.17) 216.76,83.17 CG217.2 ; CG396.2 218.44,137.31 CG401.2 218.38,137.81 v2(218.21,137.98) ; CE22.2 72.53,2.56 72.25,2.28 CE64.2 70.63,1.61 v2(70.12,2.12) ; v2(117.54,159.71) 117.76,159.93 JEDP.42 ; v2(53.86,7.42) 53.96,7.42 54.29,7.09 PQ8.3 ; 241.14,86.38 241.14,86.69 v2(240.87,86.96) ; PR28.1 54.43,8.08 v2(53.67,8.08) ; DT15.1 155.11,169.51 154.81,169.81 JUSBC1.2 ; DA8.1 40.27,5.25 v2(40.27,4.15) ; CH3.2 177.95,46.58 178.48,47.11 v2(178.48,47.24) ; RG94.1 178.26,82.07 178.34,82.15 v2(178.7,82.15) ; RE645.1 81.35,13.87 PC13.1 82.28,13.9 PR26.1 82.87,13.9 v2(82.94,13.82) ; v2(188.34,133.18) 188.15,132.98 CG330.2 CG357.2 ; v2(115.9,8.15) 115.54,7.79 Q7.4 ; CG430.2 CG426.2 241.45,81.41 v2(241.45,81.51) ; RG557.2 187.83,74.33 v2(188.23,73.94) ; CA54.2 CA53.2 32.01,17.8 32.3,17.51 32.3,17.14 v2(32.59,16.85) ; CD73.2 113.55,42.53 v2(114.37,43.35) ; CG155.2 235.18,83.91 v2(235.05,83.91) ; v2(107.95,48.62) 109.8,48.62 CD7.2 ; 242,86.38 CG160.2 242,87.29 241.5,87.78 CG154.2 240.69,88.43 v2(240.81,88.54) ; PR6102.2 204.69,31.08 205.25,31.08 v2(205.31,31.14) ; v2(240.11,127.7) 239.71,127.3 CG365.2 CG374.2 CG376.2 ; CE46.2 99.38,25.09 v2(99.84,25.55) ; CG371.2 185.4,139.29 CG101.2 v2(184.34,139.58) ; v2(89.68,109.18) 89.14,109.72 PC5026.2 PC5025.2 ; CG191.2 212.79,110.96 v2(212.75,111) ; PR6109.1 v2(198.52,29.93) 198.52,28.87 198.5,28.85 PC6120.1 ; v2(153.05,69.58) 153.38,69.91 C7.2 153.38,70.82 153.3,70.89 C2520.2 ; v2(115.72,164.27) 116,163.98 JEDP.43 ; CG315.2 v2(237.97,123.85) ; v2(237.97,123.85) 237.2,124.62 CG411.2 ; v2(237.97,123.85) 237.82,123.7 CG419.2 ; CG343.2 241.23,99.8 v2(240.66,100.37) 240.66,100.27 240.11,99.72 CG407.2 ; QV2.3 v2(116.98,153.08) ; v2(260.62,48.6) 260.86,48.84 QE3.4 ; CD87.2 110.11,36.24 109.44,35.57 v2(109.44,34.46) ; v2(23.06,15.58) 22.37,14.88 CA55.2 ; CD8.2 109.8,42.72 109.55,42.96 109.55,43.81 110.03,44.28 v2(110.18,44.28) ; v2(127.29,27.61) 127.45,27.77 RD40.2 ; v2(62.7,29.25) 60.99,29.25 60.67,29.57 PC711.1 ; RH580.2 172.23,51.33 172.08,51.47 v2(172.08,51.53) ; v2(94.81,144.84) 94.81,147.02 JTAG.8 95.46,147.67 96.1,147.67 97.02,148.59 JTAG.6 ; C2525.2 57.99,56.07 v2(57.99,56.41) ; RH585.1 169,29.55 v2(168.54,30.02) ; CG351.2 238.34,81.05 v2(238.65,81.36) ; CE9.2 v2(269.13,51.21) ; v2(301.13,45.72) 301.13,45.33 CU37.2 300.39,45.28 v2(300.39,45.72) ; v2(206.21,137.98) 206.21,137.81 206.77,137.25 206.77,136.49 206.54,136.26 CG395.2 ; v2(115.11,121.3) 115.11,121.71 PC1016.2 ; CA52.2 30.68,14.36 arc(30.72,14.16) 30.84,13.99 31.83,13 v2(31.95,13) ; CG346.2 CG105.2 183.59,134.02 v2(183.54,133.98) ; v2(26.36,42.72) 26.36,43.15 CA8.2 ; v2(146.48,53.76) 145.87,53.76 CD17.2 145.8,52.99 CD16.2 ; v2(153.97,78.31) 153.89,78.23 C10.2 ; v2(210.14,28.6) 210.14,28.22 210.5,27.85 PR6222.1 210.91,27.84 PC6212.2 ; CU47.2 19.53,53.28 v2(19.51,53.3) ; v2(106.99,31.67) 107.37,31.67 107.71,31.33 CD92.2 ; CE29.2 97.98,2.68 98.5,3.2 v2(98.5,4.36) ; PC511.2 97.99,129.34 98.31,129.66 v2(98.31,130.4) ; UU3.2 300.52,62.63 v2(300.49,62.65) ; v2(277.7,35.46) 277.26,35.9 PD1.1 ; CH197.2 92.8,74.37 v2(92.98,74.19) 92.74,73.95 91.7,73.95 91.27,73.52 PR730.1 ; CE28.2 RE66.2 102.01,24.55 102.4,24.94 v2(102.81,24.94) ; CH176.2 178.39,38.44 v2(178.79,38.04) ; CD84.2 112.59,33.47 v2(112.48,33.36) ; CH103.2 138.1,97.69 v2(137.69,97.28) ; CE38.2 82.55,9.92 82.2,9.57 v3(81.61,9.57) 80.95,9.57 v2(80.59,9.93) ; v2(104.7,27.53) 104.72,27.55 CD21.2 ; v2(182.88,30.62) 182.33,30.06 182.25,30.06 181.75,29.57 CH192.2 ; v2(191.38,71.56) 191.59,71.78 192.99,71.78 195.3,74.09 CG323.2 ; PC726.2 PC727.2 v2(56.46,30.27) ; PC8200.2 v2(248.05,65.24) ; v2(186.56,156.85) 186.55,156.85 186.28,156.58 RE42.2 185.04,156.58 RE44.2 ; R180.2 C2509.2 203.71,1.98 204.74,3.01 v2(204.74,4.72) ; PC218.2 53.07,46.3 v2(53.54,46.78) ; v2(233.25,3.07) C620.2 C628.2 ; v2(162.25,173.18) 161.94,172.87 CT94.1 ; v2(230.07,40.35) 230.33,40.6 C636.2 ; CH200.2 178.38,34.55 v2(178.66,34.27) ; v2(79.47,21.38) 79.36,21.27 SW1.1 ; v2(203.16,139.98) 203.28,140.09 CG87.2 CG403.2 ; CD72.2 122.5,42.53 v2(123.32,43.35) ; v2(186.96,43.41) 186.92,43.45 RH135.1 ; v2(240.65,78.31) 240.76,78.42 CG153.2 ; v2(161.19,158.14) 162.01,158.96 YT1.4 ; v2(36.15,35.9) 36.21,35.97 CA259.2 ; v2(292.37,65.32) 292.85,64.84 CN9.2 ; v2(172.18,32.88) 172.18,32.23 171.71,31.77 CH190.2 ; v2(176.58,51.51) 176.32,51.78 CH189.2 ; v2(85.91,27.62) 85.88,27.59 CD22.2 ; CH173.2 CH80.2 176.39,42.83 v2(175.71,42.83) ; v2(241.89,88.99) 241.96,89.06 CG379.2 CG157.2 ; v2(232.65,101.15) 232.67,101.13 CG174.2 ; v2(114.39,30.23) 113.92,29.76 CD26.2 ; C621.2 C623.2 v2(228.72,28.87) ; C618.2 C617.2 v2(230.2,44.97) ; YT1.2 159.39,161.24 CT37.2 157.1,161.24 v2(157.05,161.19) ; C624.2 v2(233.25,3.96) ; v2(104.44,42.9) 104.51,42.84 CD76.2 ; JLOGO.9 191.86,158.38 v2(191.34,158.9) 190.86,158.42 JLOGO.10 ; v2(175.25,30.4) 174.93,30.4 174.13,31.2 RH26.2 ; RE647.1 120.18,6.83 CE63.1 119.9,6.55 v2(119.9,5.49) ; v2(110.33,30.53) 110.81,30.04 CD23.2 ; CD81.2 v2(138.75,30.32) ; PR8206.1 248.3,61.43 247.98,61.75 v2(247.98,62) ; v2(119.13,42.21) 118.81,42.53 CD71.2 ; v2(193.24,153.19) 193.18,153.25 RX4.2 ; CG136.2 219.07,142.04 v2(219.01,141.98) ; C268.2 149.48,63.09 v2(149.07,62.68) ; v2(164.51,67.02) 163.99,67.02 163.45,67.56 CG386.2 ; JLOGO.11 189.56,159.16 v2(190.07,158.65) ; CG443.2 183.22,55.93 182.95,55.65 v2(182.32,55.65) ; CA85.2 30.22,31.75 v2(30.62,31.35) 29.99,30.72 RA16.2 ; CG367.2 CG347.2 236.89,106.01 v2(236.88,105.99) ; C6.2 149.76,78.08 v2(150,78.32) ; v2(260.55,65.3) 260.12,64.87 PC8217.2 259.02,64.79 PC8218.2 ; CD25.2 124.73,36.24 v2(125.14,35.84) ; CG370.2 CG413.2 235.1,124.05 v2(234.77,123.72) ; CH185.2 170.49,42.92 v2(170.56,42.85) ; CG383.2 236.98,99.89 v2(237.45,100.35) ; CG393.2 204.7,134.77 CG399.2 206.31,134.1 CG91.2 ; U18.2 150.57,60.1 ; 150.57,60.1 150.7,59.97 150.7,58.32 150.94,58.08 C2522.2 ; 150.57,60.1 149.37,60.1 ; CH4.2 171.54,37.88 171.09,37.43 v2(170.95,37.43) ; v2(90.12,35.6) 90.05,35.67 CD83.2 ; 313.81,84.99 313.82,84.97 CH2.2 ; RG108.2 197.93,135.39 197.52,134.99 CG313.2 ; v2(64.52,54.12) 64.52,53.6 PC206.2 65.16,53.71 v2(65.16,54.12) ; CE40.1 v2(83.58,15.76) ; PQ2.3 281.07,36.5 v2(280.56,35.98) ; DV4.1 128.69,157.27 v2(128.69,157.85) ; CG416.2 234.67,113.96 RG117.2 ; CG119.2 238.22,93.12 v2(238.25,93.15) ; 239.17,86.38 239.17,86.69 v2(239.03,86.83) 238.9,86.96 CG424.2 ; CE17.2 273.38,41.51 v2(273.57,41.32) 273.57,40.94 273.19,40.56 CE18.2 ; v2(266.33,51.71) 266.03,51.41 QE4.4 ; v2(174.37,31.83) 174.43,31.83 174.81,31.45 CH191.2 ; v2(299.28,62.93) 298.54,62.93 CU16.2 ; v2(240.65,97.15) 240.65,97.22 240.03,97.84 CG414.2 240.03,98.15 239.46,98.73 CG378.2 ; v2(222.21,141.98) 222.15,142.04 CG137.2 ; v2(299.11,62.27) 298.87,62.03 CU46.2 298.17,62.03 297.79,62.41 C2521.2 ; CG171.2 241.77,92.83 v2(241.45,93.15) 241.61,93.15 242.13,93.67 CG349.2 242.65,93.42 CG334.2 ; v2(244.16,79.32) 243.75,79.73 CG428.2 ; CG314.2 191.89,130.77 v2(191.66,130.77) ; CA9.2 26.36,46.51 CA10.2 v2(26.6,47.51) ; v2(206.21,140.36) 206.07,140.36 205.56,139.85 CG360.2 CG350.2 ; v2(62.18,39.5) PC718.1 ; v2(50.46,25.84) 50.46,24.79 PC715.2 ; v2(202.21,130.78) 202.23,130.76 CG88.2 203.07,130.64 CG391.2 ; CG342.2 CG358.2 218.59,128.79 218.21,129.17 v2(218.21,129.98) ; CE56.2 71.77,10.12 v2(72.02,9.87) ; CH180.2 163.54,43.23 v2(163.89,42.88) ; v2(198.29,32.7) 198.44,32.85 PC6100.2 ; v2(292.8,66.91) CM15.2 ; RV15.1 191.34,155.22 v2(192.61,156.49) ; CD28.2 v2(152.73,39.29) ; v2(184.44,137.98) 185.13,137.29 CG363.2 CG331.2 CG332.2 ; v2(115.95,48.02) 115.47,48.02 114.42,49.07 CD6.2 ; v2(314.81,39.18) 314.81,39.63 314.38,40.06 CU19.2 CU18.2 ; JWDB.4 179.04,22.06 178.62,21.64 JWDB.5 177.59,21.52 178.11,21 179.15,21 179.46,20.69 v2(179.46,20.36) ; CE30.2 CE41.2 89.84,2.73 89.48,3.09 v2(89.48,4.3) ; QE2.3 83.82,24.54 CE51.2 v2(84.86,24.22) ; CH52.2 182.47,43.92 v2(182.57,43.82) ; CD29.2 125.68,29.97 v2(125.87,30.16) ; RU3.1 17.21,46.13 CU7.2 v2(17.2,45.32) ; CG369.2 189.45,137.3 189.14,137.6 v2(189.14,138.01) ; v2(180.57,120.04) 180.57,120.08 178.98,121.66 CG308.2 CG309.2 ; v2(308.43,42.51) 308.88,42.06 DU11.1 ; v2(287.86,44.49) 288.62,43.73 CU44.2 CU42.2 CU33.2 291.16,43.65 v2(291.85,44.34) ; v2(279.48,36.35) 279.48,37.59 PR9.1 ; RH90.1 176.48,49.43 v2(176.47,49.42) 176.46,49.43 CH174.2 ; CA7.2 v2(25.67,44.46) ; CG410.2 240.76,115.23 CG124.2 ; CE16.2 273.5,42.43 273.89,42.82 v2(273.89,43.52) ; C2514.2 v2(245.7,16.66) ; CG325.2 CG340.2 218.24,131.61 v2(218.21,131.58) ; PR306.2 v2(213.58,23.62) ; v2(218.21,133.98) 218.44,134.21 CG338.2 CG141.2 ; C2.2 214.78,8.99 214.58,8.79 212.08,8.79 v2(211.84,9.03) ; CM14.2 v2(292.43,67.99) ; v2(170.08,164.87) 169.71,164.5 UE7.2 ; CG83.2 CG402.2 203.1,141.88 v2(203.01,141.98) ; v2(292.94,50.27) 293.06,50.4 CM13.2 ; CV14.2 123.65,155.09 v2(123.99,155.43) ; CG223.2 213.71,112.74 v2(213.6,112.85) ; v2(177.55,50.37) 178.05,49.87 RH88.1 ; v2(264.49,35.35) CE57.2 ; v2(139.89,95.31) 139.85,95.27 CH102.2 ; v2(148.93,27.67) 148.66,27.4 CD90.2 CD89.2 ; v2(172.12,47.94) 172.07,47.98 171.71,47.98 CH188.2 ; v2(271.85,34.19) CE6.2 ; v2(183.54,131.6) 183.61,131.66 184.09,131.66 CG368.2 ; CE59.2 v2(268.68,34.19) ; C622.2 230.65,41.49 v2(230.07,42.06) 230.39,42.38 C635.2 ; v2(126.04,38.4) 125.99,38.34 RD30.2 ; CG353.2 CG341.2 186.26,131.47 186.78,131.99 CG348.2 187.58,131.99 187.99,131.58 v2(188.34,131.58) ; v2(28.9,30.94) 29.09,31.13 CA23.2 ; PC8216.2 259.34,60.92 v2(259.73,61.3) 259.22,61.81 PC8215.2 ; PC8205.2 v2(256.36,63.76) ; CL22.2 195.53,149.08 v2(195.53,148.19) ; v2(18.98,18.5) 18.14,19.35 DA4.1 ; CU35.2 292.74,38.42 v2(292.89,38.27) ; UH5.1 v2(318.49,81.99) ; PC716.1 v2(51.96,31.9) ; CD24.2 120.53,33.87 v2(120.74,33.65) ; 237.72,73.43 CG434.2 ; CD19.2 100.53,36.3 v2(101.02,35.81) ; CG435.2 238.58,79.4 239.03,78.95 239.03,78.33 v2(239.05,78.31) ; v2(233.08,120.37) 233.02,120.43 233.02,121.78 233.38,122.13 234.04,122.13 ; CD74.2 138.82,41.29 v2(139.75,40.35) ; v2(195.85,27.65) 196.05,27.85 PR6125.1 197.58,27.84 PC6118.2 ; v2(122.97,92.06) CH122.2 ; v2(241.45,76.71) 242.05,76.71 242.39,77.05 CG361.2 242.57,77.18 CG335.2 ; v2(303.8,63.29) 303.53,63.02 CU17.2 CU11.2 ; v2(143.48,35.64) 143.64,35.79 CD82.2 ; DA7.1 v2(38.33,9.98) ; CV374.2 126.28,157.19 125.6,156.51 CV375.2 125.01,157.45 v2(124.73,157.73) ; CD4.2 CD3.2 v2(151.63,50.53) ; CD70.2 123.83,49.01 123.83,48.15 v2(123.68,48) ; RU2.1 v2(17.21,50.34) ; v2(214.26,145.12) 214.07,144.93 213.44,144.93 CL33.2 CL34.1 v2(211.68,145.1) CL32.1 CL35.2 209.46,145.1 v2(209.44,145.12) ; QV97.1 196.35,150.45 v2(196.35,150.45) ; CH82.2 169.44,46.84 v2(169.76,46.52) ; CE36.2 92.97,1.84 CE34.2 CE45.2 94.44,2.73 94.57,2.86 94.57,4.02 v2(94.5,4.09) ; CG329.2 184.85,142.48 v2(184.34,141.98) ; CG337.2 RG118.2 221.38,137.14 v2(222.21,137.98) 222.2,137.98 221.79,138.39 CG140.2 ; CG90.2 CG394.2 205.13,130 204.31,130.82 CG397.2 ; v2(200.61,136.38) 200.71,136.48 CG398.2 ; CG425.2 237.72,73.65 238.25,74.17 v2(238.25,74.31) ; CG138.2 CG382.2 CG362.2 CG333.2 222.38,132.79 222.77,133.18 v2(223.01,133.18) ; JTAG.7 93.67,154.89 v2(93.55,154.77) ; v2(161.51,107.24) 161.22,106.95 RV624.2 RV24.2 ; v2(292.84,43.4) CU34.2 ; QE4.1 v2(264.73,49.98) ; QE5.3 145.88,16.21 v2(146.51,15.58) ; JWDB.6 178.78,26.64 v2(179.26,27.13) ; CG380.2 203.87,137.13 CG373.2 203.86,138.11 CG86.2 ; RD29.2 149.29,43.91 v2(149.43,44.05) ; v2(217.63,21.97) PR308.2 PC300.2 ; CG311.2 178.98,128.74 CG310.2 ; CM10.2 v2(292.81,52.62) ; CE1.2 v2(267.79,34.19) ; v2(235.85,85.5) 235.87,85.48 RG130.2 ; C2515.2 244.43,16.15 v2(244.93,16.66) 244.5,17.09 C2516.2 ; CE32.1 RE83.2 v2(84.19,4.82) ; v2(89.42,23.45) 89.42,23.84 88.91,24.35 CE42.2 ; v2(91.83,76.8) v3(90.54,75.5) 88.21,73.18 PC724.2 ; CE27.2 83.67,13.73 v2(83.58,13.82) ; CE58.2 254.28,41.23 v2(254.08,41.43) ; v2(141.86,107.9) 141.83,107.87 CH109.2 ; CE13.2 273.68,45.13 273.88,44.93 v2(273.88,44.21) CE14.2 CE15.2 ; CG173.2 237.68,98.72 238.19,98.21 CG356.2 238.19,97.21 v2(238.25,97.15) ; RG55.2 214.07,132.99 214.69,132.38 v2(215.01,132.38) ; RD38.2 v2(144.98,24.94) ; CG412.2 CG418.2 236.97,127.16 v2(236.42,127.71) ; v2(217.63,19.2) 217.54,19.12 PR303.1 ; v2(270.07,34.19) CE60.2 ; v2(68.34,44.05) PC201.2 PC200.2 ; CG400.2 203.01,133.78 CG89.2 ; v2(122.06,92.6) 121.69,92.6 121.24,93.05 CH119.2 ; JEDP.41 139.5,160.91 v2(139.8,161.21) ; v2(266.01,34.19) CE3.2 ; CN25.2 v2(292.81,53.87) ; v2(199.72,154.39) 199.31,154.39 CE61.2 ; CD10.2 150.25,53.12 149.6,53.76 v2(149.3,53.76) ; CG423.2 CG431.2 242.58,80.35 v2(242.34,80.59) ; CG327.2 187.35,129.12 CG375.2 187.6,129.23 v2(188.34,129.98) ; CD31.2 v2(152.73,36.11) ; v2(256.87,45.11) 256.6,44.84 QE1.1 ; v2(181.94,142.78) 182.13,142.96 CG328.2 ; v2(52.66,36.28) 52.03,36.28 PC721.2 ; v2(117.09,35.87) 116.72,36.24 CD85.2 ; RE650.2 v2(146.31,18.44) ; RD28.2 146.7,42.1 CD15.2 ; DU4.1 v2(302.99,68.23) ; CE8.2 v2(268.11,51.21) ; v2(270.96,34.19) CE7.2 ; PC8209.2 v2(236.07,58.93) ; CH104.2 138,102.88 v2(137.64,103.24) ; PR8211.2 259.29,60.03 v2(259.54,59.78) ; CE4.1 v2(266.89,34.12) ; CD88.2 148.84,28.99 CD32.2 148.84,31.32 148.73,31.42 v2(148.73,31.65) ; CG392.2 206.61,132.36 v2(207.01,132.36) ; v2(223.01,131.58) 222.98,131.61 CG352.2 CG372.2 ; RG95.1 182.07,77.05 v2(181.94,76.92) 181.71,76.69 CG312.2 ; CL36.1 CL37.2 v2(219.4,145.06) CL38.1 CL39.2 v2(217.18,145.06) ; CD20.2 133.55,36.14 v2(133.25,35.85) ; CV1069.2 v2(188.12,164.47) ; CD78.2 v2(100.46,48.66) ; PR6207.1 v2(210.9,28.66) 210.95,28.61 211.48,28.61 211.84,28.97 PC6214.1 ; v2(60.01,40.11) PC720.1 ; v2(123.94,43.83) 124.16,43.83 124.52,43.47 RH211.2 CD18.2 RH209.2 ; PC102.2 49.69,26.4 v2(49.04,25.74) ; v2(67.51,11.37) 68.06,11.37 CE55.1 ; DA6.1 17.41,33.38 v2(17.54,33.25) ; RC35.2 v2(67.06,69.04) 66.99,68.97 RC348.2 ; RA9.2 30.99,34.22 v2(30.69,34.52) ; CH120.2 143.74,90.94 v2(144.03,90.94) ; QE13.1 164.76,152.99 v2(164.67,153.08) ; v2(208.61,129.18) 208.61,129.15 208.05,128.59 207.36,128.59 206.9,129.06 CG85.2 ; CV1068.2 188.29,163.73 v2(188.36,163.79) ; v2(237.05,81.36) 236.42,80.73 RG128.2 ; v2(51,5.8) 51.21,5.6 PQ4.3 ; v2(120.82,30.22) 121.28,29.76 CD86.2 ; CG442.2 186.56,56.74 v2(187.13,56.17) ; v2(241.45,75.11) 241.52,75.18 CG433.2 ; RG90.1 v2(178.63,77.55) ; CG355.2 221.81,128.79 221.82,128.8 222.15,128.8 CG103.2 222.69,128.85 v2(223.01,129.18) ; v2(142.67,48.52) 142.79,48.52 143.45,49.19 CD1.2 ; v2(125.98,26.82) 125.68,27.12 RH212.2 RH210.2 ; v2(129.3,126.28) 129.3,126.66 129.76,127.12 PR562.1 ; v2(64.97,44.75) PC208.2 PC216.2 ; v2(104.85,25.74) 104.92,25.74 105.98,24.67 LE2.1 ; QU1.3 302.6,47.1 303.61,48.11 303.61,49.2 v2(302.81,50) ; CG239.2 176.54,85.75 v2(176.23,85.43) ; CD30.2 v2(152.73,37) ; v2(236.64,86.13) 236.64,87.02 CG317.2 ; v2(160.16,155.68) 160.55,156.08 CT82.2 ; QE1.4 v2(258.59,46.38) ; 239.99,92.23 CG339.2 CG326.2 ; PR582.1 159.6,122.33 v2(158.83,122.33) ; CG100.2 183.68,130.11 v2(183.54,129.98) ; DU20.1 306.37,46.06 v2(306.76,45.67) ; JUSBC2.5 313.87,45.97 CU20.2 CU21.2 ; C4.2 v2(146.55,71.86) ; CG172.2 235.74,96.62 236.27,97.15 v2(236.65,97.15) 236.65,97.71 CG170.2 RG129.2 ; v2(47.13,3.52) 47.83,4.22 PC12.2 ; CG408.2 239.5,107.64 v2(239.56,107.58) 239.47,107.49 CG366.2 ; RA6.2 25.8,41.06 v2(26.61,40.25) ; PC802.2 161.89,150.91 161.65,151.15 161.62,151.15 v2(161.62,151.2) ; v2(187.54,140.38) 187.32,140.38 186.91,140.79 CG336.2 ; CE62.2 117.44,10.71 117.48,10.75 v2(117.58,10.75) ; RA7.2 18.09,14.06 v2(17.49,13.46) 17.41,13.55 15.93,13.55 v3(15.18,14.3) 13.35,16.13 13.35,19.96 13.98,20.6 13.98,22.08 11.85,24.22 9.18,24.22 8.86,24.54 JACK2.7 ; PD2.1 v2(58.54,4.53) ; v2(121.24,47.38) 120.68,47.38 120.34,47.72 CD5.2 ; CA38.2 v2(34.37,43.26) ; v2(57.15,5.16) PD3.1 ; CD80.2 129.25,27.73 v2(129.13,27.61) ; v2(107.74,40.41) 107.82,40.49 CD91.2 107.27,41.6 CD69.2 ; CH126.2 v2(141.44,72.34) ; PR572.1 113.06,127.5 112.72,127.17 v2(112.72,126.35) ; QE22.1 v2(176.9,153.73) ; PC6200.2 v2(211.72,32.73) ; v2(292.07,52.51) 292.07,51.84 292.43,51.48 CM12.2 ; CG240.2 193.58,79.08 v2(193.7,79.2) ; v2(67.84,62.51) CU29.2 ; v2(193.74,76.86) 194.26,76.86 194.69,76.43 CG385.2 194.92,76.48 CG322.2 ; RG57.2 235.52,108.19 CG405.2 235.54,108.83 v2(235.73,109.02) ; v2(95.12,43.51) 95.25,43.37 CD75.2 ; v2(241.08,120.37) 241.08,120.62 CG120.2 240.64,121.93 CG118.2 ; v2(83.58,11.83) CE43.2 ; RA1.2 v2(13.67,38.44) ; CT100.2 123.69,154.28 v2(122.99,154.28) ; PC8219.2 v2(244.73,75.7) ; v2(295.35,59.23) RM31.2 ; DU21.1 v2(301.26,34.7) ; CD9.2 v2(151.63,51.61) ; CD27.2 v2(152.73,38.08) ; v2(299.15,45.25) CU32.2 ; CH1.2 v2(316.37,78.45) ; PC502.2 v2(90.42,125.92)
  GND1 w0.203: JUSB1.7 13.42,46.69 ; JUSB1.7 13.42,45.51 ; JUSB1.7 12.83,46.86 ; JUSB1.7 13.59,46.1 ; JUSB1.7 12.83,45.34 ; JUSB1.7 12.24,46.69 ; JUSB1.7 12.24,45.51 ; JUSB1.7 12.07,46.1 ; H13.1 221.99,9.34 ; H13.1 220.65,9.83 ; H13.1 219.31,9.34 ; H13.1 221.99,6.66 ; H13.1 220.65,6.17 ; H13.1 222.48,8 ; H13.1 218.82,8 ; H13.1 219.31,6.66 ; JUSBC1.3 164.27,177 ; JUSBC1.3 162.62,177 ; JUSBC1.3 162.62,175.53 ; JUSBC1.3 164.27,175.53 ; JUSBC1.3 163.45,175.53 ; JUSBC1.3 162.62,178.47 ; JUSBC1.3 163.45,178.47 ; JUSBC1.3 164.27,178.47 ; 226.85,148.6 H3.1 ; H3.1 230.89,150.3 ; H3.1 230.25,152 ; H3.1 226.85,152 ; H3.1 228.55,152.64 ; H3.1 228.55,147.96 ; H3.1 230.25,148.6 ; H3.1 226.21,150.3 ; 317.18,38.81 JUSBC2.3 ; JUSBC2.3 320.12,37.15 ; JUSBC2.3 317.18,37.15 ; JUSBC2.3 318.65,37.15 ; JUSBC2.3 320.12,38.81 ; JUSBC2.3 318.65,38.81 ; JUSBC2.3 320.12,37.98 ; JUSBC2.3 317.18,37.98 ; JHDMI.5 180.1,168.33 ; JHDMI.5 180.1,167.17 ; JHDMI.5 180.56,167.29 ; JHDMI.5 180.56,168.21 ; JHDMI.5 179.64,167.29 ; JHDMI.5 179.64,168.21 ; 174.42,167.33 JHDMI.20 ; JHDMI.20 176.28,166.05 ; JHDMI.20 175.35,167.33 ; JHDMI.20 176.28,167.33 ; JHDMI.20 174.42,166.05 ; JHDMI.20 174.42,164.77 ; JHDMI.20 176.28,164.77 ; JHDMI.20 175.35,164.77 ; H25.1 239.88,166.33 ; H25.1 235.71,164.5 ; H25.1 237.8,162.67 ; H25.1 235.71,162.67 ; H25.1 239.88,164.5 ; H25.1 235.71,166.33 ; H25.1 237.8,166.33 ; H25.1 239.88,162.67 ; 157.7,85.5 H4.1 ; H4.1 157.7,82.1 ; H4.1 161.74,83.8 ; H4.1 159.4,81.46 ; H4.1 159.4,86.14 ; H4.1 161.1,85.5 ; H4.1 161.1,82.1 ; H4.1 157.06,83.8 ; 268.15,57.22 H28.1 ; H28.1 266.66,57.76 ; H28.1 269.64,57.76 ; H28.1 266.12,59.25 ; H28.1 270.18,59.25 ; H28.1 269.64,60.74 ; H28.1 268.15,61.28 ; H28.1 266.66,60.74 ; 10.99,40.56 JUSB1.11 ; JUSB1.11 12.74,38.84 ; JUSB1.11 12.74,40.56 ; JUSB1.11 14.49,39.7 ; JUSB1.11 10.99,39.7 ; JUSB1.11 14.49,38.84 ; JUSB1.11 10.99,38.84 ; JUSB1.11 14.49,40.56 ; 318.65,45.79 JUSBC2.1 ; JUSBC2.1 317.18,47.45 ; JUSBC2.1 317.18,46.62 ; JUSBC2.1 317.18,45.79 ; JUSBC2.1 318.65,47.45 ; JUSBC2.1 320.12,46.62 ; JUSBC2.1 320.12,45.79 ; JUSBC2.1 320.12,47.45 ; 22.32,6.5 H23.1 ; H23.1 24.15,4.67 ; H23.1 22.81,5.16 ; H23.1 24.15,8.33 ; H23.1 25.49,7.84 ; H23.1 22.81,7.84 ; H23.1 25.49,5.16 ; H23.1 25.98,6.5 ; JDP.13 202.49,165.48 ; JDP.13 202.49,166.4 ; JDP.13 202.02,165.36 ; JDP.13 201.56,165.48 ; JDP.13 202.02,166.52 ; JDP.13 201.56,166.4 ; JDP.13 201.44,165.94 ; JHDMI.2 178.6,166.78 ; JHDMI.2 178.14,166.66 ; JHDMI.2 178.02,166.2 ; JHDMI.2 178.14,165.74 ; JHDMI.2 179.06,165.74 ; JHDMI.2 178.6,165.62 ; JHDMI.2 179.06,166.66 ; 28.77,5.12 H21.1 ; H21.1 32.03,6.5 ; H21.1 28.27,6.5 ; H21.1 30.15,4.62 ; H21.1 30.15,8.38 ; H21.1 28.77,7.88 ; H21.1 31.53,5.12 ; H21.1 31.53,7.88 ; JHDMI.23 192.68,175.5 ; JHDMI.23 190.82,175.5 ; JHDMI.23 191.75,174.22 ; JHDMI.23 190.82,174.22 ; JHDMI.23 192.68,174.22 ; 157.8,74.48 H15.1 ; H15.1 161.46,74.48 ; H15.1 160.97,75.82 ; H15.1 158.29,73.14 ; H15.1 160.97,73.14 ; H15.1 159.63,72.65 ; H15.1 158.29,75.82 ; H15.1 159.63,76.31 ; JUSBC1.6 164.22,171.83 ; JUSBC1.6 164.22,172.55 ; JUSBC1.6 162.22,173.27 ; JUSBC1.6 164.22,173.27 ; JUSBC1.6 163.12,173.27 ; JUSBC1.6 162.22,171.83 ; JUSBC1.6 162.22,172.55 ; 229.82,167.5 H16.1 ; H16.1 232.99,166.16 ; H16.1 230.31,166.16 ; H16.1 231.65,165.67 ; H16.1 232.99,168.84 ; H16.1 233.48,167.5 ; H16.1 231.65,169.33 ; H16.1 230.31,168.84 ; 181.14,165.74 JHDMI.8 ; JHDMI.8 181.6,166.78 ; JHDMI.8 181.6,165.62 ; JHDMI.8 182.06,165.74 ; JHDMI.8 182.06,166.66 ; JHDMI.8 181.14,166.66 ; 154.81,170.62 JUSBC1.2 ; JUSBC1.2 154.81,173.28 ; JUSBC1.2 154.03,171.95 ; JUSBC1.2 154.03,170.62 ; JUSBC1.2 154.03,173.28 ; JUSBC1.2 155.58,173.28 ; JUSBC1.2 155.58,170.62 ; 48.52,53.79 H20.1 ; H20.1 48.03,55.13 ; H20.1 51.2,53.79 ; H20.1 51.69,55.13 ; H20.1 49.86,53.3 ; H20.1 48.52,56.47 ; H20.1 51.2,56.47 ; H20.1 49.86,56.96 ; H12.1 251.93,53.62 ; H12.1 251.44,54.96 ; H12.1 248.76,54.96 ; H12.1 250.1,51.79 ; H12.1 250.1,55.45 ; H12.1 248.27,53.62 ; H12.1 251.44,52.28 ; H12.1 248.76,52.28 ; 314.2,45.39 JUSBC2.5 ; JUSBC2.5 314.92,47.4 ; JUSBC2.5 314.92,46.29 ; JUSBC2.5 314.92,45.39 ; JUSBC2.5 313.48,47.4 ; JUSBC2.5 314.2,47.4 ; JUSBC2.5 313.48,45.39 ; H2.1 180.45,70.1 ; H2.1 181.09,68.4 ; H2.1 176.41,68.4 ; H2.1 177.05,66.7 ; H2.1 177.05,70.1 ; H2.1 180.45,66.7 ; H2.1 178.75,66.06 ; H2.1 178.75,70.74 ; 312.27,47.39 JUSBC2.2 ; JUSBC2.2 314.93,47.39 ; JUSBC2.2 312.27,46.62 ; JUSBC2.2 314.93,46.62 ; JUSBC2.2 312.27,45.84 ; JUSBC2.2 313.6,47.39 ; JUSBC2.2 314.93,45.84 ; 251.66,74.48 H27.1 ; H27.1 254.85,77.67 ; H27.1 258.04,74.48 ; H27.1 252.54,72.17 ; H27.1 254.85,71.29 ; H27.1 257.16,72.17 ; H27.1 257.16,76.78 ; H27.1 252.54,76.78 ; 314.8,60.87 JUSB2.13 ; JUSB2.13 313.47,60.87 ; JUSB2.13 316.13,61.75 ; JUSB2.13 313.47,61.75 ; JUSB2.13 316.13,60.87 ; JDP.21 206.52,171.41 ; JDP.21 207.3,170.1 ; JDP.21 205.75,171.41 ; JDP.21 205.75,168.79 ; JDP.21 207.3,171.41 ; JDP.21 206.52,168.79 ; JDP.21 205.75,170.1 ; JDP.21 207.3,168.79 ; 72.27,69.93 JPCMC.36 ; JPCMC.36 74.74,72.41 ; JPCMC.36 76.55,71.73 ; JPCMC.36 77.22,69.93 ; JPCMC.36 72.94,68.13 ; JPCMC.36 76.55,68.13 ; JHDMI.11 183.56,168.21 ; JHDMI.11 183.1,167.17 ; JHDMI.11 182.64,167.29 ; JHDMI.11 183.56,167.29 ; JHDMI.11 182.64,168.21 ; JHDMI.11 183.1,168.33 ; 312.76,50.26 H9.1 ; H9.1 315.93,51.6 ; H9.1 314.1,49.77 ; H9.1 314.1,53.43 ; H9.1 312.76,52.94 ; H9.1 312.27,51.6 ; H9.1 315.44,52.94 ; H9.1 315.44,50.26 ; JUSB2.4 305.57,73.93 ; JUSB2.4 304.93,73.73 ; JUSB2.4 306.2,72.46 ; JUSB2.4 304.93,72.46 ; JUSB2.4 305.57,72.27 ; JUSB2.4 304.74,73.1 ; JUSB1.12 14.49,53.36 ; JUSB1.12 12.74,53.36 ; JUSB1.12 14.49,52.5 ; JUSB1.12 14.49,51.64 ; JUSB1.12 10.99,53.36 ; JUSB1.12 10.99,52.5 ; JUSB1.12 10.99,51.64 ; JUSB1.12 12.74,51.64 ; 306.17,58 H26.1 ; H26.1 310.23,56.22 ; H26.1 308.2,56.22 ; H26.1 306.17,56.22 ; H26.1 310.23,58 ; H26.1 310.23,59.78 ; H26.1 306.17,59.78 ; H26.1 308.2,59.78 ; JCDRA.48 144.9,176.91 ; JCDRA.48 143.95,176.91 ; JCDRA.48 144.9,173.78 ; JCDRA.48 143.95,173.78 ; JCDRA.48 145.86,173.78 ; JCDRA.48 143.95,175.35 ; JUSBC1.4 164.22,173.28 ; JUSBC1.4 163.45,173.28 ; JUSBC1.4 164.22,171.95 ; JUSBC1.4 162.67,170.62 ; JUSBC1.4 164.22,170.62 ; JUSBC1.4 163.45,170.62 ; 108.51,166.84 H10.1 ; H10.1 108.02,165.5 ; H10.1 111.19,166.84 ; H10.1 109.85,163.67 ; H10.1 109.85,167.33 ; H10.1 108.51,164.16 ; H10.1 111.68,165.5 ; H10.1 111.19,164.16 ; JUSB1.4 15.09,42.6 ; JUSB1.4 13.74,43.19 ; JUSB1.4 13.74,42.01 ; JUSB1.4 14.33,43.36 ; JUSB1.4 14.33,41.84 ; JUSB1.4 14.92,43.19 ; JUSB1.4 13.57,42.6 ; JUSB1.4 14.92,42.01 ; JDP.19 204.19,166.68 ; JDP.19 203.73,167.72 ; JDP.19 203.26,167.6 ; JDP.19 204.19,167.6 ; JDP.19 203.26,166.68 ; JDP.19 203.73,166.55 ; JDP.19 204.31,167.14 ; 306.43,70.23 JUSB2.7 ; JUSB2.7 307.07,68.77 ; JUSB2.7 306.43,68.96 ; JUSB2.7 307.07,70.43 ; JUSB2.7 306.24,69.6 ; 306.22,77.45 JUSB2.11 ; JUSB2.11 309.78,78.33 ; JUSB2.11 306.22,78.33 ; JUSB2.11 308,78.33 ; JUSB2.11 306.22,76.57 ; JUSB2.11 309.78,77.45 ; H19.1 108.15,173.34 ; H19.1 106.53,171.51 ; H19.1 108.15,169.68 ; H19.1 109.78,169.68 ; H19.1 106.53,169.68 ; H19.1 109.78,171.51 ; H19.1 109.78,173.34 ; H19.1 106.53,173.34 ; 2.47,54 JUSB1.14 ; JUSB1.14 3.98,54.86 ; JUSB1.14 5.49,54.86 ; JUSB1.14 2.47,54.86 ; JUSB1.14 5.49,54 ; 88.7,83.7 H5.1 ; H5.1 90.4,87.74 ; H5.1 90.4,83.06 ; H5.1 92.1,83.7 ; H5.1 88.06,85.4 ; H5.1 92.74,85.4 ; H5.1 92.1,87.1 ; H5.1 88.7,87.1 ; 313.86,56.66 H11.1 ; H11.1 316.54,56.66 ; H11.1 313.37,58 ; H11.1 315.2,59.83 ; H11.1 315.2,56.17 ; H11.1 313.86,59.34 ; H11.1 317.03,58 ; H11.1 316.54,59.34 ; 314.1,31.17 H8.1 ; H8.1 315.44,34.34 ; H8.1 315.44,31.66 ; H8.1 314.1,34.83 ; H8.1 312.76,34.34 ; H8.1 315.93,33 ; H8.1 312.76,31.66 ; H8.1 312.27,33 ; H24.1 12.73,58 ; H24.1 9.73,59.27 ; H24.1 12.27,56.73 ; H24.1 12.27,59.27 ; H24.1 11,56.27 ; H24.1 9.73,56.73 ; H24.1 11,59.73 ; H24.1 9.27,58 ; H1.1 213.64,68.4 ; H1.1 208.96,68.4 ; H1.1 213,66.7 ; H1.1 209.6,70.1 ; H1.1 211.3,66.06 ; H1.1 213,70.1 ; H1.1 209.6,66.7 ; H1.1 211.3,70.74 ; 310.5,80.86 H30.1 ; H30.1 314.87,80.86 ; H30.1 314.87,82.84 ; H30.1 314.87,78.88 ; H30.1 312.69,82.84 ; H30.1 310.5,78.88 ; H30.1 312.69,78.88 ; JUSBC2.6 314.2,39.21 ; JUSBC2.6 314.92,37.2 ; JUSBC2.6 313.48,39.21 ; JUSBC2.6 314.92,38.3 ; JUSBC2.6 314.92,39.21 ; JUSBC2.6 313.48,37.2 ; JUSBC2.6 314.2,37.2 ; JCDRA.47 144.9,172.31 ; JCDRA.47 145.86,169.18 ; JCDRA.47 143.95,172.31 ; JCDRA.47 144.9,169.18 ; JCDRA.47 145.86,170.75 ; JCDRA.47 145.86,172.31 ; JCDRA.47 143.95,169.18 ; JCDRA.47 143.95,170.75 ; JUSBC2.4 314.93,37.98 ; JUSBC2.4 313.6,37.2 ; JUSBC2.4 312.27,37.98 ; JUSBC2.4 312.27,37.2 ; JUSBC2.4 312.27,38.75 ; JUSBC2.4 314.93,37.2 ; 305.96,37.29 H29.1 ; H29.1 307.45,37.83 ; H29.1 305.42,35.8 ; H29.1 305.96,34.31 ; H29.1 308.94,37.29 ; H29.1 309.48,35.8 ; H29.1 308.94,34.31 ; H29.1 307.45,33.77 ; 194.75,166.41 JDP.24 ; JDP.24 196.3,165.1 ; JDP.24 196.3,163.79 ; JDP.24 194.75,163.79 ; JDP.24 194.75,165.1 ; JDP.24 195.52,166.41 ; JDP.24 195.52,163.79 ; JUSBC1.1 155.63,178.47 ; JUSBC1.1 154.81,178.47 ; JUSBC1.1 155.63,177 ; JUSBC1.1 153.98,178.47 ; JUSBC1.1 153.98,177 ; JUSBC1.1 154.81,175.53 ; JUSBC1.1 155.63,175.53 ; JUSBC1.1 153.98,175.53 ; 112.75,145.6 H7.1 ; H7.1 112.11,147.3 ; H7.1 116.79,147.3 ; H7.1 116.15,149 ; H7.1 114.45,144.96 ; H7.1 112.75,149 ; H7.1 114.45,149.64 ; H7.1 116.15,145.6 ; 194.75,168.79 JDP.23 ; JDP.23 194.75,170.1 ; JDP.23 194.75,171.41 ; JDP.23 196.3,171.41 ; JDP.23 195.52,168.79 ; JDP.23 196.3,168.79 ; JDP.23 195.52,171.41 ; JDP.23 196.3,170.1 ; 169.25,144.1 H6.1 ; H6.1 170.95,143.46 ; H6.1 173.29,145.8 ; H6.1 172.65,147.5 ; H6.1 169.25,147.5 ; H6.1 168.61,145.8 ; H6.1 170.95,148.14 ; H6.1 172.65,144.1 ; H18.1 151.17,170.76 ; H18.1 151.65,172.1 ; H18.1 149.82,173.93 ; H18.1 148.48,170.76 ; H18.1 148,172.1 ; H18.1 148.48,173.44 ; H18.1 151.17,173.44 ; H18.1 149.82,170.27 ; JDP.7 200.49,165.48 ; JDP.7 200.03,166.52 ; JDP.7 199.56,166.4 ; JDP.7 200.49,166.4 ; JDP.7 200.03,165.36 ; JDP.7 200.61,165.94 ; JDP.7 199.56,165.48 ; JCDRA.50 113.36,169.18 ; JCDRA.50 113.36,170.75 ; JCDRA.50 112.4,172.31 ; JCDRA.50 112.4,169.18 ; JCDRA.50 111.45,170.75 ; JCDRA.50 113.36,172.31 ; JCDRA.50 111.45,169.18 ; JCDRA.50 111.45,172.31 ; 306.22,60.87 JUSB2.10 ; JUSB2.10 309.78,61.75 ; JUSB2.10 309.78,60.87 ; JUSB2.10 306.22,61.75 ; JUSB2.10 306.22,62.63 ; JUSB2.10 308,60.87 ; 197.74,167.14 JDP.1 ; JDP.1 198.79,167.6 ; JDP.1 198.79,166.68 ; JDP.1 197.86,166.68 ; JDP.1 198.32,167.72 ; JDP.1 198.32,166.55 ; JDP.1 197.86,167.6 ; 154.03,171.83 JUSBC1.5 ; JUSBC1.5 154.03,173.27 ; JUSBC1.5 156.03,172.55 ; JUSBC1.5 155.13,173.27 ; JUSBC1.5 156.03,171.83 ; JUSBC1.5 154.03,172.55 ; JUSBC1.5 156.03,173.27 ; H17.1 169.77,173.44 ; H17.1 166.6,172.1 ; H17.1 167.08,170.76 ; H17.1 169.77,170.76 ; H17.1 168.42,173.93 ; H17.1 170.25,172.1 ; H17.1 167.08,173.44 ; H17.1 168.42,170.27 ; JDP.22 207.3,165.1 ; JDP.22 205.75,163.79 ; JDP.22 205.75,165.1 ; JDP.22 207.3,166.41 ; JDP.22 206.52,166.41 ; JDP.22 206.52,163.79 ; 208.83,169.65 JLAN.16 ; JLAN.16 209.74,169.65 ; JLAN.16 209.74,173.16 ; JLAN.16 207.91,169.65 ; JLAN.16 207.91,171.4 ; JLAN.16 209.74,171.4 ; JLAN.16 208.83,173.16 ; JLAN.16 207.91,173.16 ; JUSB1.13 5.49,38.2 ; JUSB1.13 2.47,38.2 ; JUSB1.13 2.47,37.34 ; JUSB1.13 3.98,37.34 ; JUSB1.13 5.49,37.34 ; JLAN.14 228.79,171.4 ; JLAN.14 227.88,169.65 ; JLAN.14 226.96,171.4 ; JLAN.14 227.88,173.16 ; JLAN.14 226.96,169.65 ; JLAN.14 226.96,173.16 ; JLAN.14 228.79,169.65 ; 185.64,168.21 JHDMI.17 ; JHDMI.17 186.1,167.17 ; JHDMI.17 186.56,168.21 ; JHDMI.17 186.56,167.29 ; JHDMI.17 186.1,168.33 ; JHDMI.17 185.64,167.29 ; 172.52,172.97 JHDMI.21 ; JHDMI.21 174.38,172.97 ; JHDMI.21 173.45,175.53 ; JHDMI.21 174.38,174.25 ; JHDMI.21 173.45,172.97 ; JHDMI.21 172.52,174.25 ; 2.66,59.34 H22.1 ; H22.1 5.83,58 ; H22.1 2.66,56.66 ; H22.1 5.34,59.34 ; H22.1 4,56.17 ; H22.1 5.34,56.66 ; H22.1 4,59.83 ; H22.1 2.17,58 ; 189.85,164.77 JHDMI.22 ; JHDMI.22 190.78,166.05 ; JHDMI.22 189.85,167.33 ; JHDMI.22 188.92,166.05 ; JHDMI.22 190.78,164.77 ; JHDMI.22 190.78,167.33 ; JHDMI.22 188.92,167.33 ; JHDMI.22 188.92,164.77 ; H14.1 159.79,5.96 ; H14.1 157.11,8.64 ; H14.1 160.28,7.3 ; H14.1 157.11,5.96 ; H14.1 159.79,8.64 ; H14.1 158.45,9.13 ; H14.1 156.62,7.3 ; H14.1 158.45,5.47 ; 313.47,78.33 JUSB2.12 ; JUSB2.12 316.13,78.33 ; JUSB2.12 316.13,77.45 ; JUSB2.12 313.47,77.45 ; JUSB2.12 314.8,78.33 ; 111.45,175.35 JCDRA.49 ; JCDRA.49 113.36,176.91 ; JCDRA.49 112.4,173.78 ; JCDRA.49 113.36,175.35 ; JCDRA.49 112.4,176.91 ; JCDRA.49 113.36,173.78 ; JCDRA.49 111.45,176.91 ; JCDRA.49 111.45,173.78
  IN1 w0.1: 210.63,100.65 210.63,100.65 210.97,100.65
  IN1 w0.15: v2(196.9,112.15) 196.9,112.07 197.2,111.78 197.2,111.23 196.9,110.94 v2(196.9,110.75) ; v2(210.89,96.18) 210.62,96.45 209.7,96.45 v2(209.4,96.75) ; 210.63,100.65 210.47,100.65 v2(210.18,100.36) ; v2(207.79,81.08) 207.9,81.2 v2(207.9,82.22) 207.7,82.42 UG9.K6 v2(207.4,83.45) 207.7,83.75 207.7,84.45 ; v2(207,98.55) 208.5,98.55 208.64,98.69 v2(208.64,98.73) 209.01,98.73 209.19,98.55 209.33,98.55 209.33,98.55 209.67,98.55 209.67,98.55 209.75,98.55 v2(209.96,98.75) ; v2(209.55,109.23) 209.41,109.09 208.59,109.09 v2(208.51,109.17) ; v2(207.4,84.85) UG9.K8 207.7,84.45 ; v2(191.2,112.15) 190.9,111.85 190.9,111.11 v2(190.7,110.92) ; v2(212.67,98.47) 212.57,98.58 211.64,98.58 v2(211.5,98.72) 211.03,98.25 v2(210.8,98.25) ; 207.7,84.45 207.97,84.72 v2(208.17,84.72) ; v2(211.02,84.1) 211.02,84.08 v2(211.48,83.61) 211.74,83.61 v2(212.27,84.14) 212.85,83.56 v2(212.89,83.56) 213.2,83.87 213.98,83.87 v2(214.25,83.6) 214.57,83.92 215.56,83.92 v2(215.68,83.8) ; v2(211.5,103.03) 211.38,103.03 v2(210.94,102.59) 210.76,102.59 v2(210.2,103.15) 209.85,103.15 v2(209.62,102.92) 208.93,102.92 v2(208.78,103.07) 208.02,103.07 v2(208,103.05) ; v2(194.8,110.75) 194.8,110.97 v2(195.25,111.42) 195.1,111.57 195.1,112.55 v2(195.22,112.67) ; v2(212.86,100.55) 212.66,100.35 v2(212.3,100.35) 211.85,100.8 v2(211.35,100.8) 211.12,100.8 210.97,100.65
  IN1 w0.2: v2(210.97,107.18) 210.97,107.17 210.97,106.79 210.85,106.67 v2(210.85,106.62) ; v2(203.8,112.25) 203.35,112.7 v2(203.3,112.7)
  IN1 w0.25: v2(209.55,109.23) 210.08,109.23 v2(210.2,109.35) 210.7,109.35 v2(210.8,109.45) 210.8,108.79 v2(210.85,108.74) ; v2(210.8,98.25) 210.3,98.75 v2(209.96,98.75) ; v2(196.9,110.75) 197.38,110.27 v2(197.38,110) 197.6,109.78 v2(197.6,109.45) 197.57,109.42 v2(196.9,109.42) ; v2(212.75,96.3) 212.56,96.11 v2(212.19,96.11) 211.65,96.65 v2(211.36,96.65) ; v2(208.78,110.35) 208.78,110.59 209.02,110.83 209.52,110.83 v2(210.11,111.42) 210.26,111.42 v2(210.85,110.82) ; v2(197.5,112.15) v2(196.9,112.15)
  IN1 w0.3: v2(208.78,110.35) 208.38,109.95 208.38,109.3 v2(208.51,109.17) ; v2(208.07,96.14) 208.08,96.15 v2(208.8,96.15) v2(209.4,96.75)
  IN1 w0.508: v2(205.31,161.95) 205.67,161.95 206.2,161.42 206.2,160.11 v2(206.77,159.54)
  GND2 w0.203: 108.51,166.84 H10.1 ; H10.1 111.68,165.5 ; H10.1 109.85,163.67 ; H10.1 111.19,164.16 ; H10.1 108.51,164.16 ; H10.1 109.85,167.33 ; H10.1 108.02,165.5 ; H10.1 111.19,166.84 ; JPCMC.36 76.55,71.73 ; JPCMC.36 72.94,68.13 ; JPCMC.36 76.55,68.13 ; JPCMC.36 74.74,72.41 ; JPCMC.36 77.22,69.93 ; JPCMC.36 72.27,69.93 ; JUSBC1.2 155.58,170.62 ; JUSBC1.2 154.81,173.28 ; JUSBC1.2 155.58,173.28 ; JUSBC1.2 154.03,173.28 ; JUSBC1.2 154.03,170.62 ; JUSBC1.2 154.03,171.95 ; JUSBC1.2 154.81,170.62 ; 167.08,173.44 H17.1 ; H17.1 170.25,172.1 ; H17.1 168.42,173.93 ; H17.1 167.08,170.76 ; H17.1 168.42,170.27 ; H17.1 169.77,173.44 ; H17.1 169.77,170.76 ; H17.1 166.6,172.1 ; 314.2,45.39 JUSBC2.5 ; JUSBC2.5 313.48,47.4 ; JUSBC2.5 314.92,46.29 ; JUSBC2.5 314.92,47.4 ; JUSBC2.5 313.48,45.39 ; JUSBC2.5 314.2,47.4 ; JUSBC2.5 314.92,45.39 ; JCDRA.47 145.86,170.75 ; JCDRA.47 143.95,170.75 ; JCDRA.47 144.9,172.31 ; JCDRA.47 143.95,169.18 ; JCDRA.47 143.95,172.31 ; JCDRA.47 145.86,169.18 ; JCDRA.47 145.86,172.31 ; JCDRA.47 144.9,169.18 ; H13.1 221.99,9.34 ; H13.1 219.31,9.34 ; H13.1 220.65,9.83 ; H13.1 221.99,6.66 ; H13.1 220.65,6.17 ; H13.1 219.31,6.66 ; H13.1 218.82,8 ; H13.1 222.48,8 ; H4.1 159.4,86.14 ; H4.1 157.7,85.5 ; H4.1 157.7,82.1 ; H4.1 159.4,81.46 ; H4.1 157.06,83.8 ; H4.1 161.74,83.8 ; H4.1 161.1,85.5 ; H4.1 161.1,82.1 ; JHDMI.20 175.35,167.33 ; JHDMI.20 174.42,167.33 ; JHDMI.20 175.35,164.77 ; JHDMI.20 174.42,166.05 ; JHDMI.20 176.28,166.05 ; JHDMI.20 176.28,164.77 ; JHDMI.20 176.28,167.33 ; JHDMI.20 174.42,164.77 ; 308,60.87 JUSB2.10 ; JUSB2.10 306.22,62.63 ; JUSB2.10 306.22,61.75 ; JUSB2.10 309.78,60.87 ; JUSB2.10 306.22,60.87 ; JUSB2.10 309.78,61.75 ; H11.1 315.2,59.83 ; H11.1 316.54,56.66 ; H11.1 313.86,59.34 ; H11.1 316.54,59.34 ; H11.1 315.2,56.17 ; H11.1 317.03,58 ; H11.1 313.37,58 ; H11.1 313.86,56.66 ; 205.75,168.79 JDP.21 ; JDP.21 205.75,171.41 ; JDP.21 205.75,170.1 ; JDP.21 207.3,171.41 ; JDP.21 207.3,168.79 ; JDP.21 206.52,168.79 ; JDP.21 206.52,171.41 ; JDP.21 207.3,170.1 ; 88.7,83.7 H5.1 ; H5.1 92.1,83.7 ; H5.1 92.1,87.1 ; H5.1 88.06,85.4 ; H5.1 90.4,83.06 ; H5.1 92.74,85.4 ; H5.1 88.7,87.1 ; H5.1 90.4,87.74 ; 11,56.27 H24.1 ; H24.1 9.73,56.73 ; H24.1 12.27,56.73 ; H24.1 12.27,59.27 ; H24.1 12.73,58 ; H24.1 11,59.73 ; H24.1 9.27,58 ; H24.1 9.73,59.27 ; JUSB1.12 14.49,53.36 ; JUSB1.12 10.99,53.36 ; JUSB1.12 12.74,51.64 ; JUSB1.12 14.49,52.5 ; JUSB1.12 10.99,52.5 ; JUSB1.12 14.49,51.64 ; JUSB1.12 12.74,53.36 ; JUSB1.12 10.99,51.64 ; 226.96,173.16 JLAN.14 ; JLAN.14 228.79,171.4 ; JLAN.14 226.96,169.65 ; JLAN.14 226.96,171.4 ; JLAN.14 227.88,173.16 ; JLAN.14 228.79,169.65 ; JLAN.14 227.88,169.65 ; H3.1 228.55,152.64 ; H3.1 226.21,150.3 ; H3.1 230.89,150.3 ; H3.1 226.85,152 ; H3.1 230.25,152 ; H3.1 230.25,148.6 ; H3.1 226.85,148.6 ; H3.1 228.55,147.96 ; 179.64,167.29 JHDMI.5 ; JHDMI.5 180.1,167.17 ; JHDMI.5 179.64,168.21 ; JHDMI.5 180.56,167.29 ; JHDMI.5 180.56,168.21 ; JHDMI.5 180.1,168.33 ; JUSB1.4 15.09,42.6 ; JUSB1.4 14.33,43.36 ; JUSB1.4 13.57,42.6 ; JUSB1.4 14.92,43.19 ; JUSB1.4 14.33,41.84 ; JUSB1.4 13.74,43.19 ; JUSB1.4 14.92,42.01 ; JUSB1.4 13.74,42.01 ; H26.1 310.23,59.78 ; H26.1 306.17,59.78 ; H26.1 308.2,59.78 ; H26.1 306.17,58 ; H26.1 310.23,58 ; H26.1 308.2,56.22 ; H26.1 310.23,56.22 ; H26.1 306.17,56.22 ; JUSBC1.3 164.27,178.47 ; JUSBC1.3 163.45,178.47 ; JUSBC1.3 164.27,175.53 ; JUSBC1.3 164.27,177 ; JUSBC1.3 162.62,175.53 ; JUSBC1.3 162.62,177 ; JUSBC1.3 163.45,175.53 ; JUSBC1.3 162.62,178.47 ; H25.1 239.88,166.33 ; H25.1 237.8,162.67 ; H25.1 235.71,162.67 ; H25.1 235.71,166.33 ; H25.1 239.88,164.5 ; H25.1 237.8,166.33 ; H25.1 235.71,164.5 ; H25.1 239.88,162.67 ; 12.83,45.34 JUSB1.7 ; JUSB1.7 12.24,46.69 ; JUSB1.7 12.24,45.51 ; JUSB1.7 13.42,46.69 ; JUSB1.7 13.59,46.1 ; JUSB1.7 13.42,45.51 ; JUSB1.7 12.83,46.86 ; JUSB1.7 12.07,46.1 ; H2.1 180.45,70.1 ; H2.1 181.09,68.4 ; H2.1 177.05,66.7 ; H2.1 176.41,68.4 ; H2.1 180.45,66.7 ; H2.1 178.75,70.74 ; H2.1 177.05,70.1 ; H2.1 178.75,66.06 ; H6.1 172.65,144.1 ; H6.1 168.61,145.8 ; H6.1 169.25,147.5 ; H6.1 170.95,143.46 ; H6.1 169.25,144.1 ; H6.1 173.29,145.8 ; H6.1 170.95,148.14 ; H6.1 172.65,147.5 ; JUSBC2.4 314.93,37.98 ; JUSBC2.4 314.93,37.2 ; JUSBC2.4 312.27,37.2 ; JUSBC2.4 313.6,37.2 ; JUSBC2.4 312.27,38.75 ; JUSBC2.4 312.27,37.98 ; 112.75,145.6 H7.1 ; H7.1 116.15,145.6 ; H7.1 114.45,149.64 ; H7.1 112.75,149 ; H7.1 114.45,144.96 ; H7.1 112.11,147.3 ; H7.1 116.15,149 ; H7.1 116.79,147.3 ; JUSBC1.1 155.63,175.53 ; JUSBC1.1 153.98,175.53 ; JUSBC1.1 153.98,177 ; JUSBC1.1 154.81,178.47 ; JUSBC1.1 155.63,177 ; JUSBC1.1 154.81,175.53 ; JUSBC1.1 153.98,178.47 ; JUSBC1.1 155.63,178.47 ; 313.47,77.45 JUSB2.12 ; JUSB2.12 316.13,78.33 ; JUSB2.12 314.8,78.33 ; JUSB2.12 313.47,78.33 ; JUSB2.12 316.13,77.45 ; 304.93,72.46 JUSB2.4 ; JUSB2.4 305.57,72.27 ; JUSB2.4 304.74,73.1 ; JUSB2.4 306.2,72.46 ; JUSB2.4 304.93,73.73 ; JUSB2.4 305.57,73.93 ; H23.1 25.49,5.16 ; H23.1 22.81,5.16 ; H23.1 25.98,6.5 ; H23.1 24.15,4.67 ; H23.1 22.81,7.84 ; H23.1 24.15,8.33 ; H23.1 22.32,6.5 ; H23.1 25.49,7.84 ; JHDMI.23 192.68,175.5 ; JHDMI.23 190.82,174.22 ; JHDMI.23 190.82,175.5 ; JHDMI.23 192.68,174.22 ; JHDMI.23 191.75,174.22 ; JUSB1.11 14.49,39.7 ; JUSB1.11 12.74,40.56 ; JUSB1.11 12.74,38.84 ; JUSB1.11 10.99,40.56 ; JUSB1.11 14.49,38.84 ; JUSB1.11 10.99,39.7 ; JUSB1.11 14.49,40.56 ; JUSB1.11 10.99,38.84 ; 305.96,34.31 H29.1 ; H29.1 305.42,35.8 ; H29.1 307.45,37.83 ; H29.1 309.48,35.8 ; H29.1 308.94,37.29 ; H29.1 308.94,34.31 ; H29.1 307.45,33.77 ; H29.1 305.96,37.29 ; 111.45,175.35 JCDRA.49 ; JCDRA.49 113.36,176.91 ; JCDRA.49 113.36,175.35 ; JCDRA.49 113.36,173.78 ; JCDRA.49 111.45,176.91 ; JCDRA.49 112.4,173.78 ; JCDRA.49 112.4,176.91 ; JCDRA.49 111.45,173.78 ; 172.52,172.97 JHDMI.21 ; JHDMI.21 172.52,174.25 ; JHDMI.21 174.38,174.25 ; JHDMI.21 173.45,175.53 ; JHDMI.21 173.45,172.97 ; JHDMI.21 174.38,172.97 ; H21.1 31.53,5.12 ; H21.1 31.53,7.88 ; H21.1 30.15,8.38 ; H21.1 28.77,5.12 ; H21.1 32.03,6.5 ; H21.1 28.77,7.88 ; H21.1 30.15,4.62 ; H21.1 28.27,6.5 ; H28.1 270.18,59.25 ; H28.1 266.66,60.74 ; H28.1 269.64,57.76 ; H28.1 268.15,61.28 ; H28.1 269.64,60.74 ; H28.1 266.12,59.25 ; H28.1 268.15,57.22 ; H28.1 266.66,57.76 ; 306.24,69.6 JUSB2.7 ; JUSB2.7 306.43,68.96 ; JUSB2.7 307.07,70.43 ; JUSB2.7 307.07,68.77 ; JUSB2.7 306.43,70.23 ; 314.1,49.77 H9.1 ; H9.1 315.44,52.94 ; H9.1 312.76,50.26 ; H9.1 315.44,50.26 ; H9.1 312.27,51.6 ; H9.1 315.93,51.6 ; H9.1 314.1,53.43 ; H9.1 312.76,52.94 ; H16.1 233.48,167.5 ; H16.1 230.31,168.84 ; H16.1 232.99,166.16 ; H16.1 229.82,167.5 ; H16.1 231.65,169.33 ; H16.1 231.65,165.67 ; H16.1 232.99,168.84 ; H16.1 230.31,166.16 ; H18.1 149.82,173.93 ; H18.1 148.48,170.76 ; H18.1 148.48,173.44 ; H18.1 151.65,172.1 ; H18.1 151.17,173.44 ; H18.1 148,172.1 ; H18.1 149.82,170.27 ; H18.1 151.17,170.76 ; 314.8,60.87 JUSB2.13 ; JUSB2.13 313.47,61.75 ; JUSB2.13 313.47,60.87 ; JUSB2.13 316.13,60.87 ; JUSB2.13 316.13,61.75 ; 188.92,166.05 JHDMI.22 ; JHDMI.22 190.78,166.05 ; JHDMI.22 190.78,164.77 ; JHDMI.22 188.92,167.33 ; JHDMI.22 189.85,164.77 ; JHDMI.22 189.85,167.33 ; JHDMI.22 188.92,164.77 ; JHDMI.22 190.78,167.33 ; H30.1 312.69,82.84 ; H30.1 314.87,82.84 ; H30.1 310.5,80.86 ; H30.1 314.87,80.86 ; H30.1 314.87,78.88 ; H30.1 312.69,78.88 ; H30.1 310.5,78.88 ; JUSBC1.6 164.22,173.27 ; JUSBC1.6 162.22,172.55 ; JUSBC1.6 162.22,173.27 ; JUSBC1.6 163.12,173.27 ; JUSBC1.6 164.22,172.55 ; JUSBC1.6 162.22,171.83 ; JUSBC1.6 164.22,171.83 ; 312.76,31.66 H8.1 ; H8.1 312.76,34.34 ; H8.1 315.93,33 ; H8.1 315.44,31.66 ; H8.1 314.1,34.83 ; H8.1 314.1,31.17 ; H8.1 315.44,34.34 ; H8.1 312.27,33 ; H27.1 258.04,74.48 ; H27.1 254.85,71.29 ; H27.1 252.54,72.17 ; H27.1 257.16,76.78 ; H27.1 257.16,72.17 ; H27.1 251.66,74.48 ; H27.1 254.85,77.67 ; H27.1 252.54,76.78 ; H20.1 51.69,55.13 ; H20.1 51.2,53.79 ; H20.1 48.52,56.47 ; H20.1 49.86,56.96 ; H20.1 48.52,53.79 ; H20.1 48.03,55.13 ; H20.1 49.86,53.3 ; H20.1 51.2,56.47 ; 194.75,170.1 JDP.23 ; JDP.23 196.3,168.79 ; JDP.23 194.75,168.79 ; JDP.23 196.3,170.1 ; JDP.23 195.52,171.41 ; JDP.23 195.52,168.79 ; JDP.23 194.75,171.41 ; JDP.23 196.3,171.41 ; JUSB2.11 309.78,77.45 ; JUSB2.11 309.78,78.33 ; JUSB2.11 306.22,76.57 ; JUSB2.11 306.22,77.45 ; JUSB2.11 306.22,78.33 ; JUSB2.11 308,78.33 ; H12.1 251.44,52.28 ; H12.1 250.1,55.45 ; H12.1 250.1,51.79 ; H12.1 248.76,54.96 ; H12.1 251.93,53.62 ; H12.1 251.44,54.96 ; H12.1 248.76,52.28 ; H12.1 248.27,53.62 ; JDP.7 200.03,166.52 ; JDP.7 200.49,165.48 ; JDP.7 199.56,166.4 ; JDP.7 200.61,165.94 ; JDP.7 200.03,165.36 ; JDP.7 199.56,165.48 ; JDP.7 200.49,166.4 ; 312.27,45.84 JUSBC2.2 ; JUSBC2.2 312.27,47.39 ; JUSBC2.2 312.27,46.62 ; JUSBC2.2 314.93,47.39 ; JUSBC2.2 314.93,45.84 ; JUSBC2.2 314.93,46.62 ; JUSBC2.2 313.6,47.39 ; JDP.1 198.79,166.68 ; JDP.1 198.32,167.72 ; JDP.1 197.86,166.68 ; JDP.1 197.74,167.14 ; JDP.1 198.79,167.6 ; JDP.1 197.86,167.6 ; JDP.1 198.32,166.55 ; 111.45,170.75 JCDRA.50 ; JCDRA.50 112.4,169.18 ; JCDRA.50 111.45,172.31 ; JCDRA.50 113.36,172.31 ; JCDRA.50 112.4,172.31 ; JCDRA.50 113.36,170.75 ; JCDRA.50 113.36,169.18 ; JCDRA.50 111.45,169.18 ; 207.91,169.65 JLAN.16 ; JLAN.16 209.74,171.4 ; JLAN.16 207.91,171.4 ; JLAN.16 208.83,173.16 ; JLAN.16 208.83,169.65 ; JLAN.16 209.74,173.16 ; JLAN.16 209.74,169.65 ; JLAN.16 207.91,173.16 ; JHDMI.17 186.56,168.21 ; JHDMI.17 186.56,167.29 ; JHDMI.17 186.1,167.17 ; JHDMI.17 185.64,168.21 ; JHDMI.17 185.64,167.29 ; JHDMI.17 186.1,168.33 ; JCDRA.48 145.86,173.78 ; JCDRA.48 143.95,175.35 ; JCDRA.48 143.95,173.78 ; JCDRA.48 144.9,173.78 ; JCDRA.48 144.9,176.91 ; JCDRA.48 143.95,176.91 ; JUSBC2.1 320.12,47.45 ; JUSBC2.1 317.18,45.79 ; JUSBC2.1 320.12,45.79 ; JUSBC2.1 318.65,45.79 ; JUSBC2.1 317.18,46.62 ; JUSBC2.1 320.12,46.62 ; JUSBC2.1 318.65,47.45 ; JUSBC2.1 317.18,47.45 ; H22.1 5.83,58 ; H22.1 2.66,56.66 ; H22.1 5.34,56.66 ; H22.1 5.34,59.34 ; H22.1 2.17,58 ; H22.1 4,59.83 ; H22.1 2.66,59.34 ; H22.1 4,56.17 ; JUSBC1.4 164.22,171.95 ; JUSBC1.4 164.22,170.62 ; JUSBC1.4 162.67,170.62 ; JUSBC1.4 163.45,170.62 ; JUSBC1.4 164.22,173.28 ; JUSBC1.4 163.45,173.28 ; 202.02,165.36 JDP.13 ; JDP.13 202.49,166.4 ; JDP.13 202.02,166.52 ; JDP.13 201.56,166.4 ; JDP.13 202.49,165.48 ; JDP.13 201.56,165.48 ; JDP.13 201.44,165.94 ; H15.1 161.46,74.48 ; H15.1 160.97,75.82 ; H15.1 158.29,75.82 ; H15.1 159.63,72.65 ; H15.1 158.29,73.14 ; H15.1 160.97,73.14 ; H15.1 157.8,74.48 ; H15.1 159.63,76.31 ; H14.1 158.45,9.13 ; H14.1 157.11,8.64 ; H14.1 159.79,5.96 ; H14.1 160.28,7.3 ; H14.1 159.79,8.64 ; H14.1 156.62,7.3 ; H14.1 158.45,5.47 ; H14.1 157.11,5.96 ; JHDMI.8 181.6,166.78 ; JHDMI.8 181.14,166.66 ; JHDMI.8 181.6,165.62 ; JHDMI.8 182.06,166.66 ; JHDMI.8 182.06,165.74 ; JHDMI.8 181.14,165.74 ; JUSBC1.5 155.13,173.27 ; JUSBC1.5 154.03,173.27 ; JUSBC1.5 156.03,171.83 ; JUSBC1.5 154.03,172.55 ; JUSBC1.5 154.03,171.83 ; JUSBC1.5 156.03,172.55 ; JUSBC1.5 156.03,173.27 ; 182.64,168.21 JHDMI.11 ; JHDMI.11 183.56,167.29 ; JHDMI.11 182.64,167.29 ; JHDMI.11 183.1,167.17 ; JHDMI.11 183.1,168.33 ; JHDMI.11 183.56,168.21 ; 3.98,37.34 JUSB1.13 ; JUSB1.13 5.49,38.2 ; JUSB1.13 2.47,37.34 ; JUSB1.13 5.49,37.34 ; JUSB1.13 2.47,38.2 ; JUSBC2.3 318.65,38.81 ; JUSBC2.3 320.12,38.81 ; JUSBC2.3 320.12,37.15 ; JUSBC2.3 318.65,37.15 ; JUSBC2.3 320.12,37.98 ; JUSBC2.3 317.18,37.15 ; JUSBC2.3 317.18,37.98 ; JUSBC2.3 317.18,38.81 ; JUSB1.14 5.49,54.86 ; JUSB1.14 3.98,54.86 ; JUSB1.14 2.47,54 ; JUSB1.14 2.47,54.86 ; JUSB1.14 5.49,54 ; 194.75,166.41 JDP.24 ; JDP.24 196.3,163.79 ; JDP.24 194.75,165.1 ; JDP.24 196.3,165.1 ; JDP.24 195.52,163.79 ; JDP.24 194.75,163.79 ; JDP.24 195.52,166.41 ; 203.73,166.55 JDP.19 ; JDP.19 204.31,167.14 ; JDP.19 204.19,166.68 ; JDP.19 203.26,167.6 ; JDP.19 203.73,167.72 ; JDP.19 203.26,166.68 ; JDP.19 204.19,167.6 ; JUSBC2.6 314.92,39.21 ; JUSBC2.6 314.2,39.21 ; JUSBC2.6 314.2,37.2 ; JUSBC2.6 314.92,37.2 ; JUSBC2.6 314.92,38.3 ; JUSBC2.6 313.48,39.21 ; JUSBC2.6 313.48,37.2 ; 178.6,165.62 JHDMI.2 ; JHDMI.2 178.14,166.66 ; JHDMI.2 179.06,165.74 ; JHDMI.2 179.06,166.66 ; JHDMI.2 178.14,165.74 ; JHDMI.2 178.02,166.2 ; JHDMI.2 178.6,166.78 ; JDP.22 207.3,165.1 ; JDP.22 207.3,166.41 ; JDP.22 206.52,166.41 ; JDP.22 205.75,165.1 ; JDP.22 205.75,163.79 ; JDP.22 206.52,163.79 ; H19.1 109.78,169.68 ; H19.1 109.78,171.51 ; H19.1 106.53,173.34 ; H19.1 106.53,171.51 ; H19.1 106.53,169.68 ; H19.1 108.15,173.34 ; H19.1 108.15,169.68 ; H19.1 109.78,173.34
  VCC w0.203: JHDMI.20 176.28,164.77 ; JHDMI.20 174.42,164.77 ; JHDMI.20 174.42,166.05 ; JHDMI.20 175.35,164.77 ; JHDMI.20 176.28,166.05 ; JUSBC1.2 154.81,173.28 ; JUSBC1.2 154.81,170.62 ; JUSBC1.2 154.03,173.28 ; JUSBC1.2 155.58,170.62 ; JUSBC1.2 154.03,171.95 ; JUSBC1.2 155.58,173.28 ; JUSBC1.2 154.03,170.62 ; 313.47,60.87 JUSB2.13 ; JUSB2.13 314.8,60.87 ; JUSB2.13 316.13,60.87 ; 194.75,171.41 JDP.23 ; JDP.23 194.75,170.1 ; JDP.23 194.75,168.79 ; 313.48,45.39 JUSBC2.5 ; JUSBC2.5 314.92,46.29 ; JUSBC2.5 314.92,47.4 ; JUSBC2.5 314.2,47.4 ; JUSBC2.5 314.2,45.39 ; JUSBC2.5 314.92,45.39 ; JUSBC2.5 313.48,47.4 ; JUSBC1.4 164.22,170.62 ; JUSBC1.4 164.22,171.95 ; JUSBC1.4 163.45,173.28 ; JUSBC1.4 163.45,170.62 ; JUSBC1.4 162.67,170.62 ; JUSBC1.4 164.22,173.28 ; 186.1,167.17 JHDMI.17 ; JHDMI.17 185.64,167.29 ; JHDMI.17 186.56,167.29 ; 191.75,174.22 JHDMI.23 ; JHDMI.23 192.21,174.22 ; JHDMI.23 192.68,174.22 ; JDP.13 202.49,166.4 ; JDP.13 202.02,166.52 ; JDP.13 201.56,165.48 ; JDP.13 202.02,165.36 ; JDP.13 201.44,165.94 ; JDP.13 201.56,166.4 ; JDP.13 202.49,165.48 ; 317.18,37.98 JUSBC2.3 ; JUSBC2.3 317.18,38.81 ; JUSBC2.3 318.65,38.81 ; 208.83,169.65 JLAN.16 ; JLAN.16 207.91,169.65 ; JLAN.16 208.83,173.16 ; JLAN.16 207.91,171.4 ; 198.32,166.55 JDP.1 ; JDP.1 198.79,166.68 ; JDP.1 198.79,167.6 ; JDP.1 197.86,166.68 ; JDP.1 197.86,167.6 ; JDP.1 197.74,167.14 ; JDP.1 198.32,167.72 ; JDP.21 207.3,170.1 ; JDP.21 207.3,168.79 ; JDP.21 207.3,171.41 ; JUSB1.4 14.33,43.36 ; JUSB1.4 14.33,41.84 ; JUSB1.4 13.57,42.6 ; JUSB1.4 15.09,42.6 ; JUSB1.4 13.74,43.19 ; JUSB1.4 13.74,42.01 ; JUSB1.4 14.92,43.19 ; JUSB1.4 14.92,42.01 ; H28.1 270.18,59.25 ; H28.1 268.15,61.28 ; H28.1 266.66,60.74 ; H28.1 269.64,60.74 ; H28.1 266.12,59.25 ; H28.1 268.15,57.22 ; H28.1 269.64,57.76 ; H28.1 266.66,57.76 ; 194.75,163.79 JDP.24 ; JDP.24 196.3,163.79 ; JDP.24 195.52,166.41 ; JDP.24 195.52,163.79 ; JDP.24 194.75,165.1 ; JDP.24 196.3,165.1 ; JDP.24 194.75,166.41 ; JUSBC2.4 314.93,37.2 ; JUSBC2.4 312.27,37.2 ; JUSBC2.4 312.27,37.98 ; JUSBC2.4 312.27,38.75 ; JUSBC2.4 314.93,37.98 ; JUSBC2.4 313.6,37.2 ; 313.86,56.66 H11.1 ; H11.1 313.37,58 ; H11.1 315.2,56.17 ; H11.1 313.86,59.34 ; H11.1 315.2,59.83 ; H11.1 316.54,56.66 ; H11.1 316.54,59.34 ; 163.45,175.53 JUSBC1.3 ; JUSBC1.3 162.62,175.53 ; JUSBC1.3 162.62,177 ; 312.76,31.66 H8.1 ; H8.1 312.76,34.34 ; H8.1 315.44,31.66 ; H8.1 312.27,33 ; H8.1 314.1,34.83 ; H8.1 315.44,34.34 ; H8.1 314.1,31.17 ; 148.48,170.76 H18.1 ; H18.1 151.65,172.1 ; H18.1 149.82,170.27 ; H18.1 148.48,173.44 ; H18.1 151.17,170.76 ; H18.1 148,172.1 ; H18.1 151.17,173.44 ; 203.73,166.55 JDP.19 ; JDP.19 203.26,166.68 ; JDP.19 203.26,167.6 ; JDP.19 204.19,166.68 ; JDP.19 204.31,167.14 ; JDP.19 203.73,167.72 ; JDP.19 204.19,167.6 ; JUSB1.11 14.49,40.56 ; JUSB1.11 14.49,39.7 ; JUSB1.11 12.74,40.56 ; JUSB1.11 14.49,38.84 ; JUSB1.11 12.74,38.84 ; 306.43,68.96 JUSB2.7 ; JUSB2.7 306.24,69.6 ; JUSB2.7 306.43,70.23 ; JUSB1.7 12.83,46.86 ; JUSB1.7 12.83,45.34 ; JUSB1.7 12.07,46.1 ; JUSB1.7 12.24,45.51 ; JUSB1.7 12.24,46.69 ; JUSB1.7 13.42,46.69 ; JUSB1.7 13.42,45.51 ; JUSB1.7 13.59,46.1 ; JDP.22 207.3,166.41 ; JDP.22 206.52,163.79 ; JDP.22 205.75,163.79 ; JDP.22 207.3,165.1 ; JDP.22 206.52,166.41 ; JDP.22 205.75,165.1 ; JUSBC2.6 314.92,38.3 ; JUSBC2.6 314.92,37.2 ; JUSBC2.6 314.2,39.21 ; JUSBC2.6 314.92,39.21 ; JUSBC2.6 313.48,37.2 ; JUSBC2.6 314.2,37.2 ; JUSBC2.6 313.48,39.21 ; H25.1 239.88,162.67 ; H25.1 235.71,164.5 ; H25.1 235.71,162.67 ; H25.1 239.88,164.5 ; H25.1 237.8,162.67 ; JUSBC2.2 314.93,46.62 ; JUSBC2.2 313.6,47.39 ; JUSBC2.2 312.27,47.39 ; JUSBC2.2 312.27,45.84 ; JUSBC2.2 312.27,46.62 ; JUSBC2.2 314.93,45.84 ; JUSBC2.2 314.93,47.39 ; JCDRA.49 113.36,173.78 ; JCDRA.49 112.4,173.78 ; JCDRA.49 111.45,173.78 ; JCDRA.49 113.36,175.35 ; 112.75,145.6 H7.1 ; H7.1 112.75,149 ; H7.1 116.15,145.6 ; H7.1 112.11,147.3 ; H7.1 116.79,147.3 ; H7.1 114.45,144.96 ; H7.1 114.45,149.64 ; H7.1 116.15,149 ; H27.1 257.16,72.17 ; H27.1 251.66,74.48 ; H27.1 252.54,76.78 ; H27.1 252.54,72.17 ; H27.1 258.04,74.48 ; H27.1 254.85,77.67 ; H27.1 254.85,71.29 ; H27.1 257.16,76.78 ; JUSBC1.5 156.03,173.27 ; JUSBC1.5 154.03,171.83 ; JUSBC1.5 156.03,171.83 ; JUSBC1.5 154.03,172.55 ; JUSBC1.5 154.03,173.27 ; JUSBC1.5 156.03,172.55 ; JUSBC1.5 155.13,173.27 ; 168.42,170.27 H17.1 ; H17.1 167.08,170.76 ; H17.1 166.6,172.1 ; H17.1 169.77,173.44 ; H17.1 167.08,173.44 ; H17.1 170.25,172.1 ; H17.1 169.77,170.76 ; H3.1 230.25,152 ; H3.1 230.89,150.3 ; H3.1 226.85,148.6 ; H3.1 230.25,148.6 ; H3.1 226.85,152 ; H3.1 228.55,147.96 ; H3.1 228.55,152.64 ; H3.1 226.21,150.3 ; H29.1 307.45,37.83 ; H29.1 305.96,34.31 ; H29.1 307.45,33.77 ; H29.1 308.94,37.29 ; H29.1 305.42,35.8 ; H29.1 309.48,35.8 ; H29.1 308.94,34.31 ; H29.1 305.96,37.29 ; H16.1 232.99,166.16 ; H16.1 230.31,166.16 ; H16.1 233.48,167.5 ; H16.1 232.99,168.84 ; H16.1 231.65,165.67 ; H16.1 229.82,167.5 ; H16.1 231.65,169.33 ; H16.1 230.31,168.84 ; 144.9,169.18 JCDRA.47 ; JCDRA.47 145.86,172.31 ; JCDRA.47 145.86,170.75 ; JCDRA.47 143.95,170.75 ; JCDRA.47 145.86,169.18 ; JCDRA.47 143.95,172.31 ; JCDRA.47 143.95,169.18 ; JCDRA.47 144.9,172.31 ; 188.92,166.05 JHDMI.22 ; JHDMI.22 190.78,166.05 ; JHDMI.22 188.92,164.77 ; JHDMI.22 190.78,164.77 ; JHDMI.22 189.85,164.77 ; 306.17,56.22 H26.1 ; H26.1 310.23,56.22 ; H26.1 306.17,59.78 ; H26.1 308.2,56.22 ; H26.1 306.17,58 ; H26.1 310.23,58 ; H26.1 308.2,59.78 ; H26.1 310.23,59.78 ; 28.77,5.12 H21.1 ; H21.1 31.53,7.88 ; H21.1 30.15,4.62 ; H21.1 32.03,6.5 ; H21.1 30.15,8.38 ; H21.1 31.53,5.12 ; H21.1 28.77,7.88 ; H21.1 28.27,6.5 ; 305.57,72.27 JUSB2.4 ; JUSB2.4 304.93,73.73 ; JUSB2.4 306.2,72.46 ; JUSB2.4 304.93,72.46 ; JUSB2.4 304.74,73.1 ; JUSB2.4 305.57,73.93 ; 9.73,56.73 H24.1 ; H24.1 11,56.27 ; H24.1 12.27,59.27 ; H24.1 12.27,56.73 ; H24.1 12.73,58 ; H24.1 9.27,58 ; H24.1 9.73,59.27 ; 111.45,170.75 JCDRA.50 ; JCDRA.50 112.4,172.31 ; JCDRA.50 113.36,169.18 ; JCDRA.50 111.45,169.18 ; JCDRA.50 113.36,172.31 ; JCDRA.50 111.45,172.31 ; JCDRA.50 113.36,170.75 ; JCDRA.50 112.4,169.18 ; 312.69,78.88 H30.1 ; H30.1 312.69,82.84 ; H30.1 314.87,78.88 ; H30.1 310.5,78.88 ; H30.1 314.87,80.86 ; H30.1 314.87,82.84 ; H30.1 310.5,80.86 ; 12.74,51.64 JUSB1.12 ; JUSB1.12 14.49,52.5 ; JUSB1.12 14.49,51.64 ; JUSB1.12 12.74,53.36 ; JUSB1.12 14.49,53.36 ; H9.1 315.44,52.94 ; H9.1 315.44,50.26 ; H9.1 314.1,49.77 ; H9.1 312.76,52.94 ; H9.1 312.27,51.6 ; H9.1 314.1,53.43 ; H9.1 312.76,50.26 ; H23.1 25.49,7.84 ; H23.1 24.15,8.33 ; H23.1 24.15,4.67 ; H23.1 22.81,5.16 ; H23.1 25.98,6.5 ; H23.1 22.81,7.84 ; H23.1 25.49,5.16 ; H23.1 22.32,6.5 ; JUSB2.12 316.13,78.33 ; JUSB2.12 313.47,78.33 ; JUSB2.12 314.8,78.33 ; 169.25,147.5 H6.1 ; H6.1 173.29,145.8 ; H6.1 169.25,144.1 ; H6.1 170.95,143.46 ; H6.1 170.95,148.14 ; H6.1 172.65,147.5 ; H6.1 172.65,144.1 ; H6.1 168.61,145.8 ; JHDMI.2 179.06,166.66 ; JHDMI.2 178.14,165.74 ; JHDMI.2 178.6,165.62 ; JHDMI.2 178.6,166.78 ; JHDMI.2 178.14,166.66 ; JHDMI.2 179.06,165.74 ; JHDMI.2 178.02,166.2 ; 317.18,45.79 JUSBC2.1 ; JUSBC2.1 318.65,45.79 ; JUSBC2.1 317.18,46.62 ; H19.1 109.78,171.51 ; H19.1 109.78,169.68 ; H19.1 108.15,169.68 ; JLAN.14 228.33,169.65 ; JLAN.14 228.79,169.65 ; JLAN.14 227.88,169.65 ; 154.81,175.53 JUSBC1.1 ; JUSBC1.1 155.63,175.53 ; JUSBC1.1 155.63,177 ; 172.99,172.97 JHDMI.21 ; JHDMI.21 172.52,172.97 ; JHDMI.21 173.45,172.97 ; 182.64,167.29 JHDMI.11 ; JHDMI.11 183.56,167.29 ; JHDMI.11 183.1,167.17 ; JHDMI.8 181.6,166.78 ; JHDMI.8 181.14,166.66 ; JHDMI.8 181.6,165.62 ; JHDMI.8 181.14,165.74 ; JHDMI.8 182.06,166.66 ; JHDMI.8 182.06,165.74 ; 4,56.17 H22.1 ; H22.1 2.66,56.66 ; H22.1 5.83,58 ; H22.1 5.34,59.34 ; H22.1 5.34,56.66 ; JUSBC1.6 164.22,171.83 ; JUSBC1.6 162.22,173.27 ; JUSBC1.6 162.22,172.55 ; JUSBC1.6 164.22,173.27 ; JUSBC1.6 163.12,173.27 ; JUSBC1.6 164.22,172.55 ; JUSBC1.6 162.22,171.83 ; JDP.7 200.49,165.48 ; JDP.7 200.03,166.52 ; JDP.7 200.61,165.94 ; JDP.7 199.56,166.4 ; JDP.7 200.49,166.4 ; JDP.7 199.56,165.48 ; JDP.7 200.03,165.36 ; JUSB2.11 309.78,78.33 ; JUSB2.11 306.22,77.45 ; JUSB2.11 308,78.33 ; JUSB2.11 306.22,76.57 ; 143.95,173.78 JCDRA.48 ; JCDRA.48 143.95,175.35 ; JCDRA.48 145.86,173.78 ; JCDRA.48 144.9,173.78 ; 306.22,61.75 JUSB2.10 ; JUSB2.10 308,60.87 ; JUSB2.10 309.78,60.87 ; JUSB2.10 306.22,60.87 ; JUSB2.10 306.22,62.63 ; 180.1,167.17 JHDMI.5 ; JHDMI.5 180.56,167.29 ; JHDMI.5 179.64,167.29
  IN3 w0.508: v2(17.54,33.25) 18.87,31.92 18.87,28.33 v2(20.06,27.15) 20.06,26.61 v2(17.79,24.35) 18.98,23.16 v2(18.98,18.5)
  GND3 w0.254: 313.86,59.34 H11.1 ; H11.1 317.03,58 ; H11.1 313.86,56.66 ; H11.1 315.2,56.17 ; H11.1 315.2,59.83 ; H11.1 313.37,58 ; H11.1 316.54,59.34 ; H11.1 316.54,56.66 ; 220.65,6.17 H13.1 ; H13.1 221.99,6.66 ; H13.1 222.48,8 ; H13.1 218.82,8 ; H13.1 220.65,9.83 ; H13.1 221.99,9.34 ; H13.1 219.31,6.66 ; H13.1 219.31,9.34 ; H14.1 160.28,7.3 ; H14.1 158.45,5.47 ; H14.1 159.79,8.64 ; H14.1 157.11,8.64 ; H14.1 157.11,5.96 ; H14.1 158.45,9.13 ; H14.1 156.62,7.3 ; H14.1 159.79,5.96 ; 143.95,176.91 JCDRA.48 ; JCDRA.48 143.95,175.35 ; JCDRA.48 144.9,173.78 ; JCDRA.48 144.9,176.91 ; JCDRA.48 143.95,173.78 ; JCDRA.48 145.86,173.78 ; 306.24,69.6 JUSB2.7 ; JUSB2.7 307.07,70.43 ; JUSB2.7 307.07,68.77 ; JUSB2.7 306.43,70.23 ; JUSB2.7 306.43,68.96 ; 203.26,167.6 JDP.19 ; JDP.19 203.26,166.68 ; JDP.19 204.19,167.6 ; JDP.19 204.31,167.14 ; JDP.19 204.19,166.68 ; JDP.19 203.73,167.72 ; JDP.19 203.73,166.55 ; JUSB1.12 14.49,51.64 ; JUSB1.12 14.49,52.5 ; JUSB1.12 10.99,52.5 ; JUSB1.12 14.49,53.36 ; JUSB1.12 10.99,53.36 ; JUSB1.12 10.99,51.64 ; JUSB1.12 12.74,53.36 ; JUSB1.12 12.74,51.64 ; 190.82,175.5 JHDMI.23 ; JHDMI.23 192.68,175.5 ; JHDMI.23 192.68,174.22 ; JHDMI.23 191.75,174.22 ; JHDMI.23 190.82,174.22 ; 312.27,51.6 H9.1 ; H9.1 314.1,49.77 ; H9.1 315.93,51.6 ; H9.1 312.76,50.26 ; H9.1 315.44,52.94 ; H9.1 312.76,52.94 ; H9.1 315.44,50.26 ; H9.1 314.1,53.43 ; 306.17,58 H26.1 ; H26.1 308.2,56.22 ; H26.1 310.23,56.22 ; H26.1 310.23,58 ; H26.1 310.23,59.78 ; H26.1 308.2,59.78 ; H26.1 306.17,56.22 ; H26.1 306.17,59.78 ; JUSB1.14 5.49,54.86 ; JUSB1.14 2.47,54 ; JUSB1.14 3.98,54.86 ; JUSB1.14 5.49,54 ; JUSB1.14 2.47,54.86 ; H25.1 237.8,166.33 ; H25.1 237.8,162.67 ; H25.1 239.88,166.33 ; H25.1 235.71,162.67 ; H25.1 239.88,164.5 ; H25.1 235.71,164.5 ; H25.1 235.71,166.33 ; H25.1 239.88,162.67 ; 106.53,173.34 H19.1 ; H19.1 106.53,171.51 ; H19.1 109.78,173.34 ; H19.1 108.15,169.68 ; H19.1 106.53,169.68 ; H19.1 109.78,169.68 ; H19.1 109.78,171.51 ; H19.1 108.15,173.34 ; JUSB2.12 314.8,78.33 ; JUSB2.12 313.47,77.45 ; JUSB2.12 316.13,77.45 ; JUSB2.12 313.47,78.33 ; JUSB2.12 316.13,78.33 ; 304.93,72.46 JUSB2.4 ; JUSB2.4 306.2,72.46 ; JUSB2.4 305.57,72.27 ; JUSB2.4 305.57,73.93 ; JUSB2.4 304.74,73.1 ; JUSB2.4 304.93,73.73 ; 313.48,39.21 JUSBC2.6 ; JUSBC2.6 314.92,38.3 ; JUSBC2.6 314.92,37.2 ; JUSBC2.6 314.92,39.21 ; JUSBC2.6 314.2,39.21 ; JUSBC2.6 314.2,37.2 ; JUSBC2.6 313.48,37.2 ; 178.14,166.66 JHDMI.2 ; JHDMI.2 178.6,166.78 ; JHDMI.2 179.06,166.66 ; JHDMI.2 178.02,166.2 ; JHDMI.2 178.6,165.62 ; JHDMI.2 179.06,165.74 ; JHDMI.2 178.14,165.74 ; 9.73,59.27 H24.1 ; H24.1 12.73,58 ; H24.1 12.27,59.27 ; H24.1 12.27,56.73 ; H24.1 11,59.73 ; H24.1 11,56.27 ; H24.1 9.73,56.73 ; H24.1 9.27,58 ; 230.31,166.16 H16.1 ; H16.1 230.31,168.84 ; H16.1 232.99,168.84 ; H16.1 229.82,167.5 ; H16.1 233.48,167.5 ; H16.1 232.99,166.16 ; H16.1 231.65,169.33 ; H16.1 231.65,165.67 ; JDP.7 200.49,166.4 ; JDP.7 200.03,166.52 ; JDP.7 199.56,165.48 ; JDP.7 200.03,165.36 ; JDP.7 199.56,166.4 ; JDP.7 200.49,165.48 ; JDP.7 200.61,165.94 ; 2.47,38.2 JUSB1.13 ; JUSB1.13 5.49,37.34 ; JUSB1.13 5.49,38.2 ; JUSB1.13 2.47,37.34 ; JUSB1.13 3.98,37.34 ; JUSBC1.6 163.12,173.27 ; JUSBC1.6 164.22,172.55 ; JUSBC1.6 164.22,171.83 ; JUSBC1.6 162.22,171.83 ; JUSBC1.6 162.22,173.27 ; JUSBC1.6 164.22,173.27 ; JUSBC1.6 162.22,172.55 ; H15.1 159.63,76.31 ; H15.1 158.29,75.82 ; H15.1 160.97,75.82 ; H15.1 158.29,73.14 ; H15.1 160.97,73.14 ; H15.1 161.46,74.48 ; H15.1 159.63,72.65 ; H15.1 157.8,74.48 ; H5.1 92.1,87.1 ; H5.1 88.06,85.4 ; H5.1 88.7,83.7 ; H5.1 92.74,85.4 ; H5.1 88.7,87.1 ; H5.1 92.1,83.7 ; H5.1 90.4,83.06 ; H5.1 90.4,87.74 ; JUSB2.10 309.78,60.87 ; JUSB2.10 306.22,60.87 ; JUSB2.10 309.78,61.75 ; JUSB2.10 306.22,62.63 ; JUSB2.10 308,60.87 ; JUSB2.10 306.22,61.75 ; 266.12,59.25 H28.1 ; H28.1 268.15,61.28 ; H28.1 268.15,57.22 ; H28.1 270.18,59.25 ; H28.1 266.66,57.76 ; H28.1 266.66,60.74 ; H28.1 269.64,60.74 ; H28.1 269.64,57.76 ; H30.1 314.87,82.84 ; H30.1 312.69,82.84 ; H30.1 314.87,80.86 ; H30.1 310.5,80.86 ; H30.1 314.87,78.88 ; H30.1 310.5,78.88 ; H30.1 312.69,78.88 ; JUSBC1.4 164.22,171.95 ; JUSBC1.4 163.45,170.62 ; JUSBC1.4 162.67,170.62 ; JUSBC1.4 164.22,173.28 ; JUSBC1.4 164.22,170.62 ; JUSBC1.4 163.45,173.28 ; JDP.1 198.79,167.6 ; JDP.1 198.32,166.55 ; JDP.1 198.32,167.72 ; JDP.1 197.86,166.68 ; JDP.1 197.74,167.14 ; JDP.1 198.79,166.68 ; JDP.1 197.86,167.6 ; JUSB2.11 308,78.33 ; JUSB2.11 309.78,78.33 ; JUSB2.11 306.22,76.57 ; JUSB2.11 306.22,77.45 ; JUSB2.11 309.78,77.45 ; JUSB2.11 306.22,78.33 ; 30.15,4.62 H21.1 ; H21.1 28.27,6.5 ; H21.1 32.03,6.5 ; H21.1 28.77,7.88 ; H21.1 28.77,5.12 ; H21.1 30.15,8.38 ; H21.1 31.53,7.88 ; H21.1 31.53,5.12 ; JDP.13 202.49,165.48 ; JDP.13 201.44,165.94 ; JDP.13 201.56,166.4 ; JDP.13 201.56,165.48 ; JDP.13 202.49,166.4 ; JDP.13 202.02,165.36 ; JDP.13 202.02,166.52 ; JDP.21 207.3,168.79 ; JDP.21 205.75,168.79 ; JDP.21 207.3,170.1 ; JDP.21 206.52,168.79 ; JDP.21 206.52,171.41 ; JDP.21 207.3,171.41 ; 4,56.17 H22.1 ; H22.1 2.17,58 ; H22.1 5.83,58 ; H22.1 5.34,56.66 ; H22.1 2.66,59.34 ; H22.1 5.34,59.34 ; H22.1 2.66,56.66 ; H22.1 4,59.83 ; 185.64,167.29 JHDMI.17 ; JHDMI.17 186.1,167.17 ; JHDMI.17 185.64,168.21 ; JHDMI.17 186.1,168.33 ; JHDMI.17 186.56,167.29 ; JHDMI.17 186.56,168.21 ; 172.52,172.97 JHDMI.21 ; JHDMI.21 173.45,172.97 ; JHDMI.21 174.38,172.97 ; JHDMI.21 174.38,174.25 ; JHDMI.21 173.45,175.53 ; JHDMI.21 172.52,174.25 ; H17.1 170.25,172.1 ; H17.1 169.77,170.76 ; H17.1 167.08,173.44 ; H17.1 167.08,170.76 ; H17.1 166.6,172.1 ; H17.1 168.42,173.93 ; H17.1 169.77,173.44 ; H17.1 168.42,170.27 ; H6.1 173.29,145.8 ; H6.1 168.61,145.8 ; H6.1 169.25,147.5 ; H6.1 169.25,144.1 ; H6.1 172.65,144.1 ; H6.1 170.95,148.14 ; H6.1 170.95,143.46 ; H6.1 172.65,147.5 ; 208.83,169.65 JLAN.16 ; JLAN.16 207.91,173.16 ; JLAN.16 208.83,173.16 ; JLAN.16 207.91,171.4 ; JLAN.16 207.91,169.65 ; 22.32,6.5 H23.1 ; H23.1 25.98,6.5 ; H23.1 22.81,5.16 ; H23.1 24.15,8.33 ; H23.1 25.49,7.84 ; H23.1 22.81,7.84 ; H23.1 24.15,4.67 ; H23.1 25.49,5.16 ; JDP.23 195.52,171.41 ; JDP.23 195.52,168.79 ; JDP.23 194.75,168.79 ; JDP.23 196.3,168.79 ; JDP.23 194.75,171.41 ; JDP.23 194.75,170.1 ; 13.74,42.01 JUSB1.4 ; JUSB1.4 14.92,43.19 ; JUSB1.4 14.33,43.36 ; JUSB1.4 15.09,42.6 ; JUSB1.4 14.33,41.84 ; JUSB1.4 13.57,42.6 ; JUSB1.4 13.74,43.19 ; JUSB1.4 14.92,42.01 ; 318.65,37.15 JUSBC2.3 ; JUSBC2.3 318.65,38.81 ; JUSBC2.3 317.18,38.81 ; JUSBC2.3 317.18,37.15 ; JUSBC2.3 317.18,37.98 ; JHDMI.11 183.56,168.21 ; JHDMI.11 183.1,167.17 ; JHDMI.11 182.64,168.21 ; JHDMI.11 183.1,168.33 ; JHDMI.11 182.64,167.29 ; JHDMI.11 183.56,167.29 ; JUSB1.11 14.49,40.56 ; JUSB1.11 10.99,40.56 ; JUSB1.11 10.99,38.84 ; JUSB1.11 12.74,38.84 ; JUSB1.11 12.74,40.56 ; JUSB1.11 14.49,38.84 ; JUSB1.11 14.49,39.7 ; JUSB1.11 10.99,39.7 ; JCDRA.50 113.36,169.18 ; JCDRA.50 111.45,170.75 ; JCDRA.50 113.36,170.75 ; JCDRA.50 112.4,172.31 ; JCDRA.50 111.45,169.18 ; JCDRA.50 111.45,172.31 ; JCDRA.50 112.4,169.18 ; JCDRA.50 113.36,172.31 ; JUSBC2.5 314.92,46.29 ; JUSBC2.5 314.2,45.39 ; JUSBC2.5 314.92,47.4 ; JUSBC2.5 313.48,47.4 ; JUSBC2.5 314.92,45.39 ; JUSBC2.5 314.2,47.4 ; JUSBC2.5 313.48,45.39 ; 248.76,54.96 H12.1 ; H12.1 248.27,53.62 ; H12.1 251.44,54.96 ; H12.1 250.1,55.45 ; H12.1 248.76,52.28 ; H12.1 251.93,53.62 ; H12.1 250.1,51.79 ; H12.1 251.44,52.28 ; H10.1 111.68,165.5 ; H10.1 108.51,164.16 ; H10.1 108.02,165.5 ; H10.1 109.85,167.33 ; H10.1 109.85,163.67 ; H10.1 108.51,166.84 ; H10.1 111.19,164.16 ; H10.1 111.19,166.84 ; H18.1 151.17,173.44 ; H18.1 148.48,170.76 ; H18.1 149.82,173.93 ; H18.1 151.65,172.1 ; H18.1 148,172.1 ; H18.1 151.17,170.76 ; H18.1 149.82,170.27 ; H18.1 148.48,173.44 ; 179.64,168.21 JHDMI.5 ; JHDMI.5 180.1,167.17 ; JHDMI.5 180.56,167.29 ; JHDMI.5 180.1,168.33 ; JHDMI.5 179.64,167.29 ; JHDMI.5 180.56,168.21 ; 312.27,46.62 JUSBC2.2 ; JUSBC2.2 312.27,47.39 ; JUSBC2.2 313.6,47.39 ; JUSBC2.2 314.93,47.39 ; JUSBC2.2 314.93,46.62 ; JUSBC2.2 312.27,45.84 ; 314.8,60.87 JUSB2.13 ; JUSB2.13 313.47,60.87 ; JUSB2.13 316.13,60.87 ; JUSB2.13 316.13,61.75 ; JUSB2.13 313.47,61.75 ; 154.03,173.28 JUSBC1.2 ; JUSBC1.2 154.81,173.28 ; JUSBC1.2 154.81,170.62 ; JUSBC1.2 154.03,171.95 ; JUSBC1.2 154.03,170.62 ; JUSBC1.2 155.58,170.62 ; JHDMI.8 182.06,165.74 ; JHDMI.8 181.6,165.62 ; JHDMI.8 181.6,166.78 ; JHDMI.8 181.14,166.66 ; JHDMI.8 181.14,165.74 ; JHDMI.8 182.06,166.66 ; 12.24,45.51 JUSB1.7 ; JUSB1.7 12.24,46.69 ; JUSB1.7 13.42,45.51 ; JUSB1.7 12.83,46.86 ; JUSB1.7 13.59,46.1 ; JUSB1.7 13.42,46.69 ; JUSB1.7 12.07,46.1 ; JUSB1.7 12.83,45.34 ; 48.52,53.79 H20.1 ; H20.1 51.2,53.79 ; H20.1 48.03,55.13 ; H20.1 51.2,56.47 ; H20.1 51.69,55.13 ; H20.1 49.86,53.3 ; H20.1 48.52,56.47 ; H20.1 49.86,56.96 ; H29.1 308.94,34.31 ; H29.1 307.45,33.77 ; H29.1 305.42,35.8 ; H29.1 309.48,35.8 ; H29.1 307.45,37.83 ; H29.1 305.96,34.31 ; H29.1 308.94,37.29 ; H29.1 305.96,37.29 ; H8.1 315.44,31.66 ; H8.1 314.1,34.83 ; H8.1 312.27,33 ; H8.1 314.1,31.17 ; H8.1 312.76,31.66 ; H8.1 312.76,34.34 ; H8.1 315.93,33 ; H8.1 315.44,34.34 ; 313.6,37.2 JUSBC2.4 ; JUSBC2.4 312.27,37.98 ; JUSBC2.4 314.93,37.98 ; JUSBC2.4 314.93,37.2 ; JUSBC2.4 312.27,38.75 ; JUSBC2.4 312.27,37.2 ; 154.03,172.55 JUSBC1.5 ; JUSBC1.5 154.03,171.83 ; JUSBC1.5 156.03,173.27 ; JUSBC1.5 155.13,173.27 ; JUSBC1.5 154.03,173.27 ; JUSBC1.5 156.03,172.55 ; JUSBC1.5 156.03,171.83 ; H7.1 114.45,149.64 ; H7.1 116.15,149 ; H7.1 112.11,147.3 ; H7.1 116.79,147.3 ; H7.1 114.45,144.96 ; H7.1 112.75,145.6 ; H7.1 116.15,145.6 ; H7.1 112.75,149 ; H3.1 228.55,152.64 ; H3.1 230.25,152 ; H3.1 230.25,148.6 ; H3.1 230.89,150.3 ; H3.1 228.55,147.96 ; H3.1 226.85,152 ; H3.1 226.85,148.6 ; H3.1 226.21,150.3 ; 175.35,164.77 JHDMI.20 ; JHDMI.20 175.35,167.33 ; JHDMI.20 174.42,167.33 ; JHDMI.20 174.42,166.05 ; JHDMI.20 174.42,164.77 ; JHDMI.20 176.28,166.05 ; JHDMI.20 176.28,167.33 ; JHDMI.20 176.28,164.77 ; 251.66,74.48 H27.1 ; H27.1 258.04,74.48 ; H27.1 252.54,72.17 ; H27.1 257.16,72.17 ; H27.1 254.85,71.29 ; H27.1 252.54,76.78 ; H27.1 254.85,77.67 ; H27.1 257.16,76.78 ; 154.81,175.53 JUSBC1.1 ; JUSBC1.1 153.98,177 ; JUSBC1.1 153.98,175.53 ; JUSBC1.1 155.63,175.53 ; JUSBC1.1 155.63,177 ; 157.7,82.1 H4.1 ; H4.1 161.1,82.1 ; H4.1 157.7,85.5 ; H4.1 161.74,83.8 ; H4.1 159.4,86.14 ; H4.1 161.1,85.5 ; H4.1 159.4,81.46 ; H4.1 157.06,83.8 ; JDP.22 206.52,166.41 ; JDP.22 206.52,163.79 ; JDP.22 207.3,166.41 ; JDP.22 205.75,163.79 ; JDP.22 205.75,165.1 ; JDP.22 207.3,165.1 ; 144.9,169.18 JCDRA.47 ; JCDRA.47 145.86,170.75 ; JCDRA.47 144.9,172.31 ; JCDRA.47 145.86,172.31 ; JCDRA.47 143.95,170.75 ; JCDRA.47 145.86,169.18 ; JCDRA.47 143.95,172.31 ; JCDRA.47 143.95,169.18 ; 112.4,173.78 JCDRA.49 ; JCDRA.49 112.4,176.91 ; JCDRA.49 111.45,175.35 ; JCDRA.49 113.36,175.35 ; JCDRA.49 111.45,173.78 ; JCDRA.49 113.36,173.78 ; JCDRA.49 113.36,176.91 ; JCDRA.49 111.45,176.91 ; JDP.24 195.52,166.41 ; JDP.24 194.75,165.1 ; JDP.24 194.75,163.79 ; JDP.24 196.3,163.79 ; JDP.24 196.3,165.1 ; JDP.24 195.52,163.79 ; JDP.24 194.75,166.41 ; JUSBC1.3 164.27,175.53 ; JUSBC1.3 163.45,175.53 ; JUSBC1.3 162.62,175.53 ; JUSBC1.3 162.62,177 ; JUSBC1.3 164.27,177 ; JPCMC.36 76.55,68.13 ; JPCMC.36 77.22,69.93 ; JPCMC.36 76.55,71.73 ; JPCMC.36 72.94,68.13 ; JPCMC.36 74.74,72.41 ; JPCMC.36 72.27,69.93 ; JHDMI.22 190.78,166.05 ; JHDMI.22 189.85,167.33 ; JHDMI.22 189.85,164.77 ; JHDMI.22 190.78,164.77 ; JHDMI.22 188.92,164.77 ; JHDMI.22 190.78,167.33 ; JHDMI.22 188.92,166.05 ; JHDMI.22 188.92,167.33 ; 227.88,169.65 JLAN.14 ; JLAN.14 227.88,173.16 ; JLAN.14 228.79,171.4 ; JLAN.14 228.79,169.65 ; 317.18,46.62 JUSBC2.1 ; JUSBC2.1 317.18,47.45 ; JUSBC2.1 317.18,45.79 ; JUSBC2.1 318.65,45.79 ; JUSBC2.1 318.65,47.45
  IN5 w0.15: v2(197.5,112.15) 197.5,112.1 197.2,111.8 197.2,111.23 196.9,110.93 v2(196.9,110.75) ; v2(188.52,110.03) 188.52,110.17 188.75,110.4 188.8,110.4 ; v2(195.28,84) 195.1,83.83 UG9.AH6 v2(195.4,82.85) ; v2(199.49,109.63) 199.31,109.81 199.31,109.97 199.3,109.98 199.3,110.33 199.31,110.34 199.31,110.53 v2(199.04,110.8) 199.3,111.06 199.3,111.88 v2(199.62,112.2) ; UG9.AU47 v2(189.1,112.15) v2(188.5,112.15) UG9.AU47 ; UG9.AU47 188.8,110.4 ; v2(208.17,84.72) 208,84.55 UG9.K8 ; UG9.K8 207.7,84.32 207.7,83.98 207.7,83.98 207.7,83.75 v2(207.4,83.45) UG9.K6 207.7,83.02 207.7,82.68 207.7,82.68 207.7,82.43 v2(207.9,82.22) ; UG9.K8 v2(207.4,84.85) ; 188.8,110.4 v2(189.1,110.1) 189.04,110.04 v2(189.04,109.51)
  IN5 w0.152: v2(194.82,82.8) 195.35,82.8 v2(195.4,82.85)
  IN5 w0.25: v2(199.45,114.1) 199.6,113.95 v2(199.6,113.55) 199.11,113.06 v2(199.11,112.69) 199.12,112.69 v2(199.62,112.2)
  IN5 w0.3: 198.18,110.8 198.18,111.64 197.67,112.15 v2(197.5,112.15) ; 198.18,110.8 v2(197.38,110) ; 198.18,110.8 v2(199.04,110.8) ; v2(197.38,110) 197.6,109.78 v2(197.6,109.45) 196.93,109.45 v2(196.9,109.42) ; v2(197.38,110) 197.38,110.27 v2(196.9,110.75)
  GND4 w0.203: 314.2,45.39 JUSBC2.5 ; JUSBC2.5 314.92,47.4 ; JUSBC2.5 313.48,45.39 ; JUSBC2.5 313.48,47.4 ; JUSBC2.5 314.92,45.39 ; JUSBC2.5 314.92,46.29 ; JUSBC2.5 314.2,47.4 ; JUSBC2.3 320.12,37.15 ; JUSBC2.3 318.65,37.15 ; JUSBC2.3 320.12,37.98 ; JUSBC2.3 320.12,38.81 ; JUSBC2.3 318.65,38.81 ; JUSBC2.3 317.18,38.81 ; JUSBC2.3 317.18,37.15 ; JUSBC2.3 317.18,37.98 ; 154.03,170.62 JUSBC1.2 ; JUSBC1.2 155.58,173.28 ; JUSBC1.2 155.58,170.62 ; JUSBC1.2 154.03,171.95 ; JUSBC1.2 154.81,173.28 ; JUSBC1.2 154.03,173.28 ; JUSBC1.2 154.81,170.62 ; JHDMI.20 176.28,167.33 ; JHDMI.20 174.42,164.77 ; JHDMI.20 176.28,164.77 ; JHDMI.20 176.28,166.05 ; JHDMI.20 174.42,167.33 ; JHDMI.20 175.35,164.77 ; JHDMI.20 175.35,167.33 ; JHDMI.20 174.42,166.05 ; H22.1 5.83,58 ; H22.1 4,59.83 ; H22.1 5.34,59.34 ; H22.1 5.34,56.66 ; H22.1 4,56.17 ; H22.1 2.66,59.34 ; H22.1 2.66,56.66 ; H22.1 2.17,58 ; JDP.19 204.31,167.14 ; JDP.19 203.26,166.68 ; JDP.19 204.19,167.6 ; JDP.19 204.19,166.68 ; JDP.19 203.73,166.55 ; JDP.19 203.73,167.72 ; JDP.19 203.26,167.6 ; 111.45,176.91 JCDRA.49 ; JCDRA.49 112.4,176.91 ; JCDRA.49 111.45,175.35 ; JCDRA.49 113.36,173.78 ; JCDRA.49 113.36,175.35 ; JCDRA.49 112.4,173.78 ; JCDRA.49 113.36,176.91 ; JCDRA.49 111.45,173.78 ; 266.12,59.25 H28.1 ; H28.1 266.66,57.76 ; H28.1 270.18,59.25 ; H28.1 268.15,57.22 ; H28.1 266.66,60.74 ; H28.1 269.64,60.74 ; H28.1 268.15,61.28 ; H28.1 269.64,57.76 ; 154.03,172.55 JUSBC1.5 ; JUSBC1.5 156.03,171.83 ; JUSBC1.5 155.13,173.27 ; JUSBC1.5 156.03,172.55 ; JUSBC1.5 154.03,171.83 ; JUSBC1.5 156.03,173.27 ; JUSBC1.5 154.03,173.27 ; 230.31,166.16 H16.1 ; H16.1 229.82,167.5 ; H16.1 232.99,168.84 ; H16.1 233.48,167.5 ; H16.1 231.65,169.33 ; H16.1 232.99,166.16 ; H16.1 230.31,168.84 ; H16.1 231.65,165.67 ; 228.55,147.96 H3.1 ; H3.1 226.21,150.3 ; H3.1 230.25,148.6 ; H3.1 230.89,150.3 ; H3.1 230.25,152 ; H3.1 226.85,148.6 ; H3.1 226.85,152 ; H3.1 228.55,152.64 ; 9.73,56.73 H24.1 ; H24.1 11,56.27 ; H24.1 9.73,59.27 ; H24.1 12.73,58 ; H24.1 12.27,59.27 ; H24.1 9.27,58 ; H24.1 11,59.73 ; H24.1 12.27,56.73 ; H29.1 307.45,37.83 ; H29.1 308.94,34.31 ; H29.1 305.42,35.8 ; H29.1 308.94,37.29 ; H29.1 305.96,37.29 ; H29.1 307.45,33.77 ; H29.1 305.96,34.31 ; H29.1 309.48,35.8 ; 315.2,56.17 H11.1 ; H11.1 313.37,58 ; H11.1 316.54,59.34 ; H11.1 313.86,59.34 ; H11.1 315.2,59.83 ; H11.1 316.54,56.66 ; H11.1 313.86,56.66 ; H11.1 317.03,58 ; JDP.23 196.3,170.1 ; JDP.23 194.75,171.41 ; JDP.23 195.52,168.79 ; JDP.23 194.75,170.1 ; JDP.23 194.75,168.79 ; JDP.23 195.52,171.41 ; JDP.23 196.3,168.79 ; JDP.23 196.3,171.41 ; JUSB1.12 14.49,51.64 ; JUSB1.12 12.74,53.36 ; JUSB1.12 12.74,51.64 ; JUSB1.12 14.49,53.36 ; JUSB1.12 10.99,53.36 ; JUSB1.12 14.49,52.5 ; JUSB1.12 10.99,52.5 ; JUSB1.12 10.99,51.64 ; 188.92,166.05 JHDMI.22 ; JHDMI.22 189.85,167.33 ; JHDMI.22 190.78,166.05 ; JHDMI.22 188.92,164.77 ; JHDMI.22 190.78,164.77 ; JHDMI.22 189.85,164.77 ; JHDMI.22 188.92,167.33 ; JHDMI.22 190.78,167.33 ; JHDMI.23 192.68,175.5 ; JHDMI.23 190.82,174.22 ; JHDMI.23 191.75,174.22 ; JHDMI.23 192.68,174.22 ; JHDMI.23 190.82,175.5 ; JUSB1.4 14.92,43.19 ; JUSB1.4 14.92,42.01 ; JUSB1.4 14.33,43.36 ; JUSB1.4 14.33,41.84 ; JUSB1.4 13.74,43.19 ; JUSB1.4 15.09,42.6 ; JUSB1.4 13.57,42.6 ; JUSB1.4 13.74,42.01 ; JDP.24 195.52,166.41 ; JDP.24 194.75,163.79 ; JDP.24 194.75,165.1 ; JDP.24 196.3,163.79 ; JDP.24 196.3,165.1 ; JDP.24 194.75,166.41 ; JDP.24 195.52,163.79 ; JDP.22 206.52,166.41 ; JDP.22 206.52,163.79 ; JDP.22 205.75,163.79 ; JDP.22 205.75,165.1 ; JDP.22 207.3,165.1 ; JDP.22 207.3,166.41 ; 197.86,166.68 JDP.1 ; JDP.1 197.74,167.14 ; JDP.1 198.32,167.72 ; JDP.1 198.79,167.6 ; JDP.1 198.32,166.55 ; JDP.1 198.79,166.68 ; JDP.1 197.86,167.6 ; 10.99,38.84 JUSB1.11 ; JUSB1.11 12.74,40.56 ; JUSB1.11 14.49,40.56 ; JUSB1.11 10.99,39.7 ; JUSB1.11 12.74,38.84 ; JUSB1.11 14.49,39.7 ; JUSB1.11 10.99,40.56 ; JUSB1.11 14.49,38.84 ; 153.98,178.47 JUSBC1.1 ; JUSBC1.1 155.63,177 ; JUSBC1.1 154.81,178.47 ; JUSBC1.1 154.81,175.53 ; JUSBC1.1 153.98,177 ; JUSBC1.1 155.63,175.53 ; JUSBC1.1 155.63,178.47 ; JUSBC1.1 153.98,175.53 ; JUSBC1.4 164.22,170.62 ; JUSBC1.4 163.45,173.28 ; JUSBC1.4 162.67,170.62 ; JUSBC1.4 163.45,170.62 ; JUSBC1.4 164.22,173.28 ; JUSBC1.4 164.22,171.95 ; JUSB1.7 12.83,46.86 ; JUSB1.7 12.24,45.51 ; JUSB1.7 12.83,45.34 ; JUSB1.7 12.07,46.1 ; JUSB1.7 13.42,46.69 ; JUSB1.7 12.24,46.69 ; JUSB1.7 13.42,45.51 ; JUSB1.7 13.59,46.1 ; 181.6,165.62 JHDMI.8 ; JHDMI.8 181.6,166.78 ; JHDMI.8 181.14,165.74 ; JHDMI.8 181.14,166.66 ; JHDMI.8 182.06,165.74 ; JHDMI.8 182.06,166.66 ; H18.1 149.82,173.93 ; H18.1 149.82,170.27 ; H18.1 151.65,172.1 ; H18.1 148.48,173.44 ; H18.1 148.48,170.76 ; H18.1 151.17,173.44 ; H18.1 148,172.1 ; H18.1 151.17,170.76 ; H10.1 111.19,164.16 ; H10.1 109.85,167.33 ; H10.1 111.19,166.84 ; H10.1 108.51,166.84 ; H10.1 108.51,164.16 ; H10.1 111.68,165.5 ; H10.1 109.85,163.67 ; H10.1 108.02,165.5 ; 162.22,173.27 JUSBC1.6 ; JUSBC1.6 162.22,172.55 ; JUSBC1.6 163.12,173.27 ; JUSBC1.6 164.22,173.27 ; JUSBC1.6 162.22,171.83 ; JUSBC1.6 164.22,172.55 ; JUSBC1.6 164.22,171.83 ; 308.2,56.22 H26.1 ; H26.1 310.23,59.78 ; H26.1 306.17,58 ; H26.1 306.17,59.78 ; H26.1 308.2,59.78 ; H26.1 310.23,56.22 ; H26.1 306.17,56.22 ; H26.1 310.23,58 ; H21.1 32.03,6.5 ; H21.1 30.15,8.38 ; H21.1 31.53,5.12 ; H21.1 28.77,5.12 ; H21.1 31.53,7.88 ; H21.1 28.77,7.88 ; H21.1 30.15,4.62 ; H21.1 28.27,6.5 ; 218.82,8 H13.1 ; H13.1 221.99,6.66 ; H13.1 221.99,9.34 ; H13.1 222.48,8 ; H13.1 220.65,6.17 ; H13.1 219.31,9.34 ; H13.1 220.65,9.83 ; H13.1 219.31,6.66 ; 317.18,45.79 JUSBC2.1 ; JUSBC2.1 320.12,45.79 ; JUSBC2.1 318.65,47.45 ; JUSBC2.1 317.18,47.45 ; JUSBC2.1 317.18,46.62 ; JUSBC2.1 320.12,47.45 ; JUSBC2.1 320.12,46.62 ; JUSBC2.1 318.65,45.79 ; H20.1 51.2,53.79 ; H20.1 51.2,56.47 ; H20.1 48.03,55.13 ; H20.1 51.69,55.13 ; H20.1 48.52,56.47 ; H20.1 48.52,53.79 ; H20.1 49.86,56.96 ; H20.1 49.86,53.3 ; H23.1 24.15,8.33 ; H23.1 22.81,7.84 ; H23.1 25.49,5.16 ; H23.1 25.49,7.84 ; H23.1 24.15,4.67 ; H23.1 22.32,6.5 ; H23.1 25.98,6.5 ; H23.1 22.81,5.16 ; H4.1 161.74,83.8 ; H4.1 161.1,82.1 ; H4.1 157.06,83.8 ; H4.1 159.4,81.46 ; H4.1 157.7,85.5 ; H4.1 159.4,86.14 ; H4.1 157.7,82.1 ; H4.1 161.1,85.5 ; JDP.7 200.49,165.48 ; JDP.7 199.56,166.4 ; JDP.7 200.61,165.94 ; JDP.7 200.49,166.4 ; JDP.7 199.56,165.48 ; JDP.7 200.03,166.52 ; JDP.7 200.03,165.36 ; H2.1 178.75,70.74 ; H2.1 181.09,68.4 ; H2.1 176.41,68.4 ; H2.1 180.45,66.7 ; H2.1 180.45,70.1 ; H2.1 178.75,66.06 ; H2.1 177.05,66.7 ; H2.1 177.05,70.1 ; JUSBC2.2 314.93,47.39 ; JUSBC2.2 313.6,47.39 ; JUSBC2.2 314.93,46.62 ; JUSBC2.2 312.27,47.39 ; JUSBC2.2 312.27,45.84 ; JUSBC2.2 312.27,46.62 ; JUSBC2.2 314.93,45.84 ; H7.1 114.45,149.64 ; H7.1 112.75,145.6 ; H7.1 116.15,145.6 ; H7.1 116.79,147.3 ; H7.1 112.75,149 ; H7.1 112.11,147.3 ; H7.1 116.15,149 ; H7.1 114.45,144.96 ; 157.11,5.96 H14.1 ; H14.1 158.45,5.47 ; H14.1 158.45,9.13 ; H14.1 156.62,7.3 ; H14.1 159.79,5.96 ; H14.1 157.11,8.64 ; H14.1 160.28,7.3 ; H14.1 159.79,8.64 ; 310.5,80.86 H30.1 ; H30.1 314.87,78.88 ; H30.1 312.69,82.84 ; H30.1 312.69,78.88 ; H30.1 314.87,80.86 ; H30.1 314.87,82.84 ; H30.1 310.5,78.88 ; JUSB2.10 309.78,61.75 ; JUSB2.10 306.22,60.87 ; JUSB2.10 308,60.87 ; JUSB2.10 306.22,61.75 ; JUSB2.10 306.22,62.63 ; JUSB2.10 309.78,60.87 ; JUSB1.13 5.49,38.2 ; JUSB1.13 5.49,37.34 ; JUSB1.13 3.98,37.34 ; JUSB1.13 2.47,37.34 ; JUSB1.13 2.47,38.2 ; JLAN.16 209.74,173.16 ; JLAN.16 209.74,169.65 ; JLAN.16 207.91,171.4 ; JLAN.16 207.91,169.65 ; JLAN.16 208.83,169.65 ; JLAN.16 207.91,173.16 ; JLAN.16 209.74,171.4 ; JLAN.16 208.83,173.16 ; JUSB1.14 5.49,54 ; JUSB1.14 2.47,54.86 ; JUSB1.14 5.49,54.86 ; JUSB1.14 3.98,54.86 ; JUSB1.14 2.47,54 ; 312.27,51.6 H9.1 ; H9.1 312.76,50.26 ; H9.1 312.76,52.94 ; H9.1 314.1,53.43 ; H9.1 315.93,51.6 ; H9.1 315.44,52.94 ; H9.1 314.1,49.77 ; H9.1 315.44,50.26 ; 106.53,171.51 H19.1 ; H19.1 109.78,173.34 ; H19.1 106.53,169.68 ; H19.1 106.53,173.34 ; H19.1 108.15,173.34 ; H19.1 109.78,169.68 ; H19.1 109.78,171.51 ; H19.1 108.15,169.68 ; JUSBC2.6 314.2,39.21 ; JUSBC2.6 314.92,37.2 ; JUSBC2.6 314.92,39.21 ; JUSBC2.6 314.2,37.2 ; JUSBC2.6 313.48,39.21 ; JUSBC2.6 314.92,38.3 ; JUSBC2.6 313.48,37.2 ; 143.95,175.35 JCDRA.48 ; JCDRA.48 143.95,173.78 ; JCDRA.48 144.9,173.78 ; JCDRA.48 143.95,176.91 ; JCDRA.48 145.86,173.78 ; JCDRA.48 144.9,176.91 ; 313.47,61.75 JUSB2.13 ; JUSB2.13 313.47,60.87 ; JUSB2.13 316.13,60.87 ; JUSB2.13 314.8,60.87 ; JUSB2.13 316.13,61.75 ; 170.95,143.46 H6.1 ; H6.1 168.61,145.8 ; H6.1 169.25,147.5 ; H6.1 172.65,147.5 ; H6.1 172.65,144.1 ; H6.1 173.29,145.8 ; H6.1 170.95,148.14 ; H6.1 169.25,144.1 ; 313.6,37.2 JUSBC2.4 ; JUSBC2.4 314.93,37.2 ; JUSBC2.4 312.27,37.2 ; JUSBC2.4 314.93,37.98 ; JUSBC2.4 312.27,37.98 ; JUSBC2.4 312.27,38.75 ; 205.75,170.1 JDP.21 ; JDP.21 207.3,171.41 ; JDP.21 207.3,170.1 ; JDP.21 205.75,168.79 ; JDP.21 207.3,168.79 ; JDP.21 206.52,168.79 ; JDP.21 206.52,171.41 ; JDP.21 205.75,171.41 ; JHDMI.21 174.38,174.25 ; JHDMI.21 173.45,175.53 ; JHDMI.21 173.45,172.97 ; JHDMI.21 174.38,172.97 ; JHDMI.21 172.52,172.97 ; JHDMI.21 172.52,174.25 ; 157.8,74.48 H15.1 ; H15.1 160.97,73.14 ; H15.1 158.29,73.14 ; H15.1 159.63,72.65 ; H15.1 158.29,75.82 ; H15.1 160.97,75.82 ; H15.1 159.63,76.31 ; H15.1 161.46,74.48 ; 209.6,70.1 H1.1 ; H1.1 208.96,68.4 ; H1.1 213,70.1 ; H1.1 211.3,70.74 ; H1.1 213.64,68.4 ; H1.1 211.3,66.06 ; H1.1 213,66.7 ; H1.1 209.6,66.7 ; JDP.13 202.49,166.4 ; JDP.13 201.56,166.4 ; JDP.13 201.44,165.94 ; JDP.13 201.56,165.48 ; JDP.13 202.02,165.36 ; JDP.13 202.02,166.52 ; JDP.13 202.49,165.48 ; JLAN.14 228.79,169.65 ; JLAN.14 226.96,171.4 ; JLAN.14 227.88,173.16 ; JLAN.14 228.79,171.4 ; JLAN.14 227.88,169.65 ; JLAN.14 226.96,173.16 ; JLAN.14 226.96,169.65 ; JUSBC1.3 164.27,177 ; JUSBC1.3 162.62,178.47 ; JUSBC1.3 164.27,175.53 ; JUSBC1.3 162.62,175.53 ; JUSBC1.3 163.45,175.53 ; JUSBC1.3 164.27,178.47 ; JUSBC1.3 163.45,178.47 ; JUSBC1.3 162.62,177 ; JHDMI.2 179.06,165.74 ; JHDMI.2 178.6,166.78 ; JHDMI.2 178.14,165.74 ; JHDMI.2 178.6,165.62 ; JHDMI.2 178.14,166.66 ; JHDMI.2 178.02,166.2 ; JHDMI.2 179.06,166.66 ; 304.74,73.1 JUSB2.4 ; JUSB2.4 304.93,73.73 ; JUSB2.4 305.57,73.93 ; JUSB2.4 305.57,72.27 ; JUSB2.4 306.2,72.46 ; JUSB2.4 304.93,72.46 ; H17.1 169.77,170.76 ; H17.1 166.6,172.1 ; H17.1 168.42,170.27 ; H17.1 168.42,173.93 ; H17.1 167.08,170.76 ; H17.1 169.77,173.44 ; H17.1 170.25,172.1 ; H17.1 167.08,173.44 ; JCDRA.47 144.9,172.31 ; JCDRA.47 145.86,169.18 ; JCDRA.47 145.86,172.31 ; JCDRA.47 143.95,169.18 ; JCDRA.47 143.95,172.31 ; JCDRA.47 143.95,170.75 ; JCDRA.47 144.9,169.18 ; JCDRA.47 145.86,170.75 ; JHDMI.11 183.1,168.33 ; JHDMI.11 182.64,167.29 ; JHDMI.11 183.1,167.17 ; JHDMI.11 182.64,168.21 ; JHDMI.11 183.56,168.21 ; JHDMI.11 183.56,167.29 ; H5.1 92.1,83.7 ; H5.1 92.74,85.4 ; H5.1 88.06,85.4 ; H5.1 90.4,83.06 ; H5.1 88.7,87.1 ; H5.1 88.7,83.7 ; H5.1 90.4,87.74 ; H5.1 92.1,87.1 ; JPCMC.36 74.74,72.41 ; JPCMC.36 72.27,69.93 ; JPCMC.36 76.55,71.73 ; JPCMC.36 77.22,69.93 ; JPCMC.36 76.55,68.13 ; JPCMC.36 72.94,68.13 ; 312.27,33 H8.1 ; H8.1 312.76,34.34 ; H8.1 314.1,34.83 ; H8.1 314.1,31.17 ; H8.1 312.76,31.66 ; H8.1 315.44,31.66 ; H8.1 315.44,34.34 ; H8.1 315.93,33 ; H27.1 257.16,76.78 ; H27.1 258.04,74.48 ; H27.1 257.16,72.17 ; H27.1 252.54,76.78 ; H27.1 251.66,74.48 ; H27.1 254.85,77.67 ; H27.1 252.54,72.17 ; H27.1 254.85,71.29 ; JCDRA.50 113.36,172.31 ; JCDRA.50 112.4,172.31 ; JCDRA.50 112.4,169.18 ; JCDRA.50 111.45,170.75 ; JCDRA.50 111.45,172.31 ; JCDRA.50 111.45,169.18 ; JCDRA.50 113.36,170.75 ; JCDRA.50 113.36,169.18 ; JUSB2.7 307.07,70.43 ; JUSB2.7 306.43,70.23 ; JUSB2.7 306.24,69.6 ; JUSB2.7 307.07,68.77 ; JUSB2.7 306.43,68.96 ; 180.1,167.17 JHDMI.5 ; JHDMI.5 180.56,168.21 ; JHDMI.5 179.64,167.29 ; JHDMI.5 180.56,167.29 ; JHDMI.5 180.1,168.33 ; JHDMI.5 179.64,168.21 ; 248.27,53.62 H12.1 ; H12.1 250.1,51.79 ; H12.1 251.93,53.62 ; H12.1 251.44,54.96 ; H12.1 248.76,52.28 ; H12.1 250.1,55.45 ; H12.1 251.44,52.28 ; H12.1 248.76,54.96 ; 306.22,78.33 JUSB2.11 ; JUSB2.11 309.78,77.45 ; JUSB2.11 308,78.33 ; JUSB2.11 309.78,78.33 ; JUSB2.11 306.22,77.45 ; JUSB2.11 306.22,76.57 ; 237.8,162.67 H25.1 ; H25.1 235.71,162.67 ; H25.1 239.88,166.33 ; H25.1 235.71,164.5 ; H25.1 239.88,162.67 ; H25.1 239.88,164.5 ; H25.1 237.8,166.33 ; H25.1 235.71,166.33 ; 185.64,167.29 JHDMI.17 ; JHDMI.17 186.56,168.21 ; JHDMI.17 186.1,168.33 ; JHDMI.17 186.1,167.17 ; JHDMI.17 185.64,168.21 ; JHDMI.17 186.56,167.29 ; JUSB2.12 314.8,78.33 ; JUSB2.12 316.13,78.33 ; JUSB2.12 316.13,77.45 ; JUSB2.12 313.47,78.33 ; JUSB2.12 313.47,77.45
  BOTTOM w0.089: UG5.C3 UG5.C4 ; UG9.P51 204.9,114.85 205.22,115.17 205.22,115.53 205.11,115.64 205.11,116.62 v2(204.2,117.53) ; UG3.C3 UG3.C4
  BOTTOM w0.1: v2(208.45,116.95) 208.45,117.17 v2(207.83,117.79)
  BOTTOM w0.102: CPU1.BJ31 107.02,107.18 107.02,107.79 CPU1.BJ32 ; v2(166.64,134.01) v3(165.69,134.96) ; v3(59.47,34.89) v2(59.47,36) ; UG9.W10 v2(201.4,86.65)
  BOTTOM w0.127: v2(208,111.55) 208,111.05 v2(207.88,110.93) 207.4,111.41 v2(207.4,111.55) ; CPU1.BA7 113.68,89.31 v2(114.76,89.31) v2(115.65,89.31) ; 103.18,92.32 103.16,92.34 103.16,93.9 ; v2(113.83,91.32) 113.88,91.27 114.71,91.27 v2(114.74,91.24) 114.75,91.26 v2(115.64,91.26) ; v2(113.83,91.32) CPU1.BA11 ; v2(113.83,91.32) CPU1.BA10 ; UG9.K40 v2(207,106.95) ; UG9.K19 v2(207,92.25) ; v2(210.94,102.59) 211.06,102.59 v2(211.5,103.03) ; UG9.AH43 v2(195.1,108.35) ; UG9.H40 v2(209.4,107.25) ; UG9.H40 208.45,106.95 v2(208.3,107.1) ; UG9.H40 209.4,106.65 v2(209.43,106.65) ; UG9.BC19 v2(185.3,92.25) ; UG9.BC28 v2(185.3,98.55) ; UG9.H28 209.76,98.55 v2(209.96,98.75) ; UG9.W49 201.24,113.08 v2(201.24,112.79) ; UG9.BD24 183.9,96.55 v2(184.2,96.85) UG9.BD26 ; v2(113.83,90.05) 113.89,89.99 114.71,89.99 v2(114.76,89.94) 114.78,89.96 v2(115.63,89.96) CPU1.AU9 v2(115.65,90.58) 115.58,90.64 v2(114.76,90.64) 113.88,90.64 v2(113.83,90.69) ; v2(114.8,85.41) 113.49,85.41 113.18,85.1 112.75,85.1 CPU1.BB1 ; UG9.AH10 v2(195.1,86.65) ; v3(212.97,23.61) 213.57,23.61 v2(213.58,23.62) ; 195.1,109.67 UG9.AH45 ; v2(208.8,96.15) UG9.H25 v2(209.4,96.75) ; UG9.BC25 v2(185.3,96.45) UG9.BC24 ; UG9.AL10 v2(193,86.65) ; UG9.BC31 v2(185.3,100.65) ; v2(207,100.65) UG9.K31 208.4,100.65 v2(208.65,100.9) ; v2(193,108.35) UG9.AL43 ; UG6.R11 UG6.R12 ; UG9.F31 211.2,100.65 v2(211.35,100.8) UG9.D31 212,100.65 ; UG9.W43 v2(201.4,108.35)
  BOTTOM w0.13: UG9.AB47 199.3,111.06 v2(199.04,110.8)
  BOTTOM w0.15: v2(195.4,109.38) 195.1,109.67 ; v2(210.2,109.35) 210.2,109.45 UG9.F44 210.85,110.1 210.85,110.82 v2(210.85,110.82) ; v2(186.3,112.25) 186.7,112.65 UG9.AY49 ; v2(190.9,108.35) UG9.AP43 ; v2(207,98.55) UG9.K28 208.5,98.55 208.64,98.69 v2(208.64,98.73) ; UG9.K34 v2(207,102.75) ; v2(201.72,112.22) 201.4,111.9 UG9.W47 ; UG9.BJ7 179.7,83.85 v2(179.55,84) ; UG9.BC16 v2(185.3,90.15) ; v2(191.01,109.67) 190.9,109.78 UG9.AP45 ; v2(186.55,115.47) 186.7,115.32 UG9.AY51 ; UG9.AP49 190.9,112.45 v2(191.2,112.15) ; v2(210.9,112.25) UG9.E48 v2(210.9,112.85) ; v2(210.8,109.45) 210.8,109.41 211.16,109.05 ; v2(212.2,112.95) UG9.D49 v2(212.2,113.55) ; UG9.AU10 v2(188.8,86.65) ; UG9.BC13 v2(185.3,88.05) ; v2(203.3,85.45) 203.3,85.73 203.5,85.93 UG9.T10 v2(203.5,86.65) ; v2(210.86,118.89) 210.9,118.85 v2(210.9,118.17) 210.71,117.98 210.71,116.21 v2(210.5,116) ; UG9.AP10 v2(190.9,86.65) ; v2(207,88.05) UG9.K13 ; UG9.K37 v2(207,104.85) ; v2(205.6,86.65) UG9.N10 ; v2(205.83,110.97) 205.83,110.97 205.85,110.97 205.85,110.7 UG9.N45 v2(205.3,110.75) ; v2(212.81,104.69) 212.35,105.15 v2(212.2,105.15) ; v2(207,90.15) UG9.K16 207.9,90.35 v2(208.25,90.35) ; v2(194.8,110.75) 195.25,111.2 v2(195.25,111.42) ; UG9.BC34 v2(185.3,102.75) ; v2(209.96,98.75) 210.14,98.57 210.38,98.57 210.39,98.57 210.48,98.57 UG9.F28 v2(210.8,98.25) 211.03,98.25 v2(211.5,98.72) ; UG9.AL49 193,113.15 192.82,112.96 v2(192.82,112.7) ; UG9.BC22 v2(185.3,94.35) ; v2(196.86,84.9) 197.2,85.24 UG9.AE10 v2(197.2,86.65) ; v2(203.17,110.81) 203.5,111.14 UG9.T47 ; UG9.AU47 v2(188.5,112.15) 188.8,112.45 UG9.AU49 ; UG9.AU47 UG9.AU45 ; UG9.AU47 v2(189.1,112.15) ; v2(207,96.45) UG9.K25 ; v2(210.18,100.36) 210.08,100.36 209.78,100.65 UG9.H31 ; 190.9,111.17 UG9.AP47 ; v2(196.9,112.15) UG9.AE47 v2(197.5,112.15) ; UG9.T45 UG9.T43 v2(203.5,108.35) ; UG9.D16 212.24,90.49 212.64,90.49 v2(212.87,90.25) ; UG9.BC37 v2(185.3,104.85) ; UG9.AB43 v2(199.3,108.35) ; UG9.N43 v2(205.6,108.35) ; v2(199.3,86.65) UG9.AB10 ; UG9.F43 210.54,109.05 v2(210.85,108.74) 211.16,109.05 ; UG9.D43 211.16,109.05 ; v2(207,94.35) UG9.K22 ; v2(186.4,113.55) v2(186.4,114.35) ; 199.11,112.74 v2(199.11,112.69) ; UG9.AE43 v2(197.2,108.35)
  BOTTOM w0.152: UH1.U29 v2(168.24,38.98) ; UH1.U29 167.59,38.33 ; UH1.U29 168.11,38.33 ; UH1.U29 167.63,38.81 ; v2(168.24,38.98) UH1.U28 ; v2(168.24,38.98) UH1.V29 ; 169.79,44.4 UH1.AA17 ; 169.79,44.4 UH1.Y17 169.63,45.02 ; 169.79,44.4 UH1.AA18 ; 169.79,44.4 UH1.Y18 ; UH1.AA17 170.44,45.05 ; UH1.AA17 170.56,44.4 ; UH1.AA17 169.91,45.05 ; UH1.AJ15 UH1.AJ14 ; UH1.AJ15 UH1.AJ17 ; UH1.AJ15 UH1.AH17 ; UH1.AJ26 174.31,40.4 ; UH1.AJ26 174.31,39.88 ; UH1.AJ26 v2(173.66,40.53) ; UH1.AJ26 v2(173.66,39.75) ; UH1.Y29 169.17,38.36 ; UH1.Y29 v2(169.79,38.98) ; UH1.Y29 169.62,38.37 ; UH1.A37 160.21,34.77 UH1.B37 UH1.C37 161.53,35.08 UH1.D36 161.62,35.47 UH1.D35 ; UH1.AF25 172.89,41.3 ; UH1.AF25 v2(172.11,41.3) ; UH1.AF25 172.89,40.53 ; UH1.AF25 v2(172.11,40.53) ; 172.89,41.3 UH1.AH23 172.89,42.08 ; 172.89,41.3 UH1.AF23 ; 172.89,41.3 UH1.AH25 ; UH1.AU45 177.79,30.48 177.45,30.14 v2(177.11,30.14) ; 172.11,39.75 UH1.AE28 ; 172.11,39.75 UH1.AF28 ; 172.11,39.75 UH1.AF26 ; UH1.AE28 172.11,38.98 ; UH1.AE28 v2(171.34,38.98) ; UH1.B25 UH1.A25 159.73,40.46 v2(159.65,40.55) ; UH1.BB21 180.66,42.91 v2(180.83,42.74) ; UH1.Y18 169.79,43.63 ; UH1.Y18 169.01,43.63 ; 169.79,43.63 UH1.AA18 ; 169.79,43.63 UH1.Y20 ; 169.79,43.63 UH1.AA20 ; 172.89,43.63 UH1.AF18 172.11,43.63 ; 172.89,43.63 UH1.AH18 ; 172.89,43.63 UH1.AF20 ; 172.89,43.63 UH1.AH20 172.89,42.85 ; v2(165.98,30.72) 166.31,30.72 166.4,30.8 UH1.P45 ; UH1.AC20 v2(170.56,42.85) ; UH1.AC20 v2(171.34,42.85) ; UH1.AC20 171.34,43.63 ; UH1.AC20 170.56,43.63 ; v2(170.56,42.85) UH1.AA20 ; v2(170.56,42.85) UH1.AA21 ; v2(170.56,42.85) UH1.AC21 ; UH1.U17 167.59,45.05 ; UH1.U17 168.11,45.05 ; UH1.U17 167.59,44.52 ; UH1.U17 167.85,44.78 v2(168.23,44.39) ; UH1.AF29 172.11,38.98 ; UH1.AF29 172.89,38.98 ; UH1.AF29 172.72,38.37 ; UH1.AF29 172.26,38.35 ; 172.11,38.98 UH1.AE29 ; 172.11,38.98 UH1.AF28 ; v2(159.58,43.93) 159.62,43.97 UH1.A18 ; v2(173.66,40.53) UH1.AH25 ; v2(173.66,40.53) UH1.AH26 ; UH1.AH25 172.89,40.53 ; UH1.AJ29 174.03,38.59 v2(173.65,38.97) ; UH1.AJ29 UH1.AL29 UH1.AM29 ; UH1.AJ29 174.31,38.85 ; UH1.AJ29 173.79,38.33 ; UH1.AJ29 174.31,38.33 ; v2(175.25,30.4) 175.25,30.63 UH1.AM45 ; 172.89,40.53 UH1.AH26 ; 172.89,40.53 UH1.AF26 ; 167.59,39.63 UH1.U28 ; UH1.U28 167.59,39.1 ; v2(174.95,43.97) UH1.AM17 ; v2(174.95,43.97) UH1.AM19 ; v2(174.95,43.97) UH1.AL17 ; v2(174.95,43.97) UH1.AL19 ; v2(180.78,40.76) 180.66,40.64 UH1.BB25 ; 172.11,43.63 UH1.AF20 ; 172.11,43.63 UH1.AE18 171.34,43.63 ; 172.11,43.63 UH1.AE20 ; UH1.AF20 v2(172.11,42.85) ; UH1.AF20 172.89,42.85 ; UH1.AF26 v2(172.11,40.53) ; UH1.AF26 172.89,39.75 ; v2(172.11,40.53) UH1.AE25 v2(172.11,41.3) ; v2(169.01,42.85) UH1.Y21 ; v2(169.01,42.85) UH1.V21 v2(169.01,42.08) ; v2(169.01,42.85) UH1.Y20 ; v2(169.01,42.85) UH1.V20 ; UH1.Y21 v2(169.01,42.08) ; UH1.Y21 169.79,42.85 ; v2(169.01,42.08) UH1.V23 v2(169.01,41.3) UH1.V25 v2(169.01,40.53) UH1.Y26 v2(169.79,39.75) UH1.Y28 v2(169.79,38.98) ; v2(173.65,38.97) UH1.AH29 ; v2(173.65,38.97) 173.27,39.35 UH1.AH28 ; v2(173.65,38.97) UH1.AJ28 ; UH1.BB16 180.43,45.03 v2(180.77,45.03) ; v2(172.11,42.85) UH1.AE20 ; v2(172.11,42.85) UH1.AE21 ; v2(172.11,42.85) UH1.AF21 ; v2(171.34,42.85) UH1.AE20 ; v2(171.34,42.85) UH1.AC21 ; v2(171.34,42.85) UH1.AE21 ; UH1.AH26 172.89,39.75 ; UH1.AH26 v2(173.66,39.75) ; CPU1.BA6 113.91,88.34 114.24,88.66 v2(114.82,88.66) 115.57,88.66 v2(115.61,88.7) ; UH1.AA20 170.56,43.63 ; UH1.AA20 169.79,42.85 ; 170.56,43.63 UH1.AC18 ; 170.56,43.63 UH1.AA18 ; UH1.AC18 171.34,43.63 ; UH1.AC18 170.56,44.4 ; UH1.AF28 172.89,39.75 ; UH1.AF28 172.89,38.98 ; v2(172.11,41.3) UH1.AF23 ; UH1.AA18 170.56,44.4 ; CPU1.T7 132.89,89 133.21,88.67 134.19,88.67 CPU1.P6 ; v2(169.79,38.98) UH1.AA29 ; UH1.AH28 172.89,38.98 ; UH1.AH28 172.89,39.75 ; UH1.AH28 v2(173.66,39.75) ; v2(168.23,44.39) UH1.U18 168.21,43.65 ; v2(168.23,44.39) 168.62,44.01 UH1.V18 ; UH1.AF23 v2(172.11,42.08) ; UH1.AF23 172.89,42.08 ; v2(172.11,42.08) UH1.AE21 ; v2(172.11,42.08) UH1.AF21 ; UH1.AE20 171.34,43.63 ; UH1.AH17 173.01,45.05 ; UH1.AH17 173.54,45.05 ; v2(172.98,30.46) 173.22,30.69 UH1.AH45 ; UH1.BE14 182.19,46.23 v2(182.36,46.06) ; UH1.V18 168.21,43.65 ; UH1.V18 169.01,43.63 ; 172.89,38.98 UH1.AH29 ; UH1.AR42 176.72,32.71 v2(176.53,32.9) ; v2(182.18,37.29) 182.02,37.14 UH1.BE32 ; v2(161.67,30.33) 161.49,30.51 UH1.D45 ; v2(180.77,36.02) 180.31,36.12 UH1.BB34 ; v2(180.75,38.2) 180.31,38.38 UH1.BB30 ; UH1.AE29 171.5,38.37 ; UH1.AE29 171.93,38.39 ; UH1.AE29 v2(171.34,38.98) ; UH1.V20 168.21,43.65 ; UH1.V20 169.01,43.63 ; UH1.AH29 173.54,38.33 ; UH1.AH29 173.06,38.37 ; 172.89,42.85 UH1.AF21 ; 172.89,42.85 UH1.AH21 172.89,42.08 ; UH1.AE21 v2(171.34,42.08) UH1.AC21 ; UH1.Y20 169.79,42.85 ; UH1.Y20 169.01,43.63 ; v2(170.95,52.95) 170.96,52.94 UH1.AC1 ; v2(179.81,47.24) 180.06,47.24 UH1.BB11 ; 174.31,44.52 UH1.AJ17 ; UH1.AJ17 174.31,45.05 ; UH1.A32 159.95,37.15 159.84,37.25 159.64,37.25 v2(159.64,37.25) ; UH1.BE18 182.44,43.96 v2(182.57,43.82) ; UH1.AF21 172.89,42.08 ; 169.79,42.85 UH1.AA21 ; UH1.AA21 170.18,42.45 v2(170.56,42.07) UH1.AC21 ; UH1.V29 168.84,38.38 ; UH1.V29 168.4,38.37 ; v2(177.97,53.02) 177.97,52.67 UH1.AU1 ; v2(212.2,87.65) 212.2,87.75 UG9.D13 211.75,88.2 v2(211.49,88.2) ; UH1.H24 v2(163.89,40.5) ; UH1.AK42 174.48,32.33 174.48,32 174.37,31.9 v2(174.37,31.83) ; UH1.AC29 v2(171.34,38.98) ; UH1.AC29 170.71,38.35 ; UH1.AC29 171.18,38.36 ; UH1.AC29 v2(170.56,38.98) UH1.AA29 ; v2(168.54,30.02) 168.9,30.38 168.9,30.65 UH1.V45 ; UH1.AA25 v2(170.56,41.3) UH1.AC25 ; UH1.AA29 169.95,38.36 ; UH1.AA29 170.4,38.36 ; CPU1.G26 139.25,103.89 139.25,104.59 139.56,104.91 CPU1.G28 ; 174.28,44.24 UH1.AJ18 174.31,43.75 ; v2(173.25,53.72) 173.36,53.6 173.36,52.64 UH1.AH1 ; v2(170.58,30.39) 170.94,30.75 UH1.AC45 ; v2(183.21,42.2) 183.21,42.2 182.83,41.81 181.9,41.81 UH1.BE23 ; UH1.AJ28 174.31,39.1 ; UH1.AJ28 174.31,39.63 ; UH1.AJ28 v2(173.66,39.75)
  BOTTOM w0.165: CPU1.K2 138.18,85.74 138.5,86.06 v2(139.91,86.06) ; v2(124.88,88.59) 124.95,88.66 125.82,88.66 CPU1.AE6 ; v2(105.75,99.8) 105.76,99.81 105.76,100.58 ; CPU1.AN6 119.11,88.34 118.78,88.01 118.09,88.01 CPU1.AR5 ; UG2.H2 181.52,135.15 180.77,135.15 UG2.H1
  BOTTOM w0.2: v2(210.2,103.15) 209.97,102.92 v2(209.62,102.92) ; v2(189.04,109.51) v2(188.52,110.03) ; v2(203.9,113.55) 203.6,113.85 v2(203.6,114.15) ; UG9.BH21 UG9.BJ21 UG9.BJ19 ; UG9.B16 212.97,90.15 v2(212.87,90.25) ; UG9.BH39 UG9.BJ39 ; UG9.BJ39 UG9.BJ40 ; UG9.BJ39 UG9.BJ37 ; 190.9,111.17 190.9,111.11 v2(190.7,110.92) 190.7,110.65 UG9.AP45 ; UG9.BH18 UG9.BJ18 UG9.BJ16 ; UG9.BH30 UG9.BJ30 UG9.BJ28 ; UG9.K22 v2(208,94.65)
  BOTTOM w0.203: v2(111.09,90.05) 110.84,90.3 CPU1.BD9 ; v2(111.09,90.05) 111.09,89.35 110.73,89 CPU1.BD7 ; v2(111.09,90.05) 110.68,89.65 CPU1.BD8 ; v2(113.83,90.05) v2(113.83,90.69) 113.57,90.95 CPU1.BA10 ; v2(113.83,90.05) 113.58,90.3 CPU1.BA9 ; v2(113.83,90.05) 113.42,89.65 CPU1.BA8 ; CPU1.BE6 110.08,88.2 110.08,87.83 CPU1.BE5 110.22,87.56 110.23,87.55 110.23,87.17 110.22,87.16 CPU1.BE4 110.22,86.91 110.23,86.9 110.23,86.52 110.22,86.51 CPU1.BE3 ; CPU1.BE6 CPU1.BF6 CPU1.BG6 CPU1.BH6 ; CPU1.BE6 110.47,88.59 110.64,88.59 ; CPU1.N3 135.25,86.39 v2(134.92,86.06) ; CPU1.N3 CPU1.N4 CPU1.N5 ; CPU1.N3 135.38,86.37 135.38,85.75 CPU1.N2 CPU1.N1 135.36,84.95 135.36,84.95 135.36,84.37 135.36,84.37 v2(135.36,84.31) ; CPU1.A18 144.26,97.28 v2(144.35,97.37) ; CPU1.AM37 120.46,111.06 v2(120.78,111.39) 120.45,111.71 CPU1.AM38 ; v2(127.54,91.96) 127.83,92.25 CPU1.AC12 128.26,92.51 128.66,92.51 CPU1.AA12 CPU1.Y13 ; v2(127.54,91.96) 127.26,92.25 CPU1.AD12 127.01,92.17 127.01,91.67 CPU1.AD11 ; v2(127.54,91.96) 127.54,91.33 v2(127.55,91.32) 127.46,91.32 CPU1.AD10 ; v2(127.54,91.96) 127.49,91.96 127.13,91.6 CPU1.AD11 ; v2(113.83,92.59) 113.72,92.59 CPU1.BA12 ; CPU1.BH12 107.75,92.25 v2(107.43,91.92) 107.06,92.29 CPU1.BJ12 106.71,92.37 v2(106.57,92.52) 106.74,92.69 CPU1.BK13 106.74,93.17 106.47,93.43 ; CPU1.BH12 CPU1.BH11 ; CPU1.BH12 108.05,92.25 v2(108.34,91.96) 108.63,92.25 CPU1.BG12 CPU1.BG13 ; CPU1.AP12 119.21,92.61 v2(119.33,92.61) 119.41,92.61 CPU1.AN12 ; CPU1.AP12 119.03,92.25 v2(119.31,91.96) ; CPU1.AP12 118.52,91.91 ; CPU1.AP12 118.53,92.58 v2(118.4,92.58) 118.26,92.58 CPU1.AR13 ; CPU1.U38 v2(132.59,111.39) CPU1.U37 ; CPU1.N6 135.4,88.3 135.4,87.73 CPU1.N5 ; CPU1.N6 v2(134.91,88.68) ; CPU1.N6 v2(134.91,88.03) ; CPU1.N6 CPU1.M6 ; CPU1.W3 130.22,86.39 129.89,86.06 v2(129.89,86.09) ; CPU1.W3 CPU1.W4 CPU1.W5 130.73,88.09 130.92,88.09 CPU1.V6 CPU1.U6 132.32,88.65 132.32,88.75 CPU1.T7 CPU1.T8 CPU1.T9 ; CPU1.W3 130.37,86.35 130.37,85.77 CPU1.W2 130.33,85.61 130.33,85.39 CPU1.W1 130.33,84.37 v2(129.89,84) ; v2(173.66,44.39) 174.03,44.01 UH1.AJ18 174.05,44.01 v2(173.66,43.62) ; v2(173.66,44.39) 174.05,44.78 UH1.AJ17 ; v2(173.66,44.39) 173.28,44.01 UH1.AH18 173.27,44 v2(173.66,43.62) ; v2(173.66,44.39) 173.27,44.77 UH1.AH17 ; UH1.AE42 v2(172.18,32.88) ; v2(239.05,93.95) 239.02,93.98 238.28,93.98 ; CPU1.AH33 123.61,108.46 v2(123.93,108.78) 123.6,109.11 CPU1.AH34 ; UG9.BH27 UG9.BJ27 UG9.BJ26 UG9.BJ25 180.28,96.33 v2(179.99,96.33) 180.4,95.92 UG9.BJ24 ; CPU1.BM26 105.44,103.28 v2(105.76,102.95) ; CPU1.A6 143.46,88.63 143.02,88.19 142.66,88.19 142.3,87.83 CPU1.C5 141.67,87.34 v2(141.33,87.34) ; v2(116.84,109.43) 116.52,109.11 CPU1.AU34 ; CPU1.AU11 116.29,91.6 116.38,91.5 116.4,91.5 v2(116.58,91.32) ; CPU1.AU11 v2(115.64,91.26) 115.8,91.26 CPU1.AU10 ; CPU1.AU11 CPU1.AU12 ; CPU1.AU11 v2(115.66,91.93) CPU1.AU12 ; CPU1.AU11 CPU1.AU10 ; v2(101.76,90.65) 101.87,90.76 101.89,90.76 102,90.87 102.71,90.87 CPU1.BT9 ; v2(142.26,112.62) 141.98,112.34 141.78,112.34 141.37,111.92 CPU1.D38 ; v2(142.49,89.8) 142.49,89.73 CPU1.C8 CPU1.D6 ; v2(142.49,89.8) 142.16,90.12 CPU1.C9 141.76,90.59 ; v2(142.49,89.8) 142.65,89.96 142.65,90.03 CPU1.B9 CPU1.A9 ; CPU1.BH11 CPU1.BH10 ; CPU1.BH11 108.16,91.32 v2(108.35,91.32) ; CPU1.AR38 118.1,111.71 v2(118.42,112.04) ; CPU1.G22 139.56,100.36 v2(139.89,100.04) 140.21,99.71 CPU1.F21 ; CPU1.AV37 115.74,111.06 v2(116.06,111.39) 115.73,111.71 CPU1.AV38 ; v2(142.49,94.52) 142.49,94.59 CPU1.C15 141.76,95.31 141.76,95.45 CPU1.D16 ; CPU1.BH8 CPU1.BH9 ; CPU1.BH8 107.94,89.65 v2(108.34,90.05) ; CPU1.BH8 CPU1.BH7 ; CPU1.BH9 CPU1.BH10 ; CPU1.BH9 108.1,90.3 v2(108.34,90.05) ; CPU1.AG8 CPU1.AG7 ; v2(203.9,113.55) 203.6,113.25 UG9.T49 203.5,113.09 203.4,112.99 203.4,112.8 v2(203.3,112.7) ; v2(179.99,100.53) 179.99,100.36 UG9.BJ30 ; v2(179.99,100.53) 179.93,100.59 v2(179.42,100.59) 179.36,100.65 UG9.BL31 ; v2(179.99,100.53) 180.28,100.53 UG9.BJ31 UG9.BJ32 UG9.BJ33 ; CPU1.BM29 105.32,105.59 105.32,105.04 CPU1.BM28 105.44,104.85 v2(105.76,104.53) 105.76,104.46 CPU1.BM27 ; CPU1.BM29 CPU1.BN29 CPU1.BP29 CPU1.BR29 ; CPU1.BM29 105.5,105.78 106.02,105.78 CPU1.BL29 106.3,105.92 CPU1.BK29 107.14,106.32 CPU1.BJ30 107,106.44 v2(106.61,106.83) 106.94,107.16 CPU1.BJ31 ; UV21.18 156.52,110.44 v2(156.8,110.72) ; CPU1.BT4 102.77,87.04 102.39,87.04 v2(102.26,86.91) ; CPU1.AU12 116.2,92.25 v2(116.56,92.61) ; CPU1.AU12 116.01,92.25 v2(115.68,92.58) 115.53,92.58 CPU1.AW12 115.2,92.26 114.85,92.61 v2(114.75,92.61) ; v2(144.1,95.7) CPU1.A16 ; v2(139.9,102.41) 139.9,102.48 CPU1.F25 ; CPU1.Y14 129.93,93.55 v2(130.26,93.22) 129.93,92.9 CPU1.Y13 ; CPU1.AW4 115.19,87.04 ; 115.19,87.04 115.16,87.04 v2(114.82,86.7) 115.14,86.39 CPU1.AW3 ; 115.19,87.04 v2(114.82,87.4) 115.11,87.69 CPU1.AW5 v2(115.65,88.09) 115.83,88.09 CPU1.AU6 ; CPU1.AR1 CPU1.AR2 ; CPU1.AR1 117.76,83.64 v2(117.77,83.62) ; CPU1.AR1 v2(117.31,84.62) ; CPU1.AR2 v2(117.31,85.32) ; CPU1.AR2 117.8,85.77 117.8,86.35 CPU1.AR3 117.77,86.4 117.77,86.9 117.76,86.91 CPU1.AR4 117.76,87.17 117.81,87.22 117.81,87.5 117.76,87.55 CPU1.AR5 ; v2(122.36,110.74) 122.68,111.06 CPU1.AJ37 122.75,111.13 122.69,111.2 122.69,111.57 122.75,111.64 CPU1.AJ38 ; CPU1.N8 CPU1.N9 ; CPU1.N8 CPU1.N7 v2(134.91,88.68) ; CPU1.N8 135.77,90.1 v2(135.77,90.57) 135.71,90.57 135.43,90.3 CPU1.N9 ; CPU1.N9 CPU1.N10 CPU1.N11 ; v2(101.51,92.44) 101.54,92.47 102.69,92.47 CPU1.BT12 CPU1.BR12 103.61,92.32 103.64,92.3 103.98,92.3 104.01,92.32 CPU1.BP12 104.19,92.27 104.26,92.27 104.27,92.26 104.65,92.26 104.66,92.27 104.74,92.27 CPU1.BN12 ; CPU1.BD10 CPU1.BD11 ; CPU1.BD10 CPU1.BD9 ; CPU1.BD10 110.83,90.95 v2(111.09,90.69) ; CPU1.BD11 110.9,91.32 v2(111.09,91.32) ; CPU1.BD11 CPU1.BD12 110.8,92.25 v2(111.09,91.96) 111.37,92.25 CPU1.BC12 CPU1.BC13 111.35,92.9 v2(111.07,92.62) ; v2(134.91,88.03) CPU1.N5 ; v2(134.91,88.03) CPU1.P6 v2(134.91,88.68) ; CPU1.AL9 121.99,90.69 v2(122.06,90.69) ; CPU1.AL9 CPU1.AL10 ; CPU1.AL9 121.48,90.3 v2(121.15,90.63) ; CPU1.AL9 CPU1.AL8 ; v2(112.35,88.01) 112.68,88.34 CPU1.BB6 ; v2(112.35,88.01) 112.03,88.34 CPU1.BC6 CPU1.BD6 110.8,88.59 110.64,88.59 ; v2(112.35,88.01) 112.35,87.98 112.65,87.69 CPU1.BB5 ; CPU1.D14 141.76,93.88 141.76,93.74 CPU1.C13 142.16,93.27 v2(142.49,92.95) ; v2(108.34,93.23) 108.67,92.9 CPU1.BG13 ; CPU1.Y13 CPU1.W12 131.01,92.51 131.4,92.51 CPU1.V12 131.79,92.25 132.06,92.51 132.31,92.51 CPU1.T12 ; 105.11,91.96 104.79,92.28 CPU1.BN12 ; 105.11,91.96 105.44,91.63 CPU1.BM11 105.44,91.47 105.11,91.14 ; 105.11,91.96 105.44,92.28 CPU1.BM12 105.76,92.65 v2(105.76,92.72) 105.76,92.79 CPU1.BL13 106.41,93.43 106.47,93.43 ; CPU1.E34 140.86,109.18 140.92,109.24 140.92,109.7 CPU1.E35 ; 132.96,90.69 132.83,90.69 CPU1.T10 ; 132.96,90.69 CPU1.T9 ; 132.96,90.69 v2(133.04,90.69) ; CPU1.BN9 104.79,90.82 105.11,91.14 ; U17.11 v2(57.47,60.4) ; CPU1.AM5 120.21,87.69 v2(119.88,87.36) 119.71,87.36 CPU1.AN5 119.39,88.29 CPU1.AN6 119.44,88.72 119.3,88.86 119.3,89.21 CPU1.AP8 118.91,89.65 v2(119.31,90.05) ; CPU1.BF33 109.44,108.46 v2(109.76,108.78) 109.43,109.11 CPU1.BF34 ; CPU1.G26 139.56,103.61 v2(139.9,103.95) 139.9,104.13 140.14,104.36 CPU1.F27 ; CPU1.N12 135.46,92.25 v2(135.78,91.93) ; CPU1.N12 135.06,92.51 134.66,92.51 CPU1.P12 134.14,92.51 133.75,92.51 CPU1.R12 133.32,92.25 v2(133.03,91.96) 132.74,92.25 CPU1.T12 ; CPU1.N12 CPU1.N11 ; CPU1.E4 CPU1.F4 ; CPU1.F4 CPU1.G4 139.45,87.04 139.12,87.36 ; CPU1.F4 140.3,86.93 CPU1.F3 ; CPU1.AP9 119.07,90.3 v2(119.31,90.05) ; v2(102.19,103.48) 102.33,103.35 CPU1.BT26 ; v2(139.89,92.15) 139.89,92.08 CPU1.F11 ; CPU1.AU6 115.72,88.7 v2(115.61,88.7) ; CPU1.AU6 116.11,88.37 CPU1.AU7 ; CPU1.BH10 108.08,90.95 v2(108.34,90.69) ; CPU1.BN12 105.1,92.64 v2(105.1,92.71) 105.44,93.04 CPU1.BM13 ; v2(124.88,88.59) 124.72,88.59 CPU1.AG6 CPU1.AH6 CPU1.AJ6 122.54,88.59 122.2,88.59 122.1,88.69 121.91,88.69 CPU1.AL7 CPU1.AL8 ; v2(144.47,102) CPU1.A24 ; CPU1.C37 CPU1.B37 142.91,111.14 CPU1.A37 143.72,111.4 v2(143.72,111.8) ; CPU1.BB5 112.73,87.56 112.8,87.5 112.8,87.22 112.73,87.16 CPU1.BB4 112.73,86.91 112.8,86.85 112.8,86.57 112.73,86.51 CPU1.BB3 ; CPU1.BB5 112.89,87.85 112.89,88.17 CPU1.BB6 ; CPU1.BL35 106.02,109.76 v2(105.78,110) 105.44,109.66 CPU1.BM35 ; v2(173.66,43.62) 173.28,43.24 UH1.AH20 ; CPU1.AD7 CPU1.AD8 CPU1.AD9 ; v2(135.84,168.36) 135.84,168.81 135.65,168.99 135.65,169.56 135.85,169.76 JCDRA.41 ; CPU1.AD9 126.87,90.3 v2(126.61,90.03) ; CPU1.AD9 CPU1.AD10 ; UV21.57 157.47,104.04 157.59,104.16 v2(158.07,104.16) ; v2(114.75,92.61) 114.75,93.08 CPU1.AY14 114.15,93.55 v2(113.83,93.87) ; v2(114.75,92.61) 114.38,92.25 CPU1.AY12 114,91.96 v2(113.83,91.96) 113.73,91.96 CPU1.BA11 ; CPU1.BN7 CPU1.BM7 105.19,89.43 105.19,89.71 CPU1.BM8 105.19,90.21 105.19,90.5 CPU1.BM9 105.44,90.82 105.11,91.14 ; CPU1.BN7 CPU1.BP7 CPU1.BR7 103.4,89.26 102.07,89.26 101.61,88.8 101.27,88.8 100.7,88.23 v2(100.46,88.23) ; CPU1.BN7 104.86,89.1 v2(104.86,88.64) 105.23,88.26 CPU1.BM6 ; v2(144.1,98.85) CPU1.A20 ; v2(140.53,105.6) 140.53,105.66 140.26,105.94 CPU1.F29 ; v2(108.34,90.05) 108.37,90.03 108.37,89.3 108.06,89 CPU1.BH7 ; UG9.V52 202.1,116.01 201.96,116.15 201.96,116.61 v2(202.1,116.75) ; v2(119.31,91.96) 119.32,91.96 v2(119.32,91.32) v2(119.31,90.69) ; v2(119.31,91.96) 119.48,91.96 CPU1.AN12 ; v2(119.31,91.96) 119.22,91.96 CPU1.AP11 118.55,91.91 118.52,91.91 ; CPU1.BB3 112.82,86.3 112.82,85.82 CPU1.BB2 112.73,85.6 112.77,85.55 112.77,85.27 112.73,85.22 CPU1.BB1 112.78,85.04 112.78,84.55 v2(112.38,84.15) ; CPU1.BB3 112.63,86.39 112.35,86.11 v2(112.35,86.06) ; CPU1.D24 141.76,101.75 141.76,101.61 CPU1.C23 142.16,101.15 v2(142.49,100.82) ; v2(212.75,106.8) 212.9,106.95 UG9.B40 ; CPU1.AM4 120.28,86.91 120.3,86.88 120.3,86.54 120.28,86.51 CPU1.AM3 CPU1.AM2 CPU1.AM1 v2(120.28,84.54) ; 118.52,91.91 v2(118.44,91.91) ; 110.64,88.59 110.63,88.6 CPU1.BD7 ; CPU1.BR34 CPU1.BP34 104.46,108.53 v2(104.46,108.47) 104.79,108.79 CPU1.BN34 ; 134.93,108.78 135.32,108.46 CPU1.N33 ; 134.93,108.78 135.32,109.11 CPU1.N34 ; 134.93,108.78 v2(134.92,108.78) ; UG9.AF45 196.8,110.75 v2(196.9,110.75) UG9.AE45 197.38,110.27 v2(197.38,110) ; v2(122.06,90.69) v2(122.06,90.05) 121.65,89.65 CPU1.AL8 ; v2(122.06,90.69) v2(122.06,91.32) 121.98,91.32 CPU1.AL10 ; CPU1.BN19 104.79,97.9 v2(104.46,98.23) 104.46,98.3 CPU1.BN20 104.79,98.69 v2(104.48,99) ; v2(179.99,102.63) 179.93,102.69 v2(179.43,102.69) 179.38,102.75 UG9.BL34 ; v2(179.99,102.63) 180.28,102.63 UG9.BJ34 UG9.BJ35 UG9.BJ36 ; v2(179.99,102.63) 179.99,102.46 UG9.BJ33 ; UH1.AM24 v2(174.91,40.5) UH1.AL24 ; CPU1.BA10 CPU1.BA9 ; CPU1.BA10 CPU1.BA11 ; CPU1.BH7 107.7,88.81 CPU1.BH6 ; CPU1.T10 132.73,91.1 132.82,91.1 v2(133.04,91.32) 132.81,91.55 132.73,91.55 132.68,91.6 CPU1.T11 ; CPU1.T10 CPU1.T11 ; CPU1.T10 CPU1.T9 ; CPU1.B3 142.89,86.34 CPU1.A3 CPU1.A4 ; v2(142.49,96.1) 142.16,96.42 CPU1.C17 141.85,96.8 141.85,96.94 CPU1.D18 ; CPU1.BD37 111.01,111.06 v2(111.33,111.39) 111,111.71 CPU1.BD38 ; 141.76,90.59 141.76,90.73 CPU1.D10 ; 141.76,90.59 CPU1.D9 ; CPU1.Y10 CPU1.Y9 CPU1.Y8 CPU1.Y7 129.58,88.75 129.17,88.75 129.06,88.64 128.96,88.64 CPU1.AB6 CPU1.AC6 v2(127.37,87.96) CPU1.AC5 v2(127.38,87.36) CPU1.AC4 ; CPU1.Y10 129.92,90.95 v2(130.29,91.32) 130.11,91.5 130.1,91.5 130,91.6 CPU1.Y11 CPU1.Y10 ; CPU1.BA8 CPU1.BA7 113.12,88.75 113.12,88.72 CPU1.BB6 ; CPU1.BA8 CPU1.BA9 ; CPU1.AE6 126.48,88 v2(126.56,88) 126.65,88 CPU1.AD6 ; v2(126.31,169.46) 126.25,169.52 JCDRA.17 ; v2(207,140.36) v2(206.21,140.36) ; v2(175.71,42.83) UH1.AN22 ; CPU1.K3 137.88,86.51 137.89,86.52 137.89,86.9 137.88,86.91 CPU1.K4 ; CPU1.K3 138.02,86.24 138.02,86.05 137.88,85.91 CPU1.K2 CPU1.K1 ; CPU1.K3 137.82,86.39 v2(137.44,86) ; CPU1.BH5 107.56,87.69 v2(107.26,87.99) ; CPU1.BH5 107.7,87.78 107.74,87.82 107.74,88.2 107.7,88.24 CPU1.BH6 ; CPU1.BH5 CPU1.BH4 CPU1.BH3 107.65,86.39 v2(107.27,86) 107.53,85.74 CPU1.BH2 107.45,85.48 CPU1.BH1 107.45,84.53 v2(107.66,84.32) ; 139.12,87.36 138.8,87.04 CPU1.J4 CPU1.K4 ; 139.12,87.36 139.45,87.69 CPU1.G5 ; v2(139.24,92.16) 139.56,92.49 CPU1.G12 139.83,92.82 139.83,92.96 CPU1.F13 ; v2(139.24,92.16) 138.91,91.84 CPU1.H11 ; v2(139.24,92.16) 138.99,92.16 138.99,92.41 138.91,92.49 CPU1.H12 ; CPU1.T33 v2(133.38,108.78) 133.05,109.11 CPU1.T34 ; UG9.BJ36 UG9.BH36 ; UG9.BJ36 180.4,104.31 v2(179.98,104.73) ; CPU1.BM38 105.58,111.72 v2(105.94,112.09) 106.29,111.75 CPU1.BL38 ; CPU1.D22 141.76,100.18 141.76,100.04 CPU1.C21 142.49,99.31 v2(142.49,99.19) ; v2(179.43,92.13) 179.31,92.25 UG9.BL19 ; CPU1.AN12 120.03,92.51 120.43,92.51 CPU1.AM12 121.13,92.25 ; v2(159.34,110.72) 159.61,110.44 UV21.33 ; v2(104.48,99) 104.79,99.3 CPU1.BN21 104.93,99.41 104.99,99.35 105.31,99.35 105.36,99.41 CPU1.BM21 105.44,99.48 v2(105.75,99.8) ; v2(104.48,99) 104.14,99.34 CPU1.BP21 CPU1.BR21 CPU1.BT21 v2(102.06,99.41) ; CPU1.K38 137.29,112.13 v2(137.25,112.13) ; v2(179.99,98.43) 179.9,98.52 v2(179.44,98.52) 179.41,98.55 UG9.BL28 ; CPU1.G5 139.52,87.76 139.57,87.81 139.57,88.19 139.52,88.25 CPU1.G6 ; CPU1.G5 139.66,87.83 CPU1.F5 ; CPU1.BF12 109.6,92.25 v2(109.3,92.55) 109.15,92.55 CPU1.BG13 ; CPU1.BD7 CPU1.BD8 ; CPU1.BD8 CPU1.BD9 ; v2(116.84,108.13) 116.52,108.46 CPU1.AU33 ; UG9.F40 210.73,107.18 v2(210.97,107.18) ; v2(107.26,87.99) 107.16,87.99 106.86,88.29 CPU1.BK6 CPU1.BL6 105.32,88.34 CPU1.BM6 ; v2(107.26,87.99) 107.26,88.18 107.42,88.34 CPU1.BH6 ; CPU1.BT5 102.81,87.88 101.87,87.88 v2(101.84,87.86) ; 238.28,93.98 UG6.N14 ; 238.28,93.98 238.28,94.72 v2(238.25,94.75) ; v2(161.51,107.24) UV21.41 ; JCDRA.20 127.45,169.47 v2(127.42,169.44) ; CPU1.BB6 CPU1.BA6 ; v2(140.54,89.8) 140.86,90.12 CPU1.E9 ; v2(140.54,89.8) 140.21,90.12 CPU1.F9 140.21,90.26 v2(139.89,90.59) ; v2(140.54,89.8) 140.21,89.47 CPU1.F8 CPU1.G8 ; v2(114.8,86.06) 114.92,86.06 CPU1.AW3 ; v2(200.32,146.02) 200.32,146.85 UL1.27 ; UH1.BE40 181.76,33.27 182.2,33.71 v2(182.35,33.71) ; CPU1.AR13 118.27,93.22 v2(118.4,93.22) 118.08,93.55 CPU1.AR14 117.81,93.55 v2(117.49,93.22) ; CPU1.AR13 117.61,92.57 v2(117.5,92.57) ; v2(122.06,92.6) 122.06,92.6 v2(122.06,93.24) 122,93.24 121.69,93.55 CPU1.AL14 ; CPU1.AW3 115.28,86.35 115.28,85.77 CPU1.AW2 115.28,85.7 115.28,85.12 CPU1.AW1 115.1,85.09 114.8,85.38 v2(114.8,85.41) ; v2(144.68,94.13) CPU1.A14 ; v2(142.49,91.37) 142.16,91.7 CPU1.C11 141.88,92.05 141.88,92.19 CPU1.D12 ; 105.11,96.65 104.79,96.98 CPU1.BN18 CPU1.BP18 CPU1.BR18 CPU1.BT18 v2(101.97,97.05) ; JCDRA.8 122.65,169.49 v2(122.7,169.44) ; CPU1.C29 142.14,105.91 142.14,105.91 v2(142.48,105.57) ; CPU1.AU7 115.96,89 v2(115.65,89.31) 115.77,89.31 CPU1.AU8 CPU1.AU9 CPU1.AU10 ; CPU1.AU7 v2(116.61,89.26) ; CPU1.AU7 CPU1.AT6 ; v2(126.29,108.13) CPU1.AE33 CPU1.AE34 ; CPU1.M14 CPU1.M13 CPU1.M12 136.09,92.25 v2(135.78,91.93) ; CPU1.J36 138.75,110.16 138.89,110.16 CPU1.H35 139.36,109.76 139.68,110.08 139.74,110.08 CPU1.F36 140.39,110.73 v2(140.47,110.73) 140.44,110.76 140.44,111.58 CPU1.E38 ; v2(143.99,109.31) 143.7,109.31 CPU1.A34 ; CPU1.BM6 105.23,87.71 CPU1.BM5 ; CPU1.AC4 127.7,87.04 v2(127.37,86.71) ; CPU1.AC4 127.84,87.02 127.84,86.4 CPU1.AC3 CPU1.AC2 127.82,85.69 127.81,85.69 127.82,85.56 CPU1.AC1 v2(127.82,84.54) ; v2(102.06,108.01) CPU1.BT32 ; v2(119.31,90.69) v2(119.31,90.05) ; v2(119.31,90.69) 119.06,90.95 CPU1.AP10 ; UG12.11 v2(194.58,71.33) ; CPU1.AD10 CPU1.AD11 ; CPU1.G24 139.56,101.94 v2(139.89,101.61) 139.56,101.29 CPU1.G23 ; v2(118.42,110.73) 118.09,111.06 CPU1.AR37 ; CPU1.N11 135.44,91.6 v2(135.78,91.93) ; CPU1.AL10 121.47,90.95 v2(121.15,90.63) ; CPU1.L33 137,108.46 v2(137.32,108.78) 136.99,109.11 CPU1.L34 ; CPU1.Y37 v2(130.23,111.39) CPU1.Y38 ; CPU1.AG11 124.45,91.6 v2(124.76,91.92) 124.93,91.92 CPU1.AF12 CPU1.AF13 CPU1.AF14 ; CPU1.BA11 CPU1.BA12 ; CPU1.BA38 113.3,111.64 113.36,111.57 113.36,111.2 113.3,111.13 CPU1.BA37 113.37,111.06 v2(113.69,110.73) ; CPU1.AL33 121.1,108.46 v2(120.78,108.78) 121.11,109.11 CPU1.AL34 ; CPU1.AY34 114.15,109.11 v2(114.48,108.78) 114.16,108.46 CPU1.AY33 ; v2(182.32,34.89) 182.26,34.84 UH1.BE37 ; v2(137.38,169.5) 137.05,169.82 JCDRA.44 ; CPU1.T3 CPU1.T4 CPU1.T5 ; CPU1.T3 132.9,86.34 132.9,85.79 CPU1.T2 CPU1.T1 132.85,84.99 132.85,84.99 132.85,84.58 v2(132.4,84.12) ; CPU1.T3 132.73,86.39 v2(132.41,86.08) ; CPU1.AF3 v2(124.87,86.05) CPU1.AF2 ; CPU1.BA12 113.24,92.25 v2(112.91,92.57) 112.78,92.57 CPU1.BB12 112.19,92.52 v2(112,92.52) ; CPU1.BE3 110.22,86.26 110.23,86.25 110.23,85.87 110.22,85.86 CPU1.BE2 CPU1.BE1 110.22,84.57 v2(109.77,84.12) ; CPU1.BE3 110.22,86.39 109.8,85.97 v2(109.76,85.97) ; CPU1.G20 139.56,98.79 v2(139.89,98.46) 140.21,98.14 CPU1.F19 ; v2(144.1,92.55) CPU1.A12 ; v2(112.12,109.43) 111.8,109.11 CPU1.BC34 ; 106.47,93.43 106.74,93.69 CPU1.BK14 106.74,93.9 v2(106.35,94.29) CPU1.BK15 CPU1.BJ15 ; UG9.AV45 v2(188.52,110.03) 189.03,110.03 v2(189.1,110.1) ; v2(144.01,107.08) 143.86,106.93 CPU1.A30 ; UG9.K51 207.7,114.49 207.54,114.33 v2(207.54,114.19) ; CPU1.AH12 123.24,92.06 v2(122.97,92.06) ; UH1.H27 v2(163.89,39.45) UH1.K27 ; v2(131.03,108.77) 130.69,109.11 CPU1.W34 ; v2(103.01,112.13) CPU1.BR38 ; v2(139.91,86.06) 140.23,85.74 CPU1.F2 ; CPU1.K4 137.88,87.16 137.89,87.17 137.89,87.55 137.88,87.56 CPU1.K5 137.55,88.01 v2(137.44,88.01) ; 139.52,89.36 139.14,88.98 CPU1.J7 ; CPU1.C27 141.76,104.76 141.76,104.9 CPU1.D28 ; v2(137.69,97.28) CPU1.J18 CPU1.H18 138.95,97.19 139.47,97.19 CPU1.G18 139.56,97.21 v2(139.89,96.89) 140.21,96.56 CPU1.F17 139.89,96.17 v2(139.89,96.09) ; v2(121.15,90.63) 121.13,90.64 121.13,92.25 ; CPU1.T11 CPU1.T12 ; v2(108.97,110.73) 108.64,111.06 CPU1.BG37 ; v2(143.95,103.52) 143.89,103.58 CPU1.A26 ; v2(125.05,169.47) 125.05,169.47 JCDRA.14 ; UV21.8 154.82,106.44 v2(154.7,106.32) ; CPU1.BM23 105.44,101.05 v2(105.11,101.38) 105.11,101.45 CPU1.BN24 ; v2(127.87,112.04) CPU1.AC38 ; v2(134.06,172.05) 134.25,172.05 134.65,171.65 JCDRA.38 ; v2(123.85,169.46) JCDRA.11 ; v2(144.1,100.43) CPU1.A22 ; CPU1.AJ2 122.68,85.74 v2(122.38,85.43) 122.73,85.09 CPU1.AJ1 ; CPU1.BJ32 106.93,107.81 v2(106.61,108.13) ; v2(195.4,109.38) 195.77,109.75 UG9.AG44 ; UH1.AA42 169.67,32.59 v2(169.67,32.85) ; v2(141.83,107.07) 141.51,106.75 CPU1.D30 ; CPU1.BN2 105.1,85.74 CPU1.BM2 105.31,86.15 105.31,86.67 CPU1.BM3 105.34,86.93 v2(105.57,87.16) ; CPU1.D20 141.76,98.6 141.76,98.46 CPU1.C19 142.16,98 v2(142.49,97.67) ; CPU1.AG10 124.72,91.32 v2(124.81,91.32) ; v2(144.15,105.24) 144.06,105.15 CPU1.A28 ; CPU1.BC33 111.79,108.46 v2(112.12,108.13) ; UH1.BE28 182.16,39.41 v2(182.25,39.32) ; v2(212.29,114.34) UG9.C51 212.6,114.7 v2(212.95,115.05) ; UH1.AW13 v2(178.48,47.24) ; CPU1.AB34 v2(128.66,108.78) CPU1.AB33 ; v2(179.74,30.04) 179.74,30.5 179.41,30.83 UH1.AY45 ; JCDRA.29 v2(131.05,172.05) ; UG9.BJ33 UG9.BH33 ; v2(163.85,38.22) UH1.H29 ; v2(174.96,42.88) UH1.AM22 ; CPU1.P38 v2(134.95,111.39) CPU1.P37 ; v2(144.03,90.94) 144,90.98 CPU1.A10 ; CPU1.G14 139.56,94.27 CPU1.F15 140.21,94.99 v2(139.89,95.31) 139.56,95.64 CPU1.G16 ; 121.13,92.25 CPU1.AL12 ; 171.81,46.05 UH1.AD14 ; CPU1.AP33 118.88,108.46 v2(119.21,108.78) 118.88,109.11 CPU1.AP34 ; CPU1.T12 CPU1.T13 132.43,92.9 v2(132.13,93.2) 132.48,93.55 CPU1.T14 ; CPU1.BR36 102.95,110.28 CPU1.BT36 102.63,110.4 v2(102.27,110.03) 102.72,109.58 CPU1.BT35 ; v2(127.87,110.73) CPU1.AC37 ; CPU1.L30 CPU1.L29 ; v2(121.49,169.48) 121.45,169.52 JCDRA.5 ; UG9.AE43 196.9,109.35 v2(196.9,109.42) ; v2(108.97,112.04) CPU1.BG38 ; UH1.BE9 182.06,48.53 182.14,48.61 v2(182.32,48.61) ; v2(131.02,108.13) CPU1.W33 ; v2(142.49,102.4) 142.16,102.72 CPU1.C25 141.51,103.44 CPU1.D26 ; CPU1.BP33 104.39,107.82 104.39,107.68 CPU1.BN31 105.1,106.97 v2(105.1,106.92) 105.1,106.81 CPU1.BN30 ; CPU1.H25 CPU1.J25 137.92,102.79 137.64,103.07 v2(137.64,103.24) ; JCDRA.32 v2(132.25,172.02) ; v2(133.2,172.05) 133.2,172.02 133.45,171.77 JCDRA.35
  BOTTOM w0.229: UT4.A1 123.55,148.46 v2(123.25,148.16) ; v2(161.12,166.97) DT7.2 ; v2(163.69,166.97) DT8.2
  BOTTOM w0.25: UG9.F13 210.82,87.73 v2(210.84,87.73) ; v2(207.88,110.93) 207.75,110.8 207.75,110.5 UG9.K45 207.75,110.4 207.75,109.95 207.4,109.6 v2(207.18,109.6) ; v2(214.45,101.3) 214.4,101.35 UG9.A32 ; UG9.BD35 v2(184.2,103.15) ; UG9.BE13 182.93,87.78 v2(182.83,87.78) ; UG9.AP47 v2(191.2,112.15) ; UG9.BG13 v2(182.1,88.35) ; UG9.AA49 199.7,113.55 v2(199.6,113.55) ; UG9.BE39 v2(183.5,106.55) ; UG9.T51 203.5,114.25 v2(203.6,114.15) ; UG9.AH43 195.1,109.08 v2(195.4,109.38) ; UG9.BJ43 180.1,108.75 v2(180.1,108.65) UG9.BJ42 ; v2(212.67,98.47) 212.67,99.17 UG9.C29 ; UG9.BH5 v2(181.42,82.77) ; UG9.BJ19 180.28,92.13 v2(179.99,92.13) ; UG9.BJ27 179.98,98.27 179.98,98.43 v2(179.99,98.43) 180.28,98.43 UG9.BJ28 ; UG9.AB43 199.49,109.24 v2(199.49,109.63) ; v2(179.99,96.33) v2(179.43,96.33) 179.31,96.45 UG9.BL25 ; UG9.BE31 v2(182.9,100.35) ; UG9.BH2 v2(180.8,80.05) ; v2(191.01,109.67) 191.04,109.64 191.04,109.19 UG9.AP43 ; v2(211.52,89.96) 211.71,89.96 UG9.D16 ; UG9.BJ21 179.98,94.07 v2(179.98,94.23) ; UG9.BJ41 UG9.BJ40 ; v2(195.22,112.67) 195.22,113.13 UG9.AH49 195.03,113.32 195.03,113.86 v2(195.19,114.01) ; UG9.BJ37 180.28,104.73 v2(179.98,104.73) ; v2(179.43,106.87) 179.35,106.95 UG9.BL40 ; UG9.BG28 v2(182.1,98.85) ; v2(179.99,92.13) 179.98,92.12 ; v2(179.99,92.13) v2(179.43,92.13) ; UG9.BE25 v2(182.9,96.15) ; UG9.F16 210.8,90.45 v2(210.8,90.5) 210.8,90.55 UG9.F17 ; v2(190.75,113.66) 190.75,113.4 UG9.AP49 ; v2(205.76,109.45) 205.76,109.26 205.6,109.1 UG9.N43 ; v2(203.9,113.55) UG9.R49 ; v2(210.85,110.82) 210.53,111.15 UG9.F46 ; UG9.BE30 v2(183.5,100.25) ; UG9.BD29 v2(184.2,98.95) ; v2(200.64,142.71) 200.67,142.71 200.93,142.45 200.93,142.45 UG1.A12 ; v2(207.95,112.31) 207.51,112.75 v2(207.5,112.75) ; UG9.BG25 v2(182.1,96.75) ; UG9.BD32 v2(184.2,101.05) ; UG9.BG40 182.1,107.25 ; v2(210.5,116) UG9.F52 ; UG9.BD38 v2(184.2,105.25) ; UG9.D30 v2(212.3,100.35) ; v2(186.55,115.47) 186.73,115.65 v2(187.1,115.65) ; UG9.BE34 v2(182.9,102.45) ; UG9.BE24 v2(183.5,96.05) ; UG9.BE28 v2(182.9,98.25) ; UG9.BJ16 180.28,90.03 v2(179.98,90.03) ; UG9.BE36 v2(183.5,104.45) ; UG9.A26 214.45,97.15 v2(214.5,97.2) ; v2(208.6,104.69) 208.14,105.15 v2(208,105.15) UG9.J38 ; UG9.BE33 v2(183.5,102.35) ; UG9.BG42 v2(181.4,108.75) ; v2(208.45,116.95) v2(208.45,115.95) ; UG9.BE27 v2(183.5,98.15) ; v2(207.97,113.6) 208.05,113.6 UG9.J49 ; UG9.BL43 v2(179.45,109.05) ; UG9.BE40 v2(182.9,106.65) ; UG9.BF41 v2(182.8,107.35) ; UG9.F35 v2(210.2,103.15) ; v2(180.83,108.75) 180.85,108.6 UG9.BH42 ; UG9.BG31 v2(182.1,100.95) ; UG9.BG34 v2(182.1,103.05) ; v2(212.2,87.65) UG9.D12 ; UG9.BA48 v2(186.3,112.25) ; UG9.BG37 182.1,105.15
  BOTTOM w0.254: v2(110.63,88.03) 110.4,88.26 arc(110.32,88.32) CPU1.BE6 ; v2(110.63,88.03) 110.94,88.34 CPU1.BD6 ; v2(110.63,88.03) 110.33,87.73 arc(110.28,87.7) CPU1.BE5 ; v2(210.2,103.15) 210.5,102.85 UG9.F34 210.66,102.59 v2(210.94,102.59) ; v2(231.85,96.35) UG6.F10 232.33,96.84 232.96,96.84 UG6.G10 v2(232.65,96.35) ; v2(240.28,111.57) 239.88,111.17 UG3.E3 v2(240.28,110.77) ; v2(241.88,119.57) 241.48,119.97 UG3.C14 241.48,119.97 v2(241.08,120.37) ; v2(242.68,118.77) 243.08,118.37 UG3.A12 243.08,118.37 v2(243.48,117.97) ; UG2.G10 v2(188.34,133.98) 188.34,133.98 UG2.F10 v2(188.34,133.18) ; UG6.U3 241.05,102.35 v2(241.45,102.75) ; v2(192.87,114.18) 193,114.31 UG9.AL51 ; v2(229.45,75.11) UG5.R1 229.45,74.31 v2(229.45,74.31) ; v2(208.3,107.1) 207.85,107.1 UG9.K40 ; UG2.K2 UG2.K1 180.14,136.78 v2(180.09,136.83) ; CPU1.AD6 127.11,88.34 v2(127.44,88.67) ; v2(184.98,115.88) 184.88,115.98 184.17,115.98 v2(183.99,115.8) 183.9,115.71 UG9.BD52 ; v2(239.05,78.31) v2(239.05,77.49) 239.44,77.11 UG5.C4 239.45,77.11 v2(239.85,77.51) 239.85,77.51 UG5.B5 240.25,77.91 v2(240.65,78.31) ; UG1.M10 202.61,133.58 v2(202.21,133.98) UG1.L10 ; CPU1.AD11 126.91,91.6 v2(126.63,91.32) 127,90.95 CPU1.AD10 ; v2(240.65,96.35) 240.25,96.75 UG6.T10 ; UG3.P10 v2(232.28,117.17) UG3.R11 v2(231.48,117.97) UG3.R12 v2(232.28,118.77) v2(233.08,118.77) UG3.N12 v2(233.88,118.77) ; CPU1.BH14 108.02,93.55 v2(108.34,93.23) 108.66,93.55 CPU1.BG14 ; v2(216.61,135.58) 216.21,135.18 UG4.H2 216.16,135.13 215.46,135.13 UG4.H1 215.01,135.18 v2(214.86,135.03) ; v2(189.94,139.58) 189.54,139.18 UG2.N12 ; v2(189.94,139.58) v2(189.94,140.38) UG2.R12 ; v2(189.94,139.58) v2(190.74,139.58) 191.14,139.18 UG2.N14 v2(191.54,139.58) ; v2(235.5,104.6) 235.45,104.55 UG6.K1 UG6.K2 ; CPU1.BT26 CPU1.BR26 CPU1.BP26 104.54,103.75 105.05,103.75 CPU1.BM27 105.68,103.9 105.68,103.59 CPU1.BM26 ; v2(167.38,73.05) 167.38,73.09 167.72,73.43 167.78,73.43 168.12,73.77 UG16.6 ; CPU1.AJ3 122.88,86.29 122.88,85.83 CPU1.AJ2 ; CPU1.AJ3 122.67,86.39 v2(122.35,86.06) 122.35,86.59 CPU1.AK4 CPU1.AL4 121.02,86.89 120.42,86.89 CPU1.AM4 120.24,87.04 119.92,87.36 v2(119.88,87.36) ; CPU1.AJ3 CPU1.AJ4 CPU1.AJ5 CPU1.AJ6 ; UG9.AL43 v2(193.4,109.45) UG9.AK44 ; UG4.T10 v2(223.01,141.98) ; UG4.T10 222.61,141.58 v2(222.21,141.98) ; UG4.T10 223.01,141.18 v2(223.01,141.18) 223.41,140.78 UG4.R11 ; v2(238.25,76.71) 237.85,76.31 UG5.E3 ; v2(203.3,112.7) 203.35,112.7 v2(203.8,112.25) 203.8,112.15 UG9.T47 ; CPU1.C2 142.21,85.89 v2(142.21,86.42) ; v2(138.45,91.29) 138.76,90.98 CPU1.J10 ; v2(138.45,91.29) 138.29,91.29 CPU1.K11 ; v2(138.45,91.29) 138.11,90.95 CPU1.K10 137.92,90.95 v2(137.56,90.59) 137.69,90.59 CPU1.K9 138.11,90.17 138.11,89.77 CPU1.K8 138,89.65 v2(138.39,89.26) ; v2(138.45,91.29) 138.91,91.75 CPU1.H11 ; v2(104.46,108.47) 104.46,108.4 CPU1.BP33 ; CPU1.K7 138.13,89 v2(138.39,89.26) ; CPU1.AP11 119.13,91.32 v2(119.32,91.32) ; UG6.E1 v2(231.05,104.35) ; v2(225.71,4.55) 225.71,3.83 225.89,3.65 JSSD2.71 ; UG5.H2 UG5.H1 235.45,74.26 235.49,74.22 v2(235.49,74.14) ; v2(236.17,92.8) 235.45,93.52 UG6.K14 UG6.K13 235.15,94.64 v2(235.15,94.75) ; UG2.B10 187.94,130.38 v2(188.34,129.98) ; v2(155.79,167.66) 155.79,167.49 DT5.2 ; UG3.C11 v2(241.88,117.17) 242.28,116.77 UG3.B10 242.28,116.77 v2(242.68,116.37) ; UG3.C11 241.08,117.17 v2(241.08,117.17) 241.08,117.17 UG3.D10 240.68,116.17 v2(240.68,116.17) ; UG3.C11 241.88,117.97 v2(241.88,117.97) 241.48,118.37 UG3.C12 241.48,118.37 v2(241.08,118.77) v2(240.28,118.77) UG3.E12 239.88,118.37 v2(239.48,118.77) v2(239.48,119.57) 239.88,119.97 UG3.E14 ; v2(190.75,113.66) 190.75,114.11 v2(190.85,114.21) 190.9,114.26 UG9.AP51 ; v2(210.83,104.53) 210.82,104.53 UG9.F37 210.48,104.85 v2(210.17,105.16) 209.8,105.53 ; UG2.M10 v2(187.54,137.98) UG2.L10 ; UG2.M10 187.94,138.38 v2(188.34,138.78) 188.33,138.79 v2(188.33,139.6) 188.32,139.6 UG2.P10 ; UG2.M10 v2(187.54,138.78) ; UG4.A3 217.01,129.58 v2(216.61,129.18) ; v2(207.81,139.58) 208.21,139.18 UG1.E3 208.21,139.2 v2(208.61,139.6) 208.64,139.57 209.4,139.57 v2(209.42,139.6) 209.42,139.57 UG1.E1 v2(210.21,139.58) ; UG2.C3 182.74,131.58 ; UG2.C3 v2(182.74,130.78) 183.14,131.18 UG2.C4 ; UG2.C3 181.94,131.58 v2(181.94,131.6) ; 182.74,131.58 v2(182.74,131.6) ; 182.74,131.58 UG2.C4 ; CPU1.A36 143.49,110.36 v2(143.85,110.72) ; CPU1.A36 CPU1.A34 143.46,109.55 142.62,108.71 141.92,108.71 CPU1.D33 ; CPU1.A36 142.83,110.99 CPU1.B37 ; CPU1.Y7 130.22,89 130.61,88.6 130.81,88.6 131.08,88.34 CPU1.V6 ; v2(101.97,97.05) 101.97,94.76 CPU1.BT14 CPU1.BR14 103.81,94.22 v2(103.81,94.29) 104.14,93.97 CPU1.BP14 CPU1.BN14 105.18,94.29 v2(106.35,94.29) ; v2(239.85,75.11) v2(239.85,75.91) UG5.C3 239.05,75.91 v2(239.05,75.91) ; v2(239.85,75.11) 239.45,74.71 UG5.C1 v2(239.85,74.31) ; v2(239.85,75.11) v2(240.65,75.11) UG5.A1 ; UG3.A1 v2(243.48,109.17) ; UG6.U12 241.05,95.15 v2(241.45,94.75) ; v2(237.45,96.35) UG6.M10 v2(236.65,97.15) 236.25,96.75 UG6.L10 ; UG3.G10 238.28,116.62 v2(238.68,116.22) 239.08,116.62 UG3.F10 239.48,117.17 v2(239.48,117.17) ; CPU1.BD9 111.02,90.69 v2(111.09,90.69) ; CPU1.G16 139.89,96.04 v2(139.89,96.09) ; JSSD2.73 225.98,3.15 v2(225.73,2.89) 225.97,2.65 JSSD2.75 ; v2(239.85,102.75) 239.45,102.35 UG6.R3 239.45,102.35 v2(239.85,101.95) 239.45,101.55 UG6.R4 239.45,101.55 v2(239.85,101.15) 240.25,100.75 UG6.T5 240.25,100.75 240.63,100.37 v2(240.66,100.37) ; v2(218.21,131.58) UG4.C4 217.81,131.18 v2(217.41,131.58) UG4.C3 v2(216.61,130.78) ; v2(224.61,142.78) UG4.U12 224.21,142.38 v2(224.61,141.98) ; v2(210.89,96.18) v2(211.36,96.65) 211.55,96.65 211.67,96.53 211.85,96.53 211.85,96.5 UG9.D25 211.9,96.4 v2(212.19,96.11) 212.31,96.23 212.55,96.23 212.62,96.3 v2(212.75,96.3) 212.9,96.45 UG9.B25 ; v2(231.48,109.97) 231.88,109.57 UG3.R1 231.88,109.57 v2(231.48,109.17) ; v2(171.35,16.49) 171.1,16.74 UE4.18 ; CPU1.D33 141.51,108.25 v2(141.86,107.9) 141.86,107.81 CPU1.C31 ; CPU1.D33 141.13,107.92 140.63,107.92 140.22,107.51 CPU1.F31 139.58,107.51 CPU1.H32 139.2,107.81 v2(138.89,108.12) 138.82,108.12 ; CPU1.D33 140.86,108.95 CPU1.E34 ; UG9.F44 v2(210.8,109.45) ; v2(183.54,129.98) 183.94,130.38 UG2.B5 ; UG4.R1 v2(215.01,141.18) ; UG4.R1 v2(215.81,141.18) v2(216.61,141.18) 217.01,140.78 UG4.R3 v2(217.41,141.18) 217.81,140.78 UG4.R4 ; UG4.R1 v2(215.81,140.38) ; UG4.A12 224.21,129.58 v2(224.61,129.18) ; UG6.E3 v2(231.85,102.75) ; v2(234.25,75.91) 233.85,75.51 UG5.K2 233.76,75.42 233.76,74.8 UG5.K1 233.85,74.31 v2(233.7,74.16) ; CPU1.C31 142.57,107.11 143.11,107.11 143.29,106.93 CPU1.A30 ; CPU1.C31 141.83,107.18 v2(141.83,107.07) ; UG2.K13 UG2.K14 191.54,136.78 v2(191.79,137.03) ; UG9.AE51 197.2,114.25 v2(197.35,114.1) ; UG2.A14 191.58,129.58 v2(191.63,129.63) ; v2(219.01,138.78) UG4.M5 v2(219.01,137.98) UG4.L5 218.21,137.98 v2(218.21,137.98) ; CPU1.AD7 127.12,89 v2(127.44,88.67) ; v2(231.85,83.91) UG5.N12 v2(231.05,83.91) v2(230.25,83.91) UG5.R12 v2(229.45,83.11) UG5.R11 v2(230.25,82.31) UG5.P10 ; 132.14,90.62 v2(132.1,90.62) ; 132.14,90.62 132.17,90.62 132.5,90.95 CPU1.T10 ; 132.14,90.62 132.46,90.3 CPU1.T9 ; CPU1.B3 142.71,86.42 v2(142.21,86.42) ; UG4.E3 217.01,132.78 v2(216.61,133.18) ; UG9.D22 212.06,94.51 212.44,94.51 v2(212.75,94.2) ; UG9.G47 209.8,111.73 v2(210.11,111.42) ; v2(243.48,111.57) 243.08,111.17 UG3.A3 ; UG1.E14 199.41,139.18 v2(199.81,139.58) v2(200.61,139.58) 201.01,139.18 UG1.E12 ; v2(227.85,102.75) UG6.A3 v2(228.65,102.75) ; UG1.N12 201.01,132.78 v2(200.61,133.18) ; UG6.H13 233.84,94.35 v2(233.45,93.95) UG6.H14 233.7,93.4 v2(233.7,92.95) ; CPU1.BM21 105.74,99.04 v2(105.74,99.02) ; UG9.F31 210.21,100.36 v2(210.18,100.36) ; UG3.U3 v2(229.88,110.77) ; v2(105.57,87.16) 105.57,87.37 CPU1.BM5 104.92,87.19 CPU1.BN4 ; UG1.T5 206.61,130.38 v2(207.01,129.98) ; UG9.AB47 199.3,111.88 v2(199.62,112.2) ; CH48.2 161.28,56.58 161.61,56.91 v2(161.61,59.54) 161.61,60.32 161.44,60.49 157.47,60.49 157.22,60.23 157.22,57.01 157.64,56.58 CH47.2 ; v2(214.76,136.83) 214.81,136.78 UG4.K1 UG4.K2 ; v2(98.25,92.25) 98.08,92.08 UZ21.5 ; UG9.AH45 v2(194.8,110.75) ; UG2.U14 v2(191.54,142.78) ; v2(180.34,141.18) UG2.R1 v2(181.13,140.39) ; UG4.A1 v2(215.81,129.98) ; v2(181.94,141.18) UG2.R3 182.34,140.78 v2(182.74,141.18) UG2.R4 183.14,140.78 v2(183.54,141.18) 183.94,141.58 UG2.T5 183.94,141.58 v2(184.34,141.98) ; v2(181.94,139.58) UG2.N3 182.34,139.18 v2(182.74,139.58) v2(183.54,139.58) v2(184.34,139.58) 184.34,139.58 v2(184.34,138.78) 183.94,138.38 ; UG6.P10 238.65,96.75 v2(238.25,97.15) ; CPU1.BT24 102.92,101.68 103.4,101.68 103.49,101.77 CPU1.BR24 103.58,101.86 104.01,101.86 104.1,101.77 CPU1.BP24 104.23,101.77 104.28,101.82 104.74,101.82 CPU1.BN24 104.79,101.91 CPU1.BM25 v2(105.76,102.95) 106.34,102.95 CPU1.BK25 CPU1.BJ25 v2(107.96,102.56) ; v2(212.87,116.13) 212.87,115.62 UG9.C52 212.28,115.67 v2(212.28,115.79) ; CPU1.G6 139.52,89.36 CPU1.G8 ; v2(238.65,81.36) 238.65,81.36 UG5.D10 ; UG9.BH15 UG9.BJ15 UG9.BJ14 ; v2(193.24,153.19) 193.36,153.3 RV17.2 ; v2(233.44,85.5) 233.83,85.11 UG5.K14 v2(233.45,84.71) UG5.K13 ; UT4.L1 123.42,153.71 123.42,154.06 123.2,154.28 v2(122.99,154.28) ; v2(209.62,102.92) 209.27,102.92 UG9.H34 209.1,102.75 v2(208.78,103.07) 208.67,102.96 208.29,102.96 208.2,103.05 v2(208,103.05) ; UG2.T10 v2(188.34,141.18) UG2.R11 188.33,140.37 v2(188.33,140.36) 188.32,140.36 UG2.P10 ; UG2.T10 v2(187.54,141.98) ; UG2.T10 188.31,141.95 v2(188.33,141.95) ; v2(241.07,113.18) v2(241.07,112.36) 241.46,111.97 UG3.C4 241.88,112.37 v2(241.88,112.37) 242.28,112.77 UG3.B5 242.28,112.77 v2(242.68,113.17) ; v2(238.25,84.71) 237.85,85.11 UG5.E14 237.45,84.71 v2(237.45,84.71) ; v2(238.25,84.71) v2(239.05,84.71) 239.05,84.71 UG5.C14 239.45,85.11 v2(239.05,85.51) ; v2(238.25,84.71) v2(238.25,83.91) 237.85,83.51 UG5.E12 ; UG9.G38 209.8,105.53 ; 209.8,105.53 v2(209.41,105.14) ; UG5.U14 v2(227.85,85.51) ; v2(230.25,102.75) UG6.C3 v2(230.25,101.95) UG6.C4 ; UG2.L5 184.04,137.58 v2(184.44,137.98) 184.35,137.98 183.94,138.38 ; CPU1.A26 143.08,103.96 142.53,103.96 v2(142.49,104.01) 142.49,104.04 CPU1.C27 141.51,103.71 CPU1.D26 ; 159.14,51.44 158.8,51.78 158.8,54.28 157.93,55.15 v2(157.93,55.92) ; v2(209.5,90.4) 209.35,90.4 UG9.H16 ; UG9.E51 v2(211.5,114.95) ; JWLAN.55 303.49,65.5 v2(303.85,65.86) ; UG5.N14 v2(231.05,85.51) ; v2(239.85,94.75) 239.45,95.15 UG6.R12 ; v2(145.3,146.14) 145.11,145.95 RT24.2 ; v2(158.01,168.94) 158.01,168.93 DT3.2 ; v2(203.01,141.98) UG1.B10 v2(202.21,141.18) UG1.C11 201.81,140.78 v2(201.41,141.18) ; UG6.T10 240.25,96.75 v2(240.65,97.15) ; UG6.T10 239.85,96.35 v2(239.85,96.35) 239.45,95.95 UG6.R11 ; UG5.C11 239.45,82.71 v2(239.85,82.31) 240.25,81.91 UG5.B10 240.65,81.51 v2(240.65,81.51) ; UG5.C11 239.45,82.71 v2(239.05,82.31) 238.65,81.91 UG5.D10 ; UG5.C11 239.85,83.11 v2(239.85,83.11) 239.85,83.11 UG5.C12 ; v2(208.09,92.52) 208.09,92.64 UG9.J20 ; UG2.C12 v2(189.14,130.78) UG2.C11 v2(188.34,131.58) UG2.D10 ; UG4.L10 222.61,137.58 v2(222.21,137.98) UG4.M10 v2(223.01,138.78) ; v2(227.85,92.95) 228.25,93.35 UG6.A14 ; v2(180.34,139.58) UG2.N1 v2(181.14,138.78) ; UG5.G5 236.25,78.03 v2(236.65,78.43) 236.65,78.31 UG5.F5 237.05,77.91 v2(237.45,77.51) ; v2(107.95,100.25) 107.89,100.2 CPU1.BJ22 107.3,100.2 107.2,100.3 106.84,100.3 CPU1.BK22 106.36,100.58 105.76,100.58 105.44,100.9 CPU1.BM23 ; UM8.25 96.6,150.9 v2(96.41,150.71) ; UG1.T10 202.61,130.38 v2(202.21,130.78) 201.81,131.18 UG1.R11 v2(201.41,130.78) 201.01,131.18 UG1.R12 ; CPU1.BD12 110.5,92.25 v2(110.17,92.57) 109.85,92.25 CPU1.BF12 ; CPU1.AU8 116.22,89.65 v2(116.61,89.26) ; UG4.C1 215.41,131.18 v2(215.81,131.58) ; UG1.K13 v2(199.81,134.78) UG1.K14 199.41,135.18 v2(199.01,134.78) ; 222.61,134.38 v2(223.01,133.98) ; 222.61,134.38 222.51,134.27 222.51,133.69 UG4.F10 222.61,133.58 v2(223.01,133.18) ; 222.61,134.38 UG4.G10 ; JUSBC1.A1 v2(156.5,170.41) ; v2(223.01,129.98) 222.61,130.38 UG4.B10 ; CPU1.AW12 114.74,91.79 ; 114.74,91.79 114.29,92.24 CPU1.AY12 ; 114.74,91.79 v2(114.74,91.24) ; UG9.AH47 195.25,111.7 v2(195.25,111.42) ; v2(229.45,85.51) UG5.R14 v2(229.45,84.71) ; UG1.C4 207.41,140.78 v2(207.01,141.18) 206.61,141.58 UG1.B5 206.61,141.58 v2(206.21,141.98) ; UG1.C4 v2(207.81,141.18) ; UG1.C4 207,140.37 v2(207,140.36) ; v2(141.33,87.34) 141.19,87.34 CPU1.E4 140.92,87.04 CPU1.D3 142.11,86.32 v2(142.21,86.42) ; CPU1.F21 139.56,98.99 CPU1.G20 ; v2(226.46,136.9) 226.34,136.78 UG4.K14 UG4.K13 224.93,136.78 v2(224.61,136.46) ; CT47.2 146.27,157.16 v2(146.25,157.14) ; UG9.K25 208.01,96.14 v2(208.07,96.14) ; v2(212.55,86.05) 212,86.05 UG9.D10 ; UG6.E12 v2(231.05,94.75) ; v2(231.05,94.75) v2(231.05,93.95) UG6.E14 231.45,93.38 v2(231.05,92.98) ; v2(231.05,94.75) v2(230.25,94.75) UG6.C12 v2(229.45,95.55) UG6.C11 v2(230.25,96.35) UG6.D10 ; v2(210.36,136.88) 210.26,136.78 UG1.H1 UG1.H2 ; UG4.T5 v2(219.01,141.98) ; CT45.2 133.63,144.81 133.09,144.27 v2(133.09,144.09) ; v2(237.58,109.02) 237.48,109.12 UG3.H1 UG3.H2 ; v2(233.88,117.17) UG3.M10 234.36,116.69 235,116.69 UG3.L10 v2(234.68,117.17) ; v2(241.45,93.15) 241.05,93.55 UG6.U14 v2(240.65,93.95) ; UG9.BJ40 180.06,106.95 v2(179.96,107.05) ; UG3.M5 v2(234.68,112.37) UG3.L5 ; UG3.T10 v2(230.68,117.17) ; v2(227.85,96.35) v2(228.65,96.35) UG6.B10 ; RM70.1 98.82,143.67 v2(98.81,143.66) ; UG9.H19 v2(209.4,92.55) ; UG1.A12 v2(201.41,141.98) v2(201.41,141.18) ; v2(117.31,87.29) 117.71,87.69 CPU1.AR5 ; UG9.W49 201.42,113.25 201.75,113.58 v2(201.75,113.59) 202.09,113.25 UG9.V49 ; CPU1.BK29 107.06,105.58 CPU1.BJ29 ; UG4.A14 v2(226.41,129.58) ; UG9.BL16 179.86,90.15 v2(179.98,90.03) ; UG1.R3 v2(207.81,130.78) 207.41,131.18 UG1.R4 ; v2(139.9,102.41) 139.9,102.34 CPU1.G24 138.86,102.7 CPU1.H25 ; v2(199.01,140.38) UG1.C14 199.41,140.78 v2(199.81,141.18) v2(199.81,141.98) ; CPU1.BT3 102.73,86.27 102.31,86.27 v2(102.23,86.19) ; UG5.A12 241.45,83.91 v2(241.45,83.91) ; UG5.A12 240.65,83.11 v2(240.65,83.11) ; UG5.A12 241.45,83.11 v2(241.45,83.11) ; v2(201.41,141.18) UG1.C12 ; v2(222.19,32.68) 222.32,32.55 JSSD1.51 ; v2(191.54,134.9) 191.54,135.01 191.38,135.18 UG2.H14 v2(190.74,134.78) 190.34,135.18 UG2.H13 ; UG9.D37 212.2,105.15 v2(212.2,105.15) ; v2(229.45,104.35) UG6.C1 v2(229.45,103.55) ; v2(125.3,84.54) CPU1.AF1 CPU1.AF2 ; CPU1.AR3 117.68,86.39 v2(117.31,86.02) ; v2(210.2,109.35) 210.08,109.23 v2(209.55,109.23) ; v2(184.84,115.09) 184.6,114.85 UG9.BC51 ; v2(201.7,109.35) UG9.W43 ; v2(213.63,115.67) UG9.B52 ; UG5.T10 v2(228.65,82.31) ; UG6.U1 241.05,103.95 v2(241.45,104.35) ; UG9.D19 211.94,92.25 212.12,92.43 212.42,92.43 v2(212.75,92.1) 212.9,92.25 UG9.B19 ; CPU1.F11 139.97,91.52 139.97,91.39 CPU1.G10 139.56,90.91 v2(139.89,90.59) 139.89,90.52 CPU1.G9 ; UG2.A12 v2(189.94,129.18) ; UG1.P10 202.61,131.98 v2(202.21,132.38) ; UG5.U12 v2(227.85,83.91) ; CPU1.E38 140.57,112.16 v2(140.49,112.24) ; 138.82,108.12 138.5,108.45 CPU1.J33 ; 138.82,108.12 138.52,107.81 CPU1.J32 ; v2(179.98,104.73) 179.89,104.82 v2(179.42,104.82) 179.03,104.82 UG9.BL37 ; 170.37,74.59 169.73,74.59 169.06,75.27 UG16.3 ; v2(188.88,114.02) 188.8,114.1 UG9.AU51 ; v2(122.06,92.6) 121.71,92.25 CPU1.AL12 ; v2(229.88,109.17) 230.28,109.57 UG3.U1 ; v2(101.51,92.44) 101.51,92.95 v2(101.63,93.07) ; v2(241.88,109.17) UG3.C1 241.88,109.97 v2(241.88,110.77) UG3.C3 ; v2(226.41,131.18) UG4.C14 v2(225.41,130.78) ; 160.35,53.31 160.34,53.33 v2(160.34,55.86) ; v2(225.41,138.78) UG4.N14 v2(226.21,139.58) ; CPU1.F3 140.23,86.39 v2(139.91,86.06) ; UG1.G5 206.61,137.58 v2(206.21,137.98) UG1.F5 v2(207.01,138.78) ; UG9.F52 UG9.G51 210,114.45 v2(210,114.2) ; v2(231.48,120.37) UG3.R14 v2(231.48,119.57) ; UG2.G5 183.94,134.38 v2(183.54,133.98) UG2.F5 ; UG5.A1 v2(241.45,74.31) ; UG5.A1 241.05,74.71 v2(241.45,75.11) ; UG9.N51 205.6,114.17 v2(205.63,114.14) ; CPU1.F13 139.56,93.99 CPU1.G14 ; v2(127.44,88.67) 127.78,88.34 CPU1.AC6 ; v2(123.89,90.61) 124,90.61 CPU1.AG10 ; v2(199.01,129.18) 199.41,129.58 UG1.U14 ; UG4.R14 225.81,140.78 v2(225.41,141.18) ; v2(139.89,92.15) 139.89,92.22 CPU1.G12 ; v2(153.49,166.9) 153.49,167.03 153.62,167.16 DT4.2 ; UG5.L10 v2(232.65,82.31) UG5.M10 v2(231.85,82.31) ; CPU1.G23 139.56,101.13 v2(139.88,100.81) 139.56,100.5 CPU1.G22 139.46,100.33 138.96,100.33 CPU1.H22 138.71,100.28 138.36,100.28 CPU1.J22 ; UG5.L5 232.65,77.51 v2(232.65,77.51) UG5.M5 ; v2(167.46,31.79) 167.63,31.97 UH1.T42 ; UG1.R1 209.81,131.17 v2(209.41,130.77) 209.41,130.77 v2(209.41,129.98) 209.81,129.58 UG1.U1 ; v2(189.94,142.78) 189.54,142.38 UG2.U12 v2(189.94,141.98) ; UG2.E14 v2(190.74,132.38) v2(189.94,132.38) UG2.E12 ; UG4.C12 v2(223.81,130.78) 223.41,131.18 UG4.C11 223.41,131.18 v2(223.01,131.58) 222.61,131.98 UG4.D10 ; v2(202.21,138.78) 202.61,138.38 UG1.F10 203.01,137.98 v2(203.16,137.98) 202.76,137.58 UG1.G10 ; UG3.N3 233.08,110.77 v2(233.08,110.77) v2(232.28,110.77) UG3.R3 231.48,111.57 v2(231.48,111.57) UG3.R4 ; UG4.E1 v2(215.01,132.38) ; v2(240.65,84.71) 240.65,84.71 UG5.A14 241.05,85.11 v2(240.65,85.51) ; UG5.R4 229.45,76.71 v2(229.45,76.71) UG5.R3 229.85,76.31 v2(230.25,75.91) v2(231.05,75.91) UG5.N3 ; v2(207.97,113.6) UG9.K49 ; UG2.U3 v2(181.94,142.78) ; UG3.T5 v2(230.68,112.37) ; DT2.2 156.03,169.44 v2(155.97,169.51) ; v2(180.34,132.38) 180.74,132.78 UG2.E1 ; UG1.D10 v2(203.16,139.98) ; UG5.D10 238.64,81.91 v2(238.25,82.29) ; CPU1.F23 140.21,101.29 v2(139.89,101.61) ; v2(191.66,130.77) 191.25,131.18 UG2.C14 v2(190.74,130.78) ; v2(239.48,112.37) UG3.F5 238.68,113.17 v2(238.68,113.24) 238.28,112.84 UG3.G5 ; v2(208.61,132.38) 208.21,132.78 UG1.N3 ; UG2.P10 v2(187.54,140.38) ; v2(180.09,134.98) 180.29,135.18 UG2.H1 ; UG5.A3 241.05,76.31 v2(241.45,76.71) ; CPU1.AJ1 v2(122.79,84.54) ; UG1.N14 v2(199.81,132.38) 199.81,131.58 UG1.R14 199.41,131.18 v2(199.01,130.78) ; v2(235.48,118.77) UG3.K13 235.79,119.26 235.79,119.88 UG3.K14 ; CPU1.E35 140.48,110.14 140.34,110.14 CPU1.F36 ; CT85.2 152.18,156.99 152.68,156.49 v2(152.75,156.49) ; UG4.U3 217.01,142.38 v2(216.61,142.78) v2(215.81,142.78) UG4.U1 v2(215.01,142.78) ; UG4.P10 v2(222.21,139.58) ; v2(234.25,102.75) UG6.H2 233.76,103.24 233.76,103.86 UG6.H1 233.85,104.18 233.65,104.38 v2(233.65,104.6) ; UG3.N14 v2(233.08,120.37) ; UG3.E1 v2(240.28,109.17) ; U2407.6 71.14,63.33 70.63,63.33 v2(70.5,63.46) ; UG5.U3 v2(227.85,75.91) ; v2(180.31,129.36) 180.52,129.36 UG2.A1 ; UG9.C33 212.75,102.2 v2(212.75,102.6) ; v2(199.01,141.98) v2(199.81,141.98) ; v2(199.81,141.98) UG1.A14 ; UG3.N1 v2(233.08,109.17) ; UG9.B28 212.75,98.55 v2(212.67,98.47) 212.45,98.7 212.04,98.7 211.9,98.56 UG9.D28 211.73,98.72 v2(211.5,98.72) ; v2(144.92,86.19) 143.61,86.19 CPU1.A3 ; UG9.H22 v2(208.8,94.65) ; UG9.AR52 190.2,116.44 v2(190.17,116.47) ; UG3.A14 243.08,119.97 v2(242.68,120.37) ; v2(239.05,93.95) UG6.R14 239.45,93.55 v2(239.85,93.15) ; UG2.C4 183.54,131.58 v2(183.54,131.6) ; v2(136.99,105.26) 136.92,105.33 CPU1.L29 ; CPU1.AF3 125.32,86.4 125.32,87.02 CPU1.AF4 125.73,87.47 125.73,87.93 CPU1.AE6 ; v2(212.75,102.6) 212.46,102.89 212.1,102.89 211.96,102.75 UG9.D34 211.62,103.03 v2(211.5,103.03) ; v2(212.75,102.6) 213.15,102.6 UG9.B34 ; 183.94,138.38 UG2.M5 ; v2(229.45,92.95) 229.85,93.35 UG6.C14 v2(229.45,93.95) ; CPU1.BM13 105.53,93.21 105.99,93.21 CPU1.BL13 ; v2(210.85,106.62) 210.8,106.62 210.5,106.92 UG9.F40 ; v2(235.85,85.5) 235.92,85.5 236.55,86.13 v2(236.64,86.13) ; UG4.G5 v2(218.21,133.98) 218.61,133.58 UG4.F5 ; v2(210.36,135.03) 210.21,135.18 UG1.K1 209.75,135.11 209.08,135.11 UG1.K2 209.01,135.18 v2(208.61,135.58) ; UG5.N1 v2(231.05,74.31) ; v2(190.75,141.17) 191.14,140.78 UG2.R14 v2(191.54,141.18) ; v2(189.1,110.1) 189.1,110.15 UG9.AU45 ; UG9.BF4 182.61,81.64 v2(182.61,81.15) 182.61,80.93 182.61,80.92 182.61,80.56 182.5,80.44 UG9.BF2 ; UG3.U12 v2(229.88,118.77) ; UG4.E12 224.21,132.78 v2(224.61,132.38) v2(225.41,132.38) 225.41,132.38 UG4.E14 v2(226.41,132.78) ; UG1.U3 208.21,129.58 v2(208.61,129.18) ; UE4.7 174.6,16.74 v2(174.35,16.49) ; v2(181.37,128.99) 181.76,128.99 182.34,129.58 UG2.A3 ; UG9.F19 210.75,92 v2(210.89,92) ; v2(200.61,136.38) UG1.H13 UG1.H14 199.34,136.85 v2(198.9,136.85) ; CPU1.AG6 124.34,88.46 CPU1.AG7 ; UG9.B10 v2(213.6,85.65) ; RT65.2 130.53,153.81 128.94,153.81 128.72,153.58 UT4.L11 ; CPU1.E9 140.97,90.3 141.41,90.3 CPU1.D9 ; UG9.A29 v2(214.45,99.25) ; v2(138.39,89.26) 138.67,88.98 CPU1.J7 ; UG9.G49 209.51,113.54 v2(209.51,113.65) ; v2(208.25,90.35) 208.25,90.7 UG9.J17 ; v2(207.81,142.78) 208.21,142.38 UG1.A3 207.81,141.98 v2(207.81,141.18) ; RG518.2 RG25.2 175.97,94.7 v2(176.16,94.51) ; UG4.U14 v2(226.21,142.78) ; UG6.A12 v2(227.85,94.75) ; v2(180.34,130.78) 180.74,131.18 UG2.C1 ; v2(207.81,141.18) 208.21,140.78 UG1.C3 ; UG9.AW52 v2(187.1,115.65) ; UG1.L5 206.61,134.38 v2(207.01,133.98) UG1.M5 ; v2(179.99,92.13) 179.99,91.96 UG9.BJ18 ; UG6.F5 v2(232.65,101.15) UG6.G5 ; UG1.A1 209.81,142.38 v2(209.41,142.78) ; UG6.A1 v2(227.85,104.35) ; v2(239.05,103.55) 239.45,103.95 UG6.R1 239.45,103.95 v2(239.85,104.35) ; UG9.D40 212.04,107.09 212.42,107.09 212.71,106.8 v2(212.75,106.8) ; UG3.H13 237.48,119.17 v2(237.08,119.57) 237.48,119.97 UG3.H14 237.48,120.47 v2(237.68,120.67) ; UG9.AB51 199.3,114.25 v2(199.45,114.1) ; UG1.N1 209.81,132.78 v2(210.21,132.38) ; UG4.N12 v2(224.61,139.58) v2(224.61,140.38) 224.21,140.78 UG4.R12 ; UG1.U12 200.97,129.58 v2(200.61,129.22) ; UG9.J52 208.4,115.9 v2(208.45,115.95) ; UG9.AH51 195.1,114.1 v2(195.19,114.01) ; UG6.N12 v2(238.25,94.75) ; v2(179.55,84) 179.4,83.85 UG9.BL7 ; UG9.BJ10 180.25,85.8 v2(180,85.8) 179.85,85.95 UG9.BL10 ; UG9.H28 208.92,98.73 v2(208.64,98.73) ; UG5.T5 228.66,77.52 v2(228.66,77.5) ; UG6.B5 v2(228.65,101.15) ; UG5.U1 228.24,74.71 v2(227.85,74.31) ; UG4.H13 225.01,135.18 v2(225.41,134.78) UG4.H14 226.26,135.18 v2(226.41,135.03) ; v2(181.94,135.58) 181.54,135.18 UG2.H2 ; v2(212.3,100.35) 212.2,100.35 UG9.D31 ; UG6.L5 236.25,100.75 v2(236.65,101.15) 237.05,100.75 UG6.M5 237.05,100.75 v2(237.45,100.35) 238.34,100.35 v2(238.34,100.35) 238.25,100.45 v2(238.25,101.95) UG6.N3 237.85,102.35 v2(238.25,102.75) ; UG2.E3 v2(181.94,133.18) ; UG9.BL22 179.3,94.35 v2(179.42,94.23) v2(179.98,94.23) ; UG4.B5 218.61,130.38 v2(218.21,129.98) ; JUSBC2.5 314.88,45.61 314.88,45.3 314.75,45.17 JUSBC2.B12 ; v2(238.25,104.35) 237.85,103.95 UG6.N1 ; v2(235.73,109.02) 235.88,109.17 UG3.K1 235.79,109.66 235.79,110.28 UG3.K2 235.88,110.37 v2(236.28,110.77) ; v2(217.41,139.58) UG4.N3 217.01,139.18 v2(216.61,139.58) ; UG1.C1 v2(210.21,141.18) ; v2(292.81,53.87) 293.19,54.25 JWLAN.18 ; v2(168.99,17.33) 169.43,17.78 169.43,18.83 169.83,19.24 UE4.23 ; UG9.BB49 v2(185,112.95) ; v2(107.98,96.89) 107.82,97.05 CPU1.BJ18 CPU1.BK18 106.36,97.42 105.81,97.42 CPU1.BM18 105.11,96.65 ; UG2.U1 v2(180.34,142.78) ; CPU1.BN18 CPU1.BN19 ; UG9.AG14 195.8,88.8 v2(195.5,89.1) ; CPU1.BC14 CPU1.BC13 ; UG9.BL5 v2(178.7,82.15) ; UG3.U14 v2(229.88,120.37) ; v2(214.45,113.95) UG9.A50 ; UG4.N1 v2(215.01,139.58) ; UG9.BE37 v2(182.87,104.52) ; 210.5,93.69 v2(209.99,94.2) 210.35,94.2 UG9.F22 210.75,94.1 v2(210.95,94.1) UG9.F21 210.5,93.69
  BOTTOM w0.279: v2(314.81,39.18) 314.81,39.55 314.69,39.67 JUSBC2.B1 ; JUSBC1.5 155.91,173.33 156.12,173.33 156.25,173.2 JUSBC1.B12 ; JUSBC2.A1 312.9,44.92 v2(312.08,44.92) ; JUSBC2.A12 312.08,39.42 v2(312.02,39.49) ; v2(163.53,170.1) 162.56,170.1 162,170.66 JUSBC1.A12
  BOTTOM w0.3: UG9.A51 v2(214.36,115) ; UG9.B37 212.97,104.85 v2(212.81,104.69) ; UG9.B51 v2(213.75,115.1) ; v2(208.51,109.17) 208.44,109.24 208.44,110.01 v2(208.78,110.35) 208.67,110.45 UG9.K45 ; UG9.B13 212.91,88.05 v2(212.74,87.88) ; v2(199.04,110.8) 199.04,110.71 UG9.AB45 ; UG9.H31 208.85,100.9 v2(208.65,100.9) ; UG9.B46 212.9,111.15 v2(212.75,111) 212.46,111.29 212.04,111.29 UG9.D46 ; v2(193.33,112.2) 193.3,112.18 193.3,112.15 UG9.AL47 ; UG9.B22 212.9,94.35 v2(212.75,94.2) ; v2(212.93,79.34) 212.91,79.34 UG9.C1 ; v2(212.86,100.55) 212.96,100.65 UG9.B31 ; v2(189.5,115.83) UG9.AT52 UG9.AT51 ; v2(214.55,79.8) UG9.A2 ; v2(197.35,114.1) 197.08,113.83 197.08,113.37 UG9.AE49 ; UG9.T45 203.17,110.78 v2(203.17,110.81) ; UG9.N47 205.78,112.03 v2(205.78,112.25) ; UG9.W51 201.4,114.31 201.57,114.14 ; UG9.B43 212.9,109.05 v2(212.75,108.9) 212.53,109.12 211.98,109.12 UG9.D43 ; UG9.AD44 v2(197.6,109.45) ; v2(211.5,80.05) UG9.E2 ; UG9.AY47 v2(187,111.55) ; v2(188.88,114.02) 188.67,113.81 188.67,113.38 UG9.AU49 ; v2(199.11,112.69) 199.12,112.69 v2(199.62,112.2) ; v2(213.9,79.2) 213.75,79.2 UG9.B1 ; UG9.F46 210.23,111.42 v2(210.11,111.42) ; v2(186.4,114.35) UG9.AY51 ; UG9.B48 v2(213.6,112.85) ; UG9.AK47 v2(193.4,111.55) ; UG9.AL45 v2(192.7,110.75) ; UG9.N49 205.39,113.46 205.39,113.9 v2(205.63,114.14) ; UG9.A3 v2(214.57,81.05) ; v2(199.6,113.55) UG9.AB49 ; UG9.B2 v2(213.67,79.97)
  BOTTOM w0.305: JDIMM1.202 134.28,40.4 v2(134.4,40.28) 134.4,40.28 135.02,40.28 135.28,40.54 JDIMM1.206 ; v2(89.52,46.12) 89.53,46.12 JDIMM1.31 ; JSSD1.9 222.88,43.05 v2(222.76,43.17) ; JDIMM2.14 85.28,28.04 85.7,27.62 v2(85.91,27.62) 86.28,27.99 JDIMM2.18 ; v2(126.04,39.04) 126.99,39.04 127.53,38.51 JDIMM2.175 ; v2(130.65,27.61) 130.65,27.6 ; 130.65,27.6 130.78,27.73 JDIMM2.188 ; 130.65,27.6 130.65,27.6 130.07,27.6 129.78,27.9 JDIMM2.184 ; JSSD2.21 v2(228.6,16.15) ; v2(141.13,44.59) 140.98,44.59 140.28,43.89 JDIMM1.226 ; v2(143.52,39.68) 143.63,39.68 144.77,40.83 JDIMM1.244 ; v2(144.29,27.58) 144.4,27.58 144.78,27.96 JDIMM2.244 ; JSSD1.1 223.1,45.05 v2(222.79,44.75) 222.99,44.55 JSSD1.3 ; JDIMM1.172 126.77,40.75 127.12,40.41 v2(127.52,40.41) 127.77,40.67 JDIMM1.176 ; JSSD2.57 227.94,7.15 v2(228.07,7.02) ; JDIMM1.188 130.77,40.53 v2(130.65,40.41) 130.65,40.4 130.07,40.4 129.77,40.7 JDIMM1.184 ; v2(222.71,41.39) 222.87,41.55 JSSD1.15 ; JDIMM2.73 100.03,38.88 100.23,39.09 v2(100.64,39.09) 101.18,38.54 101.18,38.11 101.03,37.95 JDIMM2.77 ; JDIMM1.15 85.53,50.73 85.7,50.91 85.7,50.94 85.87,51.11 86.13,51.11 v2(86.18,51.16) 86.23,51.11 86.27,51.11 86.53,50.85 JDIMM1.19 ; 126.69,51.42 126.69,51.22 126.53,51.05 JDIMM1.171 ; 126.69,51.42 v2(126.67,51.42) ; 126.69,51.42 126.63,51.35 125.82,51.35 125.53,51.06 JDIMM1.167 ; JDIMM2.93 105.03,38.32 104.83,38.51 v2(104.42,38.51) 104.33,38.51 104.03,38.21 JDIMM2.89 ; JDIMM1.30 89.27,40.69 89.57,40.4 v2(89.97,40.4) 90.31,40.4 90.78,40.86 JDIMM1.36 ; 85.91,40.44 86.27,40.81 JDIMM1.18 ; 85.91,40.44 85.7,40.44 85.27,40.87 JDIMM1.14 ; 85.91,40.44 v2(85.91,40.42) ; JDIMM2.185 130.03,38.12 130.54,38.63 v2(130.67,38.63) 130.78,38.63 131.03,38.38 JDIMM2.189 ; JDIMM2.243 144.53,35.98 144.18,35.64 v2(143.48,35.64) 143.48,36.03 143.53,36.07 JDIMM2.239 ; JDIMM1.26 88.27,40.81 88.2,40.73 87.87,40.41 87.85,40.41 v2(87.85,40.41) 87.65,40.41 87.27,40.78 JDIMM1.22 ; JDIMM1.243 144.52,48.78 144.12,48.37 v2(143.5,48.37) 143.52,48.4 JDIMM1.239 ; JDIMM2.72 99.78,27.85 99.54,27.61 v2(98.97,27.61) 98.78,27.8 JDIMM2.68 ; v2(300.49,62.65) 300.65,62.5 JWLAN.43 ; v2(228.74,17.49) 228.58,17.65 JSSD2.15 ; UG5.G10 236.8,81.36 v2(237.05,81.36) 237.05,81.36 UG5.F10 237.05,81.91 v2(237.45,82.31) ; JDIMM2.251 146.53,38.21 146.31,38.42 v2(145.72,38.42) 145.53,38.23 JDIMM2.247 ; JDIMM1.205 135.02,50.95 134.79,51.19 v2(134.68,51.19) 134.37,51.19 134.02,50.84 JDIMM1.201 ; JSSD1.39 222.29,35.55 v2(222.23,35.61) ; v2(222.76,40.27) 222.98,40.05 JSSD1.21 ; v2(99.49,40.38) 99.78,40.67 JDIMM1.72 ; v2(222.68,38.38) 222.86,38.55 JSSD1.27 ; JDIMM1.73 100.02,50.82 99.82,51.02 99.82,51.72 99.98,51.89 v2(100.4,51.89) 100.63,51.89 101.02,51.49 JDIMM1.77 ; v2(100.53,27.61) 100.87,27.61 101.28,28.01 JDIMM2.78 ; JDIMM2.248 145.78,27.76 v2(146.06,27.47) 146.26,27.47 146.78,27.98 JDIMM2.252 ; UG6.N14 v2(238.25,93.15) ; JDIMM2.19 86.53,38.31 v2(86.46,38.37) 85.86,38.37 85.53,38.04 JDIMM2.15 ; JDIMM2.238 143.28,27.92 v2(143.58,27.62) ; v2(138.23,27.62) 138.28,27.66 JDIMM2.218 ; v2(146.49,52.01) 145.98,52.01 145.52,51.56 JDIMM1.247 ; JDIMM1.35 90.53,51.29 91.3,52.06 v2(91.51,52.06) ; JDIMM1.1 82.02,47.49 v2(81.8,47.27) ; v2(225.06,19.2) 225.2,19.06 225.98,19.06 226.06,19.15 JSSD2.9 ; JDIMM1.98 106.27,40.61 106.35,40.54 v2(106.35,40.38) ; v2(128.83,51.87) 129.53,51.87 130.02,51.38 JDIMM1.185 ; v2(228.06,8.74) 227.97,8.65 JSSD2.51 ; JDIMM1.231 141.52,51.03 v2(141.69,51.19) 142.38,51.19 142.52,51.05 JDIMM1.235 ; JDIMM2.196 132.78,27.98 132.4,27.6 v2(132.4,27.61) 132.39,27.6 132.23,27.6 131.78,28.06 JDIMM2.192 ; v2(302.99,67.4) 302.6,67 JWLAN.61 ; JDIMM1.47 93.53,51.17 v2(93.71,51.35) 94.06,51.35 94.53,50.88 JDIMM1.51 ; JDIMM2.1 82.03,38.49 82.18,38.65 v2(82.41,38.65) 82.57,38.65 83.03,38.2 JDIMM2.5 ; v2(124.8,93.26) 125.09,93.55 CPU1.AF14 ; JDIMM1.43 92.53,51.67 92.97,52.11 93.65,52.11 v2(93.71,52.05) ; v2(128.52,40.43) 128.77,40.68 JDIMM1.180 ; JDIMM2.227 140.53,38.29 140.3,38.52 v2(139.81,38.52) 139.53,38.24 JDIMM2.223 ; JDIMM2.202 134.28,28.04 134.72,27.6 v2(134.84,27.6) 134.92,27.6 135.28,27.96 JDIMM2.206 ; v2(95.12,39.68) 95.78,40.34 JDIMM1.56 ; v2(82.39,32.12) 82.5,32.12 83.28,31.34 JDIMM2.6 83.28,27.86 82.98,27.57 82.67,27.57 82.28,27.96 JDIMM2.2 ; v2(107.36,22.15) 107.3,22.21 107.3,23.09 JEC.8 ; JDIMM1.69 99.02,51.33 98.56,51.8 v2(98.27,51.8) ; v2(94.99,30.96) 94.78,30.75 JDIMM2.52 ; v2(83.01,48.36) 83.02,48.38 JDIMM1.5 ; v2(102.97,51.16) 103.02,51.11 JDIMM1.85 ; v2(90.92,31.73) 91.1,31.73 91.78,31.06 JDIMM2.40 ; JDIMM2.57 96.03,38.08 95.72,38.39 v2(95.12,38.39) 94.76,38.39 94.53,38.15 JDIMM2.51 ; v2(222.2,31.1) 222.37,30.92 222.73,30.92 222.86,31.05 JSSD1.57 ; JDIMM2.60 96.78,27.75 96.91,27.61 v2(97.28,27.61) 97.44,27.61 97.78,27.94 JDIMM2.64 ; v2(97.02,51.81) 96.51,51.81 96.02,51.32 JDIMM1.57 ; JDIMM2.10 v2(84.28,30.76) ; JSSD2.3 227.88,20.65 v2(228.17,20.94) 227.95,21.15 JSSD2.1 ; JWLAN.37 302.78,61 302.84,60.94 302.84,59.86 ; v2(102.52,38.5) 102.03,38.01 JDIMM2.81 ; JDIMM1.10 84.27,43.83 84.4,43.96 v2(84.4,44.72) ; JDIMM2.180 128.78,27.97 v2(129.13,27.61) ; JDIMM2.201 134.03,37.99 v2(134.38,38.34) 134.72,38.34 135.03,38.03 JDIMM2.205 ; JDIMM1.193 132.02,51.42 v2(132.01,51.42) 131.42,51.42 131.02,51.02 JDIMM1.189 ; JDIMM2.231 141.53,38.14 141.77,38.39 v2(142.04,38.39) 142.26,38.39 142.53,38.13 JDIMM2.235 ; JDIMM1.64 97.78,40.71 97.41,40.35 v2(96.93,40.35) 96.78,40.5 JDIMM1.60 ; PU507.4 114.8,134.55 v2(114.5,134.24) ; v2(123.94,43.83) 125.33,43.83 125.77,43.38 JDIMM1.168 ; JDIMM2.65 98.03,38.12 97.74,38.4 v2(96.91,38.4) 97.03,38.29 JDIMM2.61 ; JWLAN.25 v2(300.45,58) ; JDIMM1.209 136.02,50.94 136.25,51.16 v2(136.6,51.16) 136.83,51.16 137.02,50.96 JDIMM1.213 ; JDIMM2.99 106.53,38.13 v2(106.31,38.34) ; JDIMM1.222 139.28,40.83 v2(139.75,40.35) ; v2(302.72,56.88) 302.84,57 302.84,59.86 ; JDIMM2.172 126.78,27.83 126.99,27.61 v2(127.29,27.61) 127.39,27.61 127.78,28 JDIMM2.176 ; JDIMM1.106 108.27,40.86 107.82,40.41 107.74,40.41 v2(107.74,40.41) 107.49,40.41 107.27,40.62 JDIMM1.102 ; JDIMM1.192 131.77,40.67 v2(131.95,40.5) 132.51,40.5 132.77,40.76 JDIMM1.196 ; JDIMM2.94 105.28,27.95 104.86,27.53 v2(104.7,27.53) 104.28,27.96 JDIMM2.90 ; JDIMM2.22 87.28,27.97 87.64,27.61 v2(87.85,27.61) 88.28,28.03 JDIMM2.26 ; JDIMM2.86 103.28,27.92 102.96,27.61 v2(102.71,27.61) 102.28,28.04 JDIMM2.82 ; JDIMM2.98 106.28,27.81 v2(106.48,27.61) ; JDIMM1.234 142.28,40.78 v2(141.9,40.41) 141.5,40.41 141.28,40.64 JDIMM1.230 ; JDIMM1.248 145.77,40.36 v2(145.75,40.34) 146.41,40.34 146.77,40.7 JDIMM1.252 ; JDIMM1.94 105.27,40.64 104.93,40.29 v2(104.45,40.29) 104.27,40.46 JDIMM1.90 ; v2(128.52,38.44) 129.03,37.94 JDIMM2.181 ; JSSD1.71 223.07,27.55 v2(222.79,27.27) 223.02,27.05 JSSD1.73 ; JWLAN.31 302.49,59.5 302.84,59.86 ; JDIMM2.107 108.53,38.15 108.34,38.33 107.84,38.33 v2(107.75,38.42) 107.53,38.2 JDIMM2.103 ; v2(108.32,51.94) 107.05,51.94 106.53,51.41 JDIMM1.99 ; JDIMM2.102 107.28,27.77 v2(107.11,27.6) ; JDIMM1.82 102.27,40.63 v2(102.5,40.41) 103,40.41 103.27,40.68 JDIMM1.86 ; JSSD1.33 222.89,37.05 v2(222.73,37.21) ; JDIMM1.227 140.52,50.87 140.17,51.22 v2(139.84,51.22) 139.68,51.22 139.52,51.07 JDIMM1.223 ; JDIMM1.81 102.02,51.46 102.49,51.93 v2(102.97,51.93) ; JDIMM2.39 91.53,38.34 v2(91.5,38.37) 90.8,38.37 90.53,38.09 JDIMM2.35 ; JDIMM1.6 83.27,40.82 83.68,40.42 v2(83.75,40.42) ; v2(137.88,40.42) 138.28,40.81 JDIMM1.218 ; JDIMM2.226 140.28,31.07 141,31.79 v2(141.13,31.79) ; v2(302.81,50) JWLAN.1 ; JDIMM1.210 136.28,40.78 v2(136.63,40.42) 136.93,40.42 137.28,40.76 JDIMM1.214 ; JDIMM1.40 91.78,43.86 91.1,44.53 v2(90.92,44.53) ; JDIMM2.85 103.03,38.71 102.63,39.1 v2(102.52,39.1) ; JDIMM2.167 125.53,38.26 125.66,38.4 v2(126.04,38.4) 126.23,38.4 126.53,38.1 JDIMM2.171 ; JDIMM2.27 88.53,38.22 88.28,38.46 v2(87.81,38.46) 87.53,38.18 JDIMM2.23 ; v2(235.05,83.91) 235.05,83.91 UG5.H13 UG5.H14 235.45,85.17 235.77,85.5 v2(235.85,85.5) ; JWLAN.67 302.71,68.5 v2(302.99,68.23) ; v2(146.39,51.32) 146.52,51.18 JDIMM1.251 ; JDIMM1.39 91.53,51.3 v2(91.47,51.35) ; JDIMM2.193 132.03,38.25 v2(131.95,38.33) ; JSSD2.33 228,13.15 228.74,13.89 v2(228.74,14.65) JSSD2.27 ; JDIMM2.43 92.53,38.56 93.09,39.12 v2(93.27,39.12) ; JDIMM2.69 99.03,38.48 v2(99.49,38.94) ; JDIMM2.56 95.78,27.86 v2(96.02,27.62) ; JDIMM1.181 129.02,51.08 v2(128.87,51.24) ; v2(126.67,52.05) 127.01,52.05 127.53,51.54 JDIMM1.175 ; JDIMM2.36 90.78,27.99 90.5,27.71 89.41,27.71 v2(89.3,27.6) 89.3,28.04 89.28,28.06 JDIMM2.30 ; v2(137.71,51.16) 138.02,50.85 JDIMM1.217 ; JSSD2.45 v2(225.75,10.15) 225.59,10.32 225.59,11.43 225.8,11.65 JSSD2.39 ; JDIMM1.2 82.27,40.43 v2(82.46,40.25) ; JDIMM2.31 89.53,33.48 v2(89.37,33.32) ; PU507.23 v2(111.58,133.31) ; JDIMM1.68 98.78,40.23 99.21,39.8 v2(99.49,39.8) ; v2(132.26,147.82) 132.72,148.28 RT108.2 ; JDIMM2.234 142.28,27.95 141.93,27.61 v2(141.71,27.61) 141.54,27.61 141.28,27.88 JDIMM2.230 ; JDIMM1.48 93.78,42.85 93.84,42.92 93.84,44.14 93.45,44.53 v2(93.28,44.53) 92.9,44.53 92.64,44.26 92.64,42.92 92.78,42.78 JDIMM1.44 ; JDIMM2.9 84.03,38.54 v2(84.04,38.55) ; JDIMM1.9 84.02,50.75 84.4,51.13 v2(84.4,51.22) ; UG9.M52 v2(206.3,115.8) ; JDIMM2.210 136.28,27.98 v2(136.64,27.62) 136.88,27.62 137.28,28.01 JDIMM2.214 ; v2(143.58,40.42) 143.28,40.72 JDIMM1.238 ; JDIMM1.103 107.53,50.89 107.89,51.25 v2(108.32,51.25) 108.53,51.05 JDIMM1.107 ; JDIMM2.48 93.78,30.48 93.91,30.61 93.91,31.28 93.45,31.73 v2(93.28,31.73) 92.9,31.73 92.64,31.46 92.64,30.3 92.78,30.16 JDIMM2.44 ; JDIMM1.27 88.53,50.94 88.28,51.18 v2(88,51.18) 87.81,51.18 87.53,50.89 JDIMM1.23 ; JDIMM2.47 93.53,38.17 v2(93.27,38.42) ; v2(106.99,30.4) 107.62,30.4 108.28,29.75 JDIMM2.106 ; JDIMM1.89 104.02,50.95 104.25,51.18 v2(104.47,51.18) 104.89,51.18 105.02,51.04 JDIMM1.93 ; v2(222.14,33.91) 222.42,34.19 222.89,34.19 223.02,34.05 JSSD1.45 ; JDIMM2.168 125.78,27.03 v2(125.98,26.82) ; v2(137.86,38.3) 138.03,38.14 JDIMM2.217 ; JDIMM1.61 v2(97.02,51.17) ; v2(131.99,52.09) 132.3,52.09 133.02,51.37 JDIMM1.197 ; v2(131.96,38.91) 132.57,38.91 133.03,38.46 JDIMM2.197 ; v2(95.12,43.51) 94.78,43.16 JDIMM1.52 ; JDIMM2.222 139.28,28.04 139.56,27.76 v2(139.56,27.61) ; v2(100.68,40.41) 100.86,40.41 101.27,40.82 JDIMM1.78 ; JDIMM2.213 137.03,38.11 136.81,38.32 v2(136.64,38.32) 136.23,38.32 136.03,38.11 JDIMM2.209 ; JSSD1.75 v2(225.31,26.55) ; v2(98.27,51.19) 98.15,51.19 98.02,51.06 JDIMM1.65 ; JWLAN.49 v2(300.49,64) ; UG9.R52 204.2,115.73 v2(204.26,115.78) ; v2(302.81,51.5) JWLAN.7
  BOTTOM w0.356: RT39.2 146.89,149.59 v2(146.63,149.33) ; RT73.2 119.5,155.85 v2(118.67,155.03) ; v2(183.15,58.95) 183.28,58.83 RG3.1 ; CT59.2 149.43,155.31 148.97,155.31 v2(148.85,155.19) ; v2(118.33,153.17) 118.98,153.82 CT102.2 120.27,153.19 CT101.2 ; CT79.2 149.69,154.74 v2(150.15,155.19) ; RT72.2 122.88,156.69 v2(123.35,157.17) 123.77,156.75 RT71.2 ; RM64.2 109.78,151.73 110.06,151.73 110.25,151.54 v2(110.57,151.54) ; v2(144.96,157.14) 144.96,157.74 RT80.1 ; v2(135.31,163.94) 135.31,163.22 135.75,162.77 RV600.1 136.37,162.65 135.7,161.98 ; RM82.1 RM23.1 109.53,153.76 v2(110.31,153.76) ; v2(147.55,154.54) 147.58,154.57 CT61.2 ; QE57.4 177.28,13.75 176.91,14.12 RE641.2 176.67,12.75 v2(176.67,12.63) ; 194.08,134.38 195.11,134.38 CG78.2 CG79.2
  BOTTOM w0.381: RV669.2 176.38,123.72 v2(176.73,123.72) ; DU12.3 v2(311.1,45.62) ; RT79.2 148.91,146.04 v2(148.82,146.13) ; v2(199.3,162.21) 200.13,163.03 JDP.8 ; v2(193.78,159.54) 193.59,159.72 UV3.15 ; CG79.2 198.05,134.3 198.52,134.78 v2(199.01,134.78) ; v2(176.73,125.63) 176.63,125.73 RV670.2 ; CG167.2 241.45,106.16 v3(241.45,105.47) v2(241.45,104.35) ; v2(148.24,146.1) 148.24,146.1 RT78.2 ; v2(222.96,25.55) 223.06,25.45 JSSD1.77 ; v2(203.02,144.8) 202.82,144.6 CL7.2 ; UV3.8 189.69,155.64 189.33,156.01 189.1,156.01 188.94,156.17 v2(188.67,156.17) ; v2(191.54,134.9) 191.8,134.64 192.61,134.64 192.88,134.38 RG112.2 194.08,134.38 ; CT60.2 150.05,152.63 149.54,152.63 v2(149.5,152.59) ; CT80.2 148.77,155.12 v2(148.85,155.19) ; CV484.2 171.86,129.02 UV22.15 ; RG501.2 185.27,75.93 184.8,75.46 v2(184.8,75.03) ; RT64.2 CT112.2 ; v2(166.64,134.01) 165.55,132.92 UV22.8 ; CG483.2 v2(185.28,67.39) ; v2(201.7,162.24) 201.92,162.46 JDP.14 ; CV34.2 205.13,161.15 CV35.2 204.97,161.48 205.31,161.82 v2(205.31,161.95) ; PR104.2 PR106.1 32.71,23.46 v2(33.29,22.88) 33.6,23.2 PR107.2 ; RM62.1 108.09,144.39 v2(108.09,143.79) 108.09,143.13 RM75.1 ; v2(124.73,157.73) 124.7,157.71 124.7,156.68 RT69.2 RT68.2 ; v2(159.28,165.64) 159.22,165.7 DT10.3 ; CT78.2 147.46,152.73 CT46.2 146.76,152.73 146.62,152.59 v2(146.25,152.59) ; v2(187.4,60.54) 187.21,60.73 CG1.2 ; UM4.15 v2(88.82,149.03) ; DU13.3 308.56,42.38 v2(308.43,42.51) ; CG113.2 CG114.2 RG123.2 ; Q28.4 221.51,19.76 ; UM4.19 v2(91.42,149.03) ; RT44.2 RT43.2 151,159.09 150.7,159.09 150.69,159.08 v2(150.14,159.08) ; RT63.2 131.58,148.6 CT93.2 ; CT113.2 130.57,156.96 v2(129.76,157.77) ; 170.37,74.59 v2(170.37,74.59) ; CT62.2 146.21,155.89 v2(146.25,155.84) ; RT22.2 v2(128.09,144.87) ; UM4.6 v2(88.82,145.57) ; CV20.2 195.65,160.32 195.65,160.58 195.63,160.59 CV23.2
  BOTTOM w0.4: v2(238.25,74.31) UG5.E1 237.85,74.71 v2(238.25,75.11)
  BOTTOM w0.406: UM7.3 117.81,168.25 117.61,168.45 117.61,168.52 v2(117.63,168.52) ; v2(126.44,166.14) 126.58,166 UM3.3 ; v2(194.96,155.92) 194.96,155.47 CL15.2 ; v2(101.46,20.28) 101.59,20.28 101.81,20.5 JEC.9 ; v2(128.69,157.85) 128.69,157.78 129.11,157.36 RT64.2 ; UX2.3 167.48,162.75 v2(167.14,162.41) ; v2(128.06,161.49) 128.26,161.7 QM2.1 ; JEC.10 v2(108.24,21.25)
  BOTTOM w0.457: v2(30.33,19.61) 29.87,19.15 CA71.1 ; v2(31.19,39.68) 31.23,39.64 31.39,39.64 CA12.2 ; CG82.2 210.69,142.3 v2(210.21,142.78) ; v2(188.93,61.11) 188.52,61.11 PC6393.2 ; v2(188.93,57.4) 188.52,57.4 PC6402.2 ; CH48.2 160.64,56.39 160.34,56.08 v2(160.34,55.86) ; CG97.2 193.65,131.88 192.55,130.77 v2(191.66,130.77) ; v2(226.41,129.58) 227.31,128.68 CG134.2 ; UG11.3 201.24,71.68 CG61.2 ; CG149.2 235.55,87.6 v3(235.97,87.18) 235.97,86.8 v2(236.64,86.13) ; CT93.2 132.04,148.03 v2(132.26,147.82) ; v2(210.21,139.58) 212.48,139.58 CG80.2 ; PC6401.2 188.52,56.13 v2(188.93,56.13) ; v2(199.01,130.78) 198.78,130.54 CG81.2 ; CG12.1 v2(191.38,71.56) ; v2(191.63,129.63) 192.3,128.95 CG98.2 ; CG117.2 232.32,121.73 233.08,120.97 v2(233.08,120.37) ; v2(64.78,61.23) 65.4,60.61 R185.1 ; v2(129.43,160.95) 129.56,160.81 QM2.4 ; CG132.2 226.46,139.83 v2(226.21,139.58) ; v2(188.93,59.84) 188.47,59.84 PC6394.2 ; v2(174.58,74.64) 174.58,74.64 RG98.2 ; CG133.2 226.37,142.94 v2(226.21,142.78) ; v2(123.65,161.71) 123.65,159.93 122.99,159.27 CV19.2 ; CG21.1 v2(190.11,71.56)
  BOTTOM w0.508: v2(117.55,164.49) 118.24,165.18 RM42.2 ; v2(142.83,163.46) 142.83,163.79 142.58,164.03 CV373.2 CV9.2 ; v2(191.54,142.78) 193.5,142.78 CG99.2 ; CG388.2 196.84,127.79 198.17,129.12 198.95,129.12 v2(199.01,129.18) ; RA73.2 30.61,12.99 CA254.2 31.27,13 v2(31.95,13) ; PC501.2 v2(91.11,124.34) ; CM20.2 89.22,141.45 v2(89.29,141.38) ; PR6230.2 217.4,27.02 v2(216.93,26.55) ; CH175.2 181.83,56.27 182.32,55.78 v2(182.32,55.65) ; v2(51.95,60.78) C258.2 ; v2(299.03,70.08) 299.52,69.6 JWLAN.69 ; PR1305.2 166.71,27.38 v2(166.57,27.24) 166.42,27.09 166.02,27.09 165.81,26.89 PU1300.8 ; v2(173.56,83.72) 173.94,83.34 CG75.1 ; CE19.2 72.01,14.26 71.64,14.63 71.32,14.63 71.07,14.88 v2(71.01,14.88) ; v2(30.62,31.35) 30.79,31.18 CA18.2 ; RE27.2 RE37.2 171.73,23.53 CE25.2 171.72,24.12 v2(171.9,24.29) ; QG4.3 239.11,89.08 240.27,89.08 v2(240.81,88.54) ; v2(97.94,140.63) PC529.2 ; v2(120.88,145.02) 120.14,145.02 119.77,144.64 CT88.2 ; CU2.2 19.72,55.77 v2(19.79,55.7) ; C2506.2 C2507.2 60.96,60.91 61.29,61.24 v2(61.29,61.81) C2524.2 ; v2(101.05,85.7) 100.27,85.7 99.79,86.18 C2518.2 ; v2(98.65,100.98) RH59.2 RH57.1 ; Q28.1 223.34,21.17 v2(222.65,21.87) ; v2(174.5,158.05) 174.42,157.96 RX1.2 ; v2(186.01,47.67) 185.38,47.67 185.04,48 CH46.2 ; C2498.2 70.25,57.87 v2(69.8,58.32) ; RG92.1 176.93,75.14 v2(176.42,74.64) 175.97,75.08 RG93.1 ; RH466.2 124.21,113.74 v2(123.64,113.17) 123.32,113.49 RH472.2 ; RE29.2 RE30.2 178.34,18.82 v2(178.37,18.86) ; PR116.2 36.14,19.72 35.71,19.28 v2(35.63,19.28) ; v2(60.01,40.11) 60.42,39.71 PC709.2 ; CM35.2 v2(100.08,143.66) ; PR5018.1 93.73,113.09 v2(93.61,113.2) ; RX8.2 166.51,161.63 v2(166.38,161.76) ; CG436.2 173.83,61.47 CG437.2 173.34,60.6 v2(173.18,60.77) ; PC1006.2 150.76,116.8 v2(150.76,117.26) ; PC2.2 PC1.2 v2(32.26,47.07) ; v2(35.64,7.91) 35.05,7.32 JSPK.8 ; YH2.4 158.35,57.41 157.93,56.99 CH47.2 v2(157.93,55.92) ; CG134.2 228.68,128.61 CG364.2 ; JDIMM1.262 149.2,53.87 v2(149.3,53.76) ; v2(247.33,84.03) 248.48,85.18 JFAN2.5 ; CM31.2 94.2,148.27 v2(94.05,148.42) ; v2(239.85,104.35) 239.85,105.19 239.09,105.94 CG421.2 ; v2(38.62,28.81) PC111.2 ; JDIMM2.262 147.4,21 v2(146.95,20.55) ; v2(95.56,126.64) PR517.2 PR518.2 ; v2(237.82,147.22) 237.82,147.51 PC815.2 ; CG148.2 RG134.2 CG149.2 ; v2(192.04,147.28) 191.9,147.42 CL42.2 ; v2(227.85,85.51) 227.09,86.26 CG151.2 ; v2(203.98,157.82) 203.98,157.65 YL1.4 ; v2(138.07,81.64) 138.36,81.35 RH150.1 RH149.1 ; RM84.1 v2(96.41,144.45) ; JSPK.7 44.55,7.32 v2(44.53,7.3) ; v2(33.39,37.35) CA41.2 ; v2(205.06,27.58) 204.74,27.9 PR6133.1 ; v2(60.33,46.92) PC212.2 ; UV17.2 139.55,163.91 v2(139.5,163.96) ; v2(97.21,105.82) 97.21,106.44 RH166.1 ; PR519.2 PR516.2 96.44,126.81 v2(96.34,126.71) ; v2(36.15,35.9) 35.98,35.73 34.97,35.73 CA11.2 ; PC112.2 37.28,20.03 37.87,20.62 v2(38.11,20.62) ; SW2.1 v2(174.73,162.01) ; v2(20.06,27.15) 20.03,27.13 CA258.2 ; PR715.2 63.1,34.17 v2(64.32,35.4) ; v2(170.08,164.87) 170.08,165.4 CX2.2 ; RT65.2 130.8,153.62 CT106.2 131.69,153.62 v2(132.22,153.08) ; CL9.1 200.71,154.66 200.96,154.91 YL1.2 200.54,155.23 v2(199.89,155.89) ; PR6225.1 174.64,109.18 174.19,108.74 v2(173.94,108.74) 174.39,108.29 RG23.1 ; CV438.2 RV23.1 163.33,103.28 v2(163.65,103.28) ; CL30.1 v2(229.52,158.95) ; PC811.2 v2(238.9,155.6) ; v2(62.46,20.26) 61.75,19.55 PC8.2 61.75,18.35 PC9.2 ; PR6117.2 v2(199.36,26.04) ; v2(161.37,149.51) 162.17,149.51 PC800.1 ; v2(162.32,115.92) 162.32,115.03 RV20.2 ; v2(195.85,159.22) 195.85,159.84 CV20.2 ; RV1.2 135.76,156.35 135.89,156.48 v2(136.84,156.48) ; v2(61.8,62.19) 62.82,62.19 63.25,62.63 63.25,62.93 JFAN1.6 ; v2(49.28,43.07) 49.21,43 PR700.1 ; QL3.3 v2(236.86,154.69) ; RV630.2 159.94,97.74 v2(159.78,97.58) ; CE20.2 69.47,14.3 v2(69.93,14.76) ; v2(90.06,155.09) RM38.2 ; CG390.2 197.23,140.37 v2(198.05,140.37) ; PR6128.1 v2(173.94,111.58) ; v2(179.26,27.13) 179.24,27.15 UH4.4 ; CT90.2 132.28,143.66 131.59,142.96 v2(130.95,142.96) ; JDIMM2.261 v2(84.19,21) ; RV665.2 187.09,154.72 187.09,154.96 186.7,155.35 186.7,156.72 186.58,156.85 v2(186.56,156.85) ; RM21.1 v2(92.14,141.25) ; v2(146.25,153.24) 146.24,153.26 RT5.2 ; PC507.2 86.6,127.39 PR513.1 86.59,126.5 PC5010.1 86.61,126.31 87.12,125.81 v2(87.52,125.81) ; RA22.2 28.66,43.56 v2(28.83,43.74) ; v2(40.45,48.21) PC3.2 ; PC719.2 PR719.2 63.33,36.65 v2(63.82,36.65) ; RG26.2 177.12,91.91 177.24,91.78 v2(177.62,91.78) ; RH497.1 99.24,108.28 v2(98.77,108.28) ; PC590.2 PR5034.1 ; PC590.2 v2(96.53,107.72) ; PC590.2 PR5008.2 ; CG152.2 238.56,87.49 238.55,87.48 238.55,87.3 v2(239.03,86.83) ; CG79.2 196.1,133.76 CG389.2 ; v2(234.77,123.72) 235.15,124.1 RG123.2 ; CT48.2 150.44,155.19 v2(150.15,155.19) ; PC6.2 72.37,19.26 v2(72.78,18.84) 72.31,18.37 PC7.2 ; Q29.1 219.47,17.05 v2(219.41,17.11) ; v2(68.89,5.94) 68.2,5.26 UE2.4 ; CE65.2 72.9,3.76 73.26,4.12 74.28,4.12 74.82,3.58 v2(74.82,3.33) ; CG150.2 241.54,88.64 v2(241.89,88.99) ; v2(98.44,136.46) 98.44,137.39 98.83,137.79 PC522.2 ; RH187.2 99.16,97.87 98.65,98.38 v2(98.65,98.82) ; v2(118.15,151.71) 119.38,151.71 119.77,152.1 RT75.2 120.08,152.08 120.08,150.91 CT103.2 120.27,149.94 CT98.2 ; PC1304.2 PC1303.2 v2(158.95,27.82) ; v2(55.31,40.05) 55.93,40.66 PC707.1 ; QG3.3 237.83,126.82 v2(238.73,127.72) ; PC6121.2 203.24,26.72 v2(203.66,27.14) ; UL2.2 v2(193.56,151.08) ; CM29.2 94.2,145.06 v2(94.06,144.93) ; CT91.2 131.07,143.74 v2(130.95,143.62) ; v2(160.16,155.68) 160.27,155.79 PC801.2 ; v2(187.26,62.94) 186.73,62.94 RG562.2 ; v2(90.44,94.21) 90.37,94.21 PC597.2 ; PC817.2 168.04,156.93 167.46,157.5 v2(167.46,157.69) ; v2(97.56,91.57) 97.56,92.46 97.6,92.5 C3.2 ; C2519.2 v2(96.34,87.72) ; v2(199.9,161.04) 199.53,160.66 199.53,160.3 199.14,159.9 RV18.1 198.27,159.9 198.22,159.96 CX1.2 ; JELC.7 219.93,32.29 v2(220.55,32.92) ; v2(61.31,51.35) 61.21,51.45 PC214.2 ; CL41.2 188.17,151.65 v2(188.04,151.79) ; v2(180.34,139.58) 179.61,139.58 178.58,140.61 CG422.2 ; v2(86.24,142.09) 86.25,142.09 86.48,141.86 CM21.2 ; v2(61.86,48.31) 61.73,48.44 PC207.1 ; v2(167.24,53.8) 167.55,54.11 167.55,54.36 167.61,54.43 CH178.2 ; PC1004.2 146.95,116.8 v2(146.95,117.26) ; v2(152.8,99.47) 152.73,99.53 CV437.2 ; CH179.2 v2(164.92,56.81) ; v2(28.9,30.94) 28.9,31.38 29.16,31.65 CA1.2 CA2.2 v2(29.16,33.28) ; v2(31.5,46.32) CA35.2 CA34.2 ; v2(229.45,85.51) 229.38,85.58 229.38,86.7 229.57,86.89 CG420.2 ; RA52.1 29.16,22.71 RA62.1 29.85,22.2 30.01,22.04 32.02,22.04 32.24,21.81 v3(32.83,21.81) v2(33.29,22.27) ; RH581.2 172.46,55.95 RH109.2 170.95,55.95 CH177.2 169.93,54.93 v2(169.93,53.61) ; CV1056.2 164.72,162.42 v2(164.86,162.29) ; RV628.2 RV22.2 v2(156.93,97.05) ; v2(188.86,149.19) 188.86,150.22 CL40.2 ; v2(98.69,102.41) 98.9,102.41 RH58.1 ; v2(181.94,142.78) 182.39,143.22 CG406.2 ; CG61.2 v2(200.51,70.32) ; CM19.2 v2(85.37,153.11) ; JSPK.6 37.3,11.58 37.07,11.35 35.47,11.35 35,10.88 v2(35,10.25) ; v2(131.09,166.17) 130.86,165.94 RM6.1 ; v2(229.09,2.81) 229.09,2.12 228.52,1.55 JSSD2.77 ; v2(94.38,102.83) 94.32,102.88 PC807.2 93.16,102.88 v2(93.11,102.83) ; v2(61.66,53.35) 61.42,53.35 PR207.2 ; PC813.2 v2(233.51,150.12) ; RG89.1 v2(173.94,78.89) ; RT37.2 143.52,155.64 v2(143.49,155.68) ; YG1.4 170.87,83.31 v2(171.08,83.53) ; v2(165.47,80.61) 164.86,80 UG13.4 ; PC213.2 60.17,50.21 v2(60.68,50.73) ; v2(34.37,41.9) CA37.2 CA36.2 ; CG324.2 CG169.2 230.14,91.78 229.45,92.47 v2(229.45,92.95) ; v2(188.93,58.63) 188.55,58.63 PC6408.2 ; PR811.2 v2(240.87,155.6) ; RH148.1 v2(144.92,81.42) ; v2(61.8,59.33) 61.42,58.95 C2523.2 ; v2(94.69,153.38) 94.69,153.06 95.16,152.59 RM72.1 RM87.2 ; v2(141.85,149.2) 141.55,149.5 141.55,150.52 UT2.4 ; CT99.2 122.44,144.7 v2(122.77,144.37) ; PC523.2 v2(89.16,137.53) ; v2(217.63,19.2) 217.5,19.33 Q34.4 ; JRTC1.3 v2(255.73,50.25) ; v2(57.86,30.26) PC710.2 ; CL11.2 CL12.2 196.14,154.79 196.14,155.47 v2(196.13,155.47) ; CT73.2 135.7,161.98 ; JSSD1.76 v2(226.43,46.15) ; CM16.2 v2(92.97,153.42) ; CG316.2 227.57,134.96 v2(227.56,134.97) ; RM29.2 v2(85.67,155.09) ; v2(109.55,148.36) 109.82,148.62 CM34.2 ; RG88.1 172.23,83.84 v2(172.04,83.65) ; PC812.2 v2(233.51,147.19) ; v2(136.22,164.95) 136.22,164.7 136.76,164.16 CV372.2 ; v2(27.21,47.51) 27.21,47.06 CA6.2 27.63,46.64 CA5.2 ; JACK1.7 8.84,12.09 9.16,11.77 14.77,11.77 v3(15.88,12.88) v2(17.2,12.88) ; v2(154.61,98.34) 155.16,97.79 RV622.2 RV626.2 ; CG66.2 170.13,86.47 169.69,86.91 166.72,86.91 v2(166.51,86.7) ; PR711.2 57.37,33.89 v2(57.34,33.87) ; v2(170.26,71.97) 170.64,71.97 170.89,71.72 UG15.4 ; CV484.2 172.43,129.26 173.43,130.26 v2(173.43,130.9) ; CM9.2 v2(104.59,155.64) ; CG116.2 240.91,120.54 v2(241.08,120.37) ; v2(247.66,90.32) 247.09,90.51 246.18,90.05 246.18,88.61 246.16,88.58 JFAN2.1 ; v2(148.86,117.26) 148.86,116.8 PC1003.2 ; v2(165.53,17.99) 165.79,18.25 PR1302.2 PC1301.2 ; v2(154.38,113.33) 154.51,113.45 CV436.2 ; v2(161.19,158.14) 161.32,158.01 PR802.2 ; RG87.1 v2(173.32,75.23) ; CM18.2 v2(89.41,153.42) ; PR5015.2 v2(90.07,111.54) ; CA7.2 v2(25.67,44.46) ; PC6215.2 v2(215.71,26.25) ; JDIMM1.261 83.91,57.8 84.87,56.84 v2(84.91,56.84) ; v2(226.46,136.9) 226.82,137.26 RG120.2 ; RH185.2 v2(98.65,96.92) ; CG344.2 243.83,79.65 v2(244.16,79.32) ; CA64.2 29.29,26.13 29.17,26.01 29.17,25.43 v2(29.6,25) ; v2(18.62,13.38) CA257.2 19.3,13.68 19.88,14.26 RA76.2 ; PR547.1 89.59,139.9 PC537.2 89.64,140.62 89.99,140.97 v2(89.99,141.35) ; PC806.2 v2(239.41,147.46) ; v2(187.4,26.08) 187.66,25.83 CH49.2 ; PR6213.2 v2(212.19,26.25) ; v2(59.47,36) 59.46,36.02 PR728.1 ; RM17.1 CM23.2 v2(128.72,167.01) ; Q29.4 217.36,14.98 v2(217.36,14.44) ; CL29.2 v2(233.35,160.1) ; CA13.2 CA12.2 ; PH500.1 110.21,136.49 v2(110.25,136.44) ; PC5003.2 v2(95.07,102.72) ; CM30.2 94.49,148.92 v2(94.05,149.37) 94.49,149.81 CM33.2 ; v2(173.94,79.65) CG76.1 172.7,80.4 YG1.2 ; CL8.1 203.47,153.51 v2(203.18,153.22) ; JRTC1.4 262.08,54.43 v2(262.92,55.27) ; PR813.1 163.73,156.5 v2(164.1,156.87) 164.16,156.87 164.59,156.44 PR805.2 ; CM32.2 v2(101.6,143.66) ; RV664.2 187.29,151.55 186.96,151.22 v2(186.96,150.07) ; PR105.1 32.57,31.36 v2(33.18,31.97) ; C11.2 100.9,92.74 101.23,93.07 v2(101.63,93.07) ; v2(117.54,159.71) 117.68,159.58 CV21.2 ; CG404.2 229.76,120.49 v2(229.88,120.37) ; JRTC1.2 v2(259.53,49.12) ; v2(64.59,67.33) 64.61,67.32 64.61,64.68 64.21,64.29 64.21,63.91 JFAN1.1 ; CL28.2 v2(233.35,158.19) ; CU3.2 v2(19.51,57.29) ; CLRP1.2 v2(143.74,15.86) ; CG288.2 198.26,71.36 v2(198.92,72.02) 198.54,72.4 RG65.1 ; CA65.2 v2(29.29,28.01) 29.89,28.01 PR103.1 30.23,27.21 30.17,27.16 PC101.2 ; CL14.2 195.9,150.45 v2(196.35,150.45) 196.35,150.76 196.66,151.08 CL13.2 ; CM36.2 v2(101.35,155.03) ; CH45.2 184.62,51.08 v2(184.32,51.39) 184.87,51.95 RH9.2 ; v2(40.45,49.16) PC4.2 ; 221.51,19.76 v2(221.51,19.14) ; RL3.2 204.49,153.7 v2(204.1,153.31) ; CG168.2 v2(241.29,91.57) ; CA4.2 26.12,42.97 v2(26.36,42.72) ; CG384.2 122.82,159.23 CV19.2 ; DU1.1 v2(21.66,47.2) ; v2(229.12,21.04) 229.12,21.61 228.49,22.25 JSSD2.76 ; JFAN1.5 68.53,64.84 68.53,63.83 67.84,63.13 v2(67.84,62.51) ; v2(142.26,114.53) 142.63,114.9 RH469.2 ; v2(34.37,43.26) CA38.2 ; PC5011.1 88,139.32 88.37,138.95 v2(88.37,138.62) ; CT92.2 132.12,146.83 v2(132.8,147.5) ; PC1307.2 v2(158.64,21.3) ; CL27.2 v2(206.77,159.54) ; QG2.3 193.29,138.41 192.12,139.58 v2(191.54,139.58) ; v2(182.32,4.94) 182.32,5.75 183.65,7.08 JKB.31 ; v2(242.68,120.37) 243.77,121.46 CG115.2 ; PR808.2 v2(239.85,155.6) ; CG241.2 v2(171.58,69.04) ; RM25.1 v2(90.75,153.42) ; v2(233.31,161.63) 233.31,161.75 CL31.2 ; Q34.1 219.94,21.65 v2(220.23,21.65) ; v2(18.98,18.5) DA5.1 ; v2(134.52,161.5) 134.86,161.16 134.86,160.68 CT74.2 135.7,158.51 CT75.2 ; CM17.2 v2(92.08,153.42) ; PH504.1 v2(134.75,138.16) ; v2(172.99,71.46) 172.99,72.43 QG500.4 ; CM70.2 v2(114.68,166.59) ; QX1.3 v2(175.5,157.99) ; CU6.2 v2(19.51,53.3) ; YH2.2 v2(161.61,59.54) ; v2(185.05,4.94) 186.7,6.59 JKBBL.22 ; JTP.17 v2(215.35,5.02) ; v2(299.17,48.9) JWLAN.68
  vias: v2(1.7,54.61) v2(1.99,58) v2(3,59.74) v2(3,56.26) v2(5,59.74) v2(5,56.26) v2(6.01,58) v2(9.09,58) v2(10.05,59.65) v2(10.05,56.35) v2(11.95,59.65) v2(11.95,56.35) v2(12.9,58) v2(14.4,60.3) v2(17.03,11.77) v2(20.13,48.97) v2(21.1,10.3) v2(21.1,2.68) v2(22.02,60.3) v2(22.14,6.5) v2(22.98,28.03) v2(23.15,8.24) v2(23.15,4.76) v2(23.45,57.87) v2(23.64,54) v2(23.84,23.29) v2(23.84,21.91) v2(23.84,20.53) v2(23.84,19.15) v2(24.21,52.28) v2(24.54,40.25) v2(24.54,38.18) v2(24.54,36.11) v2(25.22,23.29) v2(25.22,21.91) v2(25.22,20.53) v2(25.22,19.15) v2(25.15,8.24) v2(25.15,4.76) v2(25.29,57.81) v2(25.87,12.05) v2(26.19,12.57) v2(26.16,6.5) v2(26.25,27.98) v2(26.5,12.05) v2(26.61,38.18) v2(26.61,36.11) v2(26.6,23.29) v2(26.6,21.91) v2(26.6,20.53) v2(26.6,19.15) v2(26.89,27.98) v2(27.14,12.05) v2(27.98,23.29) v2(27.98,21.91) v2(27.98,20.53) v2(27.98,19.15) v2(28.09,6.5) v2(28.39,0.45) v2(28.73,56.44) v2(28.67,55.36) v2(28.67,54.34) v2(28.68,40.25) v2(28.68,38.18) v2(28.68,36.11) v2(28.99,54.85) v2(29.05,55.87) v2(29.12,8.28) v2(29.12,4.72) v2(29.43,56.44) v2(29.37,55.36) v2(29.37,54.34) v2(29.64,60.3) v2(29.75,55.87) v2(29.75,54.85) v2(30.13,56.44) v2(30.07,55.36) v2(30.07,54.34) v2(30.45,55.87) v2(30.45,54.85) v2(30.83,56.44) v2(30.77,55.36) v2(30.77,54.34) v2(31.15,55.87) v2(31.15,54.85) v2(31.18,8.28) v2(31.18,4.72) v2(31.53,56.44) v2(31.53,55.36) v2(31.46,54.34) v2(31.85,55.87) v2(31.85,54.85) v2(32.21,6.5) v2(33.89,27.55) v2(34.51,28.17) v2(34.51,26.93) v2(35.13,27.55) v2(35.7,3.45) v2(37.26,60.3) v2(40.01,29.83) v2(40.02,28.56) v2(40.33,30.46) v2(40.33,29.2) v2(40.65,31.04) v2(40.65,28.56) v2(40.65,29.83) v2(40.97,30.46) v2(40.97,29.19) v2(41.29,31.03) v2(41.29,29.83) v2(41.29,28.56) v2(41.6,31.6) v2(41.6,30.46) v2(41.6,29.19) v2(41.6,27.92) v2(41.92,31.03) v2(41.92,29.83) v2(41.92,28.56) v2(42.24,30.46) v2(42.23,29.2) v2(42.23,27.93) v2(42.55,31.04) v2(42.56,29.83) v2(42.55,28.56) v2(42.86,65.46) v2(42.87,30.46) v2(42.87,29.19) v2(42.87,27.92) v2(43.19,31.03) v2(43.19,29.83) v2(43.19,28.56) v2(43.19,27.35) v2(43.32,3.45) v2(43.51,27.92) v2(43.76,21.19) v2(43.76,20.55) v2(44.84,20.55) v2(44.84,19.92) v2(44.84,19.28) v2(44.84,18.65) v2(45.35,14.39) v2(47.85,55.13) v2(48.86,56.87) v2(48.86,53.39) v2(48.94,17.85) v2(49.2,18.42) v2(49.26,19.01) v2(49.58,17.85) v2(49.83,18.42) v2(49.9,19.01) v2(50.22,17.85) v2(50.37,31.16) v2(50.37,30.52) v2(50.46,65.99) v2(50.53,19.01) v2(50.47,18.42) v2(50.86,56.87) v2(50.86,53.39) v2(50.85,17.85) v2(50.95,31.16) v2(50.95,30.52) v2(51.1,18.42) v2(51.17,19.01) v2(51.49,17.85) v2(51.53,6.15) v2(51.74,18.42) v2(51.8,19.01) v2(51.85,5.64) v2(51.87,55.13) v2(52.12,17.85) v2(52.17,6.15) v2(52.53,7.58) v2(52.51,5.64) v2(52.65,40.49) v2(52.65,39.79) v2(52.65,39.1) v2(52.65,38.4) v2(52.83,6.15) v2(53.1,26.08) v2(53.1,25.44) v2(53.1,24.81) v2(53.13,7.42) v2(53.18,5.64) v2(53.29,3.52) v2(53.5,6.15) v2(53.73,24.81) v2(54.11,27.73) v2(54.11,27.09) v2(54.11,26.46) v2(54.37,24.81) v2(54.98,53.59) v2(55.37,66.02) v2(55.97,66.02) v2(56.21,53.59) v2(56.72,32.62) v2(57.34,36) v2(57.61,28.3) v2(57.61,27.67) v2(57.61,27.03) v2(57.84,67.88) v2(58.31,28.3) v2(58.41,34.93) v2(58.56,3.45) v2(59,53.57) v2(59.19,27.67) v2(59.19,27.03) v2(59.47,33.87) v2(59.64,53.57) v2(61.31,50.1) v2(61.93,50.73) v2(62.35,47.89) v2(62.62,53.68) v2(63.2,53.68) v2(65.15,36.09) v2(65.35,69.17) v2(65.47,35.57) v2(65.78,36.11) v2(65.85,40.91) v2(66.17,40.4) v2(66.5,40.94) v2(66.91,7.92) v2(66.91,5.94) v2(66.88,2.95) v2(67.9,6.93) v2(68.39,28.59) v2(68.89,7.92) v2(69.03,28.59) v2(70.08,75.15) v2(70.49,28.59) v2(71.12,28.59) v2(71.95,46.69) v2(71.95,46.05) v2(71.95,45.42) v2(71.95,44.78) v2(72.58,46.69) v2(72.58,46.05) v2(72.58,45.42) v2(72.58,44.78) v2(73.16,45.83) v2(73.16,45.19) v2(73.16,44.56) v2(73.61,25.25) v2(73.61,24.62) v2(73.6,0.45) v2(75.27,80.73) v2(79.25,87.22) v2(81.22,0.45) v2(81.88,94.38) v2(82.39,34.66) v2(82.39,33.39) v2(83.05,101.91) v2(83.01,47.07) v2(83.01,45.8) v2(83.01,44.53) v2(83.1,155.25) v2(83.1,147.63) v2(83.1,140.01) v2(83.1,132.39) v2(83.1,124.77) v2(83.1,117.15) v2(83.1,109.53) v2(84.34,34.59) v2(84.34,32.68) v2(84.4,47.39) v2(84.4,45.49) v2(85.67,47.07) v2(85.67,45.8) v2(85.67,44.53) v2(85.67,34.27) v2(85.67,33) v2(85.67,31.73) v2(87.71,47.07) v2(87.71,45.8) v2(87.71,44.53) v2(87.96,34.27) v2(87.96,33) v2(87.96,31.73) v2(88.84,0.45) v2(89.37,31.41) v2(89.52,44.22) v2(89.61,106.79) v2(89.61,106.15) v2(90.51,157.05) v2(90.92,47.07) v2(90.92,45.8) v2(90.92,34.27) v2(90.92,33) v2(91.2,110.64) v2(91.56,135.19) v2(91.56,133.22) v2(91.56,131.25) v2(91.64,123.81) v2(91.82,109.07) v2(92.04,106.77) v2(92.15,104.12) v2(92.15,103.53) v2(92.28,126.66) v2(92.47,123.81) v2(92.79,110.93) v2(92.79,110.32) v2(92.79,103.53) v2(93.28,47.07) v2(93.28,45.8) v2(93.28,34.27) v2(93.28,33) v2(93.36,123.81) v2(93.53,135.19) v2(93.53,133.22) v2(93.53,131.25) v2(93.48,126.66) v2(93.67,123.17) v2(93.8,93.77) v2(94.94,96.12) v2(94.94,94.85) v2(95.01,97.52) v2(95.02,47.39) v2(95.02,45.49) v2(94.96,34.59) v2(94.96,32.68) v2(95.39,98.32) v2(95.49,135.19) v2(95.49,133.22) v2(95.49,131.25) v2(96.53,109.58) v2(96.46,0.45) v2(96.84,47.07) v2(96.84,45.8) v2(96.84,44.53) v2(96.97,34.27) v2(96.97,33) v2(96.97,31.73) v2(97.87,126.22) v2(97.87,125.58) v2(98.13,157.05) v2(98.37,126.54) v2(98.37,125.9) v2(98.82,151.43) v2(98.82,149.9) v2(98.82,148.38) v2(98.83,90.4) v2(99.35,47.07) v2(99.35,45.8) v2(99.35,44.53) v2(99.35,34.27) v2(99.35,33) v2(99.35,31.73) v2(100.58,151.43) v2(100.58,149.9) v2(100.58,148.38) v2(100.66,90.94) v2(100.68,46.12) v2(100.68,44.22) v2(100.99,84.81) v2(101.13,33.32) v2(101.13,31.41) v2(101.36,89.66) v2(101.49,117.84) v2(101.49,117.2) v2(101.99,118.15) v2(101.99,117.52) v2(102.34,151.43) v2(102.34,149.9) v2(102.34,148.38) v2(102.34,81.64) v2(102.5,47.07) v2(102.5,45.8) v2(102.5,44.53) v2(102.5,34.27) v2(102.5,33) v2(102.5,31.73) v2(103.27,140.61) v2(103.47,83) v2(104.1,151.43) v2(104.1,149.9) v2(104.1,148.38) v2(104.08,0.45) v2(104.85,143.66) v2(104.86,84.12) v2(105.17,140.74) v2(105.58,81.4) v2(105.56,79.6) v2(105.74,157.35) v2(105.86,151.43) v2(105.86,149.9) v2(105.86,148.38) v2(105.93,140.42) v2(106.55,83.01) v2(107.01,34.25) v2(106.99,32.94) v2(107.57,81.31) v2(107.84,165.5) v2(107.9,140.8) v2(107.95,47.35) v2(107.94,46.06) v2(107.94,44.6) v2(107.94,43.26) v2(108.47,123.81) v2(108.46,34.22) v2(108.45,32.93) v2(108.85,167.24) v2(108.85,163.76) v2(108.88,82.59) v2(109.11,123.81) v2(109.05,95.5) v2(109.56,104.81) v2(109.74,123.81) v2(109.78,106.83) v2(109.81,101.32) v2(110.05,34.15) v2(110.05,32.85) v2(110.05,31.48) v2(110.2,104.81) v2(110.18,46.95) v2(110.18,45.65) v2(110.38,123.81) v2(110.54,106.84) v2(110.51,82.46) v2(110.46,80.63) v2(110.64,98.08) v2(110.64,96.81) v2(110.85,167.24) v2(110.85,163.76) v2(110.89,95.5) v2(111.53,95.5) v2(111.69,0.75) v2(111.86,165.5) v2(111.92,34.29) v2(111.92,32.92) v2(111.94,31.68) v2(112.04,104.81) v2(112.02,45.71) v2(112.12,106.84) v2(112.1,101.32) v2(112.05,47.09) v2(112.07,44.49) v2(112.67,104.81) v2(112.88,106.85) v2(112.93,98.15) v2(112.93,96.88) v2(113.31,95.5) v2(113.53,134.24) v2(113.54,115.19) v2(113.54,114.55) v2(113.55,79.92) v2(113.55,78.65) v2(113.94,95.5) v2(114.18,115.19) v2(114.18,114.55) v2(114.31,34.33) v2(114.31,33.06) v2(114.31,31.82) v2(114.38,133.1) v2(114.38,132.32) v2(114.38,131.54) v2(114.37,47.13) v2(114.37,45.86) v2(114.37,44.62) v2(114.45,106.84) v2(114.51,104.81) v2(114.45,101.32) v2(114.93,83.46) v2(114.91,80.86) v2(115.15,104.81) v2(115.15,98.15) v2(115.15,96.88) v2(115.25,133.1) v2(115.25,131.54) v2(115.27,106.84) v2(115.91,95.5) v2(115.95,46.12) v2(115.95,44.85) v2(115.95,42.94) v2(115.95,34.97) v2(115.95,33.06) v2(115.95,31.79) v2(116.11,133.1) v2(116.11,131.54) v2(116.55,95.5) v2(116.64,78.99) v2(116.64,77.08) v2(116.88,106.84) v2(116.93,104.81) v2(116.86,101.32) v2(116.98,133.1) v2(116.98,131.54) v2(117.5,98.15) v2(117.5,96.88) v2(117.61,106.85) v2(117.63,104.84) v2(117.82,136.63) v2(117.81,130.74) v2(117.81,130.16) v2(117.81,129.58) v2(117.77,81.72) v2(117.77,79.75) v2(118.2,173.16) v2(118.32,95.54) v2(118.41,132.56) v2(118.41,131.98) v2(118.41,131.39) v2(118.4,130.74) v2(118.4,130.16) v2(118.4,129.58) v2(118.81,34.84) v2(118.81,33.31) v2(118.81,31.79) v2(118.92,95.54) v2(118.99,132.56) v2(118.99,131.98) v2(118.99,131.39) v2(118.98,130.74) v2(118.98,130.16) v2(118.98,129.58) v2(119.21,106.84) v2(119.19,47.64) v2(119.19,46.11) v2(119.19,44.59) v2(119.19,43.06) v2(119.34,101.32) v2(119.31,0.45) v2(119.42,12.64) v2(119.42,10.65) v2(119.47,104.88) v2(119.63,131.96) v2(119.62,131.37) v2(119.62,130.73) v2(119.62,130.15) v2(119.62,129.56) v2(119.62,128.95) v2(119.62,128.37) v2(119.62,127.75) v2(119.62,127.16) v2(119.65,126.54) v2(119.65,125.9) v2(119.72,163.96) v2(119.85,98.15) v2(119.85,96.88) v2(119.85,74.46) v2(119.85,73.22) v2(119.85,71.95) v2(119.98,106.83) v2(120.06,104.88) v2(120.1,103.23) v2(120.15,128.69) v2(120.15,128.09) v2(120.15,127.49) v2(120.15,126.85) v2(120.15,126.22) v2(120.15,125.58) v2(120.41,11.64) v2(120.74,95.54) v2(121.24,45.86) v2(121.24,44.33) v2(121.29,164.45) v2(121.29,74.24) v2(121.29,73.66) v2(121.29,73.08) v2(121.29,72.49) v2(121.29,70.12) v2(121.29,69.53) v2(121.29,68.95) v2(121.29,68.36) v2(121.32,34.84) v2(121.32,33.31) v2(121.32,31.79) v2(121.37,95.54) v2(121.4,10.65) v2(121.54,83.92) v2(121.52,82.03) v2(121.58,106.84) v2(121.68,79.22) v2(121.69,77.42) v2(121.82,104.88) v2(121.75,102.46) v2(121.75,101.13) v2(121.75,99.86) v2(121.86,134.33) v2(121.88,103.23) v2(122.07,98.08) v2(122.07,96.81) v2(122.33,163.84) v2(122.33,106.84) v2(122.39,165.09) v2(122.51,104.88) v2(122.71,133.19) v2(122.71,132.41) v2(122.71,131.63) v2(122.77,83.19) v2(122.78,81.36) v2(122.88,79.47) v2(123.18,47.64) v2(123.18,46.11) v2(123.18,44.59) v2(123.18,34.84) v2(123.18,33.31) v2(123.18,31.79) v2(123.58,133.19) v2(123.58,131.63) v2(123.92,106.8) v2(123.94,31.15) v2(124.03,163.83) v2(124.16,165.06) v2(124.44,133.19) v2(124.44,131.63) v2(124.63,152.59) v2(124.61,105.26) v2(124.73,106.84) v2(124.86,99.99) v2(124.93,95.16) v2(125.25,101.89) v2(125.31,133.19) v2(125.31,131.63) v2(125.32,83.34) v2(125.3,82.02) v2(125.32,80.72) v2(125.32,79.49) v2(125.97,165.1) v2(126.14,130.81) v2(126.14,130.22) v2(126.14,129.64) v2(126.19,136.7) v2(126.45,105.26) v2(126.74,132.65) v2(126.74,132.07) v2(126.74,131.48) v2(126.73,130.81) v2(126.73,130.22) v2(126.73,129.64) v2(126.71,99.99) v2(126.71,95.16) v2(126.67,47.12) v2(126.67,45.85) v2(126.67,44.58) v2(126.79,34.32) v2(126.79,33.05) v2(126.79,31.78) v2(126.93,0.45) v2(126.95,152.55) v2(126.96,149.57) v2(127.09,106.85) v2(127.09,105.26) v2(127.33,132.65) v2(127.33,132.07) v2(127.33,131.48) v2(127.31,130.81) v2(127.31,130.22) v2(127.31,129.64) v2(127.31,129.06) v2(127.31,128.47) v2(127.31,127.89) v2(127.33,127.23) v2(127.33,126.6) v2(127.33,125.96) v2(127.33,125.33) v2(127.34,99.99) v2(127.34,95.16) v2(127.54,151.89) v2(127.54,151.31) v2(127.54,150.75) v2(127.54,150.16) v2(127.52,149.57) v2(127.47,101.89) v2(127.83,172.41) v2(127.78,82.8) v2(127.94,132.05) v2(127.94,131.46) v2(127.95,130.8) v2(127.95,130.21) v2(127.95,129.63) v2(127.95,129.04) v2(127.95,128.46) v2(127.96,127.87) v2(127.96,127.23) v2(127.96,126.6) v2(127.96,125.96) v2(127.96,125.33) v2(128.17,47.43) v2(128.17,45.53) v2(128.17,34.63) v2(128.17,32.73) v2(128.66,106.84) v2(128.74,81.06) v2(128.86,105.26) v2(129.11,120.23) v2(129.11,119.59) v2(129.06,101.89) v2(129.12,99.99) v2(129.12,95.16) v2(129.44,106.84) v2(129.5,105.26) v2(129.62,79.57) v2(129.74,120.23) v2(129.74,119.59) v2(129.75,99.99) v2(129.75,95.16) v2(129.99,134.31) v2(130.03,47.13) v2(130.03,45.86) v2(130.03,44.59) v2(129.96,34.33) v2(129.96,33.06) v2(129.96,31.79) v2(130.34,82.44) v2(130.84,133.16) v2(130.84,132.38) v2(130.84,131.6) v2(130.96,134.31) v2(131,106.84) v2(131.21,101.89) v2(131.28,105.26) v2(131.53,99.99) v2(131.53,95.16) v2(131.71,133.16) v2(131.71,131.6) v2(131.69,81.09) v2(131.81,106.85) v2(131.91,105.26) v2(131.97,167.66) v2(131.99,47.2) v2(131.99,45.93) v2(131.99,44.66) v2(131.99,34.4) v2(131.99,33.13) v2(131.99,31.86) v2(132.13,95.16) v2(132.17,99.99) v2(132.44,164.51) v2(132.55,101.89) v2(132.57,133.16) v2(132.57,131.6) v2(132.99,79.79) v2(133.44,133.16) v2(133.44,131.6) v2(133.41,106.85) v2(133.69,105.26) v2(133.75,82.78) v2(133.84,46.24) v2(133.84,44.34) v2(133.84,33.44) v2(133.84,31.54) v2(133.94,99.99) v2(133.92,95.16) v2(134.14,106.86) v2(134.31,136.7) v2(134.27,130.78) v2(134.27,130.2) v2(134.27,129.61) v2(134.33,104.75) v2(134.33,104.17) v2(134.52,95.16) v2(134.55,0.45) v2(134.71,97.38) v2(134.87,132.62) v2(134.87,132.04) v2(134.87,131.46) v2(134.86,130.78) v2(134.86,130.2) v2(134.86,129.61) v2(134.86,129.03) v2(134.86,128.45) v2(134.86,127.86) v2(135.03,81.53) v2(135.44,130.78) v2(135.44,130.2) v2(135.44,129.61) v2(135.44,129.03) v2(135.44,128.45) v2(135.44,127.86) v2(135.45,132.62) v2(135.45,132.04) v2(135.45,131.46) v2(135.6,97.38) v2(135.67,47.13) v2(135.67,45.86) v2(135.67,44.59) v2(135.67,34.33) v2(135.67,33.06) v2(135.67,31.79) v2(135.78,127.3) v2(135.78,126.66) v2(136.08,132.02) v2(136.07,131.43) v2(136.08,130.77) v2(136.08,130.19) v2(136.08,129.6) v2(136.08,129.02) v2(136.08,128.43) v2(136.09,127.84) v2(136.41,127.3) v2(136.41,126.66) v2(136.36,95.16) v2(136.48,80.11) v2(136.64,142.76) v2(136.71,82.96) v2(136.79,112.99) v2(136.92,114.26) v2(136.93,102.97) v2(136.93,102.39) v2(137.51,47.2) v2(137.51,45.93) v2(137.51,44.66) v2(137.51,34.4) v2(137.51,33.13) v2(137.51,31.86) v2(138.2,113.14) v2(138.52,165.56) v2(138.51,134.26) v2(139.07,173.73) v2(139.16,165.56) v2(139.23,82.96) v2(139.36,133.11) v2(139.36,132.33) v2(139.36,131.55) v2(139.35,47.51) v2(139.35,45.61) v2(139.35,34.71) v2(139.35,32.81) v2(139.48,134.26) v2(139.52,120.04) v2(139.52,119.4) v2(139.77,165.56) v2(140.03,120.36) v2(140.03,119.72) v2(140.23,133.11) v2(140.23,131.55) v2(141.09,133.11) v2(141.09,131.55) v2(141.13,47.13) v2(141.13,45.86) v2(141.13,34.33) v2(141.13,33.06) v2(141.44,75.67) v2(141.44,75.08) v2(141.44,74.12) v2(141.44,73.53) v2(141.45,70.52) v2(141.45,69.94) v2(141.45,69.35) v2(141.45,68.77) v2(141.96,133.11) v2(141.96,131.55) v2(142.19,177.35) v2(142.24,172.45) v2(142.17,0.45) v2(142.44,127.23) v2(142.44,126.6) v2(142.44,125.96) v2(142.44,125.33) v2(142.79,162.48) v2(142.82,136.63) v2(142.79,130.73) v2(142.79,130.15) v2(142.79,129.56) v2(142.79,128.98) v2(142.79,128.4) v2(142.79,127.81) v2(143.09,161.86) v2(143.08,125.96) v2(143.08,125.33) v2(143.41,142.58) v2(143.39,132.57) v2(143.39,131.99) v2(143.39,131.41) v2(143.38,130.73) v2(143.38,130.15) v2(143.38,129.56) v2(143.38,128.98) v2(143.38,128.4) v2(143.38,127.81) v2(143.52,146.2) v2(143.48,47.13) v2(143.48,45.86) v2(143.48,44.59) v2(143.48,34.33) v2(143.48,33.06) v2(143.48,31.79) v2(143.64,161.39) v2(143.71,125.96) v2(143.98,131.99) v2(143.98,131.41) v2(143.96,130.73) v2(143.96,130.15) v2(143.96,129.56) v2(143.96,128.98) v2(143.96,128.4) v2(143.96,127.81) v2(143.97,127.17) v2(143.97,126.54) v2(144.96,153.9) v2(145.05,88.42) v2(145.07,46.18) v2(145.07,44.27) v2(145.07,33.38) v2(145.07,31.47) v2(145.43,100.04) v2(145.74,42.97) v2(145.94,119.87) v2(145.94,119.23) v2(145.86,97.04) v2(145.95,95.59) v2(146.13,73.56) v2(146.33,88.43) v2(146.44,166.19) v2(146.44,120.19) v2(146.44,119.55) v2(146.45,85.56) v2(146.38,64.98) v2(146.48,134.28) v2(146.52,94.08) v2(146.57,165.04) v2(146.57,164.43) v2(146.9,159.09) v2(147.04,47.13) v2(147.04,45.86) v2(147.04,44.59) v2(147.06,166.21) v2(147.08,164.74) v2(147.08,99.66) v2(147.17,34.33) v2(147.17,33.06) v2(147.17,31.79) v2(147.33,133.14) v2(147.33,132.36) v2(147.33,131.57) v2(147.43,163.05) v2(147.44,134.28) v2(147.59,88.42) v2(147.82,172.1) v2(147.78,85.62) v2(147.91,97.88) v2(147.91,96.67) v2(148.2,159.09) v2(148.2,158.44) v2(148.16,146.88) v2(148.19,133.14) v2(148.19,131.57) v2(148.16,110.09) v2(148.21,92.61) v2(148.3,94.4) v2(148.29,60.48) v2(148.82,173.84) v2(148.82,170.36) v2(148.79,146.88) v2(148.99,111.72) v2(148.96,60.47) v2(149.06,133.14) v2(149.06,131.57) v2(149.24,174.45) v2(149.21,163.05) v2(149.5,157.14) v2(149.5,156.49) v2(149.79,0.45) v2(149.92,133.14) v2(149.92,131.57) v2(150.15,157.14) v2(150.15,156.49) v2(150.19,112.76) v2(150.32,127.23) v2(150.32,126.6) v2(150.32,125.96) v2(150.32,125.33) v2(150.32,124.69) v2(150.83,173.84) v2(150.83,170.36) v2(150.8,153.24) v2(150.76,136.57) v2(150.76,130.76) v2(150.76,130.17) v2(150.76,129.59) v2(150.76,129) v2(150.76,128.42) v2(150.76,127.84) v2(150.97,125.97) v2(150.95,125.33) v2(150.95,124.69) v2(151.34,130.76) v2(151.34,130.17) v2(151.34,129.59) v2(151.34,129) v2(151.34,128.42) v2(151.34,127.84) v2(151.45,153.89) v2(151.44,152.59) v2(151.4,136.57) v2(151.35,132.6) v2(151.35,132.01) v2(151.35,131.43) v2(151.71,127.23) v2(151.83,172.1) v2(151.84,126.09) v2(151.84,125.46) v2(151.94,132.6) v2(151.94,132.01) v2(151.94,131.43) v2(151.93,130.76) v2(151.93,130.17) v2(151.93,129.59) v2(151.93,129) v2(151.93,128.42) v2(151.93,127.84) v2(152.03,112.76) v2(152.1,151.93) v2(152.48,126.09) v2(152.48,125.46) v2(152.48,124.82) v2(152.75,155.84) v2(152.75,151.96) v2(152.75,157.81) v2(152.95,163.19) v2(153.11,124.82) v2(153.39,153.91) v2(153.73,125.74) v2(154.7,127.85) v2(154.81,164.97) v2(154.81,163.18) v2(154.94,126.8) v2(155.46,39.39) v2(155.46,37.55) v2(155.46,35.77) v2(155.63,43) v2(155.74,126.8) v2(155.84,120.42) v2(155.84,119.79) v2(155.97,42.53) v2(155.97,40.09) v2(156.2,43.16) v2(156.44,7.3) v2(156.54,126.8) v2(156.54,125.74) v2(156.48,120.42) v2(156.48,119.79) v2(156.67,34) v2(156.8,136.49) v2(156.8,108.53) v2(156.8,106.35) v2(156.8,104.16) v2(156.86,52.37) v2(156.92,37.36) v2(157.05,150.14) v2(157.11,62.29) v2(157.11,35.59) v2(157.45,9.04) v2(157.45,5.56) v2(157.62,163.41) v2(157.56,149.82) v2(157.62,74.48) v2(157.56,62.83) v2(157.68,126.85) v2(157.68,126.22) v2(157.68,125.56) v2(157.84,159.13) v2(158.07,110.72) v2(158.07,108.53) v2(158.07,106.35) v2(158.63,76.22) v2(158.63,72.74) v2(158.7,32.98) v2(158.7,31.9) v2(159.34,108.53) v2(159.34,106.35) v2(159.34,104.16) v2(159.45,9.04) v2(159.45,5.56) v2(159.64,30.62) v2(159.64,29.99) v2(160.05,52.83) v2(160.46,7.3) v2(160.63,76.22) v2(160.63,72.74) v2(160.77,163.73) v2(160.95,151.26) v2(161.11,50.15) v2(161.11,47.45) v2(161.12,45.01) v2(161.13,42.68) v2(161.1,40.48) v2(161.13,38.06) v2(161.11,36.04) v2(161.11,32.98) v2(161.16,51.4) v2(161.43,152.42) v2(161.37,53.32) v2(161.64,74.48) v2(161.74,39.47) v2(161.67,37.09) v2(161.69,17.93) v2(161.95,152.16) v2(162.07,152.93) v2(162.26,37.19) v2(162.46,171.75) v2(162.51,4.66) v2(163.15,32.54) v2(163.14,31.91) v2(163.15,17.93) v2(163.15,17.32) v2(163.4,49.35) v2(163.36,45.15) v2(163.4,44.24) v2(163.42,34.96) v2(163.65,34.32) v2(163.91,23.71) v2(164.33,50.75) v2(164.26,32.58) v2(164.41,48.93) v2(164.43,47.92) v2(164.56,97.84) v2(164.85,95.38) v2(164.91,96.55) v2(165.01,99.3) v2(164.99,0.45) v2(165.17,36.16) v2(165.34,101.63) v2(165.29,51.52) v2(165.27,32.94) v2(165.28,31.86) v2(165.37,100.49) v2(165.39,50.07) v2(165.39,47.92) v2(165.57,46.29) v2(165.82,102.95) v2(166,126.64) v2(166,124.74) v2(166,122.77) v2(166,120.93) v2(166.19,40.61) v2(166.26,118.64) v2(166.3,38.2) v2(166.42,172.1) v2(166.4,97.85) v2(166.45,47.93) v2(166.38,37.03) v2(166.38,36.39) v2(166.37,35.57) v2(166.38,34.73) v2(166.61,43.94) v2(166.67,96.57) v2(166.65,95.39) v2(166.7,42.86) v2(166.9,99.3) v2(167.04,94.02) v2(167.12,101.71) v2(167.17,100.5) v2(167.24,52.94) v2(167.19,45.32) v2(167.35,103.49) v2(167.42,173.84) v2(167.42,170.36) v2(167.42,46.33) v2(167.53,48.81) v2(167.51,48.06) v2(167.45,37.62) v2(168.23,94.02) v2(168.29,97.8) v2(168.47,95.38) v2(168.58,162.43) v2(168.67,154.27) v2(168.73,36.89) v2(168.77,34.6) v2(169.31,154.27) v2(169.43,173.84) v2(169.43,170.36) v2(169.56,94.02) v2(169.74,48) v2(169.74,34.07) v2(169.76,50.27) v2(169.76,49.57) v2(169.76,48.63) v2(169.94,154.29) v2(170.43,172.1) v2(171.35,19.48) v2(172.11,46.31) v2(172.14,36.92) v2(172.14,35.39) v2(172.61,0.45) v2(172.85,17.99) v2(173.18,47.01) v2(173.25,37.62) v2(173.22,36.91) v2(173.18,34.63) v2(173.67,159.82) v2(174.35,19.48) v2(174.4,51.52) v2(174.49,168.33) v2(174.6,35.39) v2(174.71,47.86) v2(175.46,33.88) v2(175.65,36.99) v2(175.72,40.5) v2(175.71,36.16) v2(175.79,39.4) v2(175.97,87.91) v2(176.16,95.15) v2(176.35,87.4) v2(176.73,121.56) v2(176.73,120.93) v2(176.73,119.59) v2(177.4,114.46) v2(177.54,35.45) v2(177.55,36.14) v2(177.83,80.57) v2(177.88,79.92) v2(177.89,40.46) v2(177.91,37.19) v2(178.18,139.36) v2(178.55,79.9) v2(178.98,158.46) v2(179.29,49.22) v2(179.63,79.2) v2(180.23,0.45) v2(180.59,154.16) v2(180.67,155.33) v2(180.69,53.11) v2(180.94,158.11) v2(181.24,118.96) v2(181.3,53.12) v2(181.45,84.17) v2(181.77,153.34) v2(182.1,94.65) v2(182.1,90.45) v2(182.1,86.25) v2(182.26,118.13) v2(182.25,92.5) v2(182.38,31) v2(182.73,138.01) v2(182.91,157.09) v2(182.95,117.12) v2(182.9,94.05) v2(182.9,91.95) v2(182.9,89.85) v2(183.27,151.84) v2(183.43,159.16) v2(183.5,93.95) v2(183.5,91.85) v2(183.5,89.75) v2(183.96,118.2) v2(184.16,60.29) v2(184.76,153.34) v2(184.93,118.35) v2(185.81,158.4) v2(186.4,85.65) v2(186.62,83.56) v2(187.02,113.6) v2(187.02,84.23) v2(187.1,110.85) v2(187.1,84.85) v2(187.1,82.1) v2(187.2,16.38) v2(187.7,105.9) v2(187.7,103.8) v2(187.7,102.4) v2(187.7,101) v2(187.7,99.6) v2(187.7,98.9) v2(187.7,97.5) v2(187.7,96.1) v2(187.7,95.4) v2(187.7,94) v2(187.7,92.6) v2(187.7,91.2) v2(187.7,89.8) v2(187.7,89.1) v2(187.78,16.38) v2(187.85,0.45) v2(188.42,168.3) v2(188.4,85.55) v2(188.37,16.38) v2(188.65,118.26) v2(188.66,157.82) v2(188.93,62.64) v2(189.1,105.9) v2(189.1,99.6) v2(189.1,98.9) v2(189.1,97.5) v2(189.1,94) v2(189.1,92.6) v2(189.1,84.95) v2(189.1,84.25) v2(189.69,67.4) v2(189.69,63.84) v2(190.01,47.48) v2(190.01,46.9) v2(190.01,45.83) v2(190.01,45.25) v2(190.01,44.06) v2(190.01,43.47) v2(190.07,157.5) v2(190.07,73.99) v2(190.07,73.29) v2(190.07,69.94) v2(190.24,117.61) v2(190.32,67.4) v2(190.32,63.84) v2(190.5,99.6) v2(190.5,98.9) v2(190.62,85.6) v2(191.04,82.65) v2(191.02,81.33) v2(190.99,80.76) v2(190.96,67.4) v2(190.96,63.84) v2(191.2,84.25) v2(191.3,84.85) v2(191.9,101) v2(192.04,58.19) v2(192.7,84.92) v2(192.71,83.53) v2(193.12,80.78) v2(193.22,82.71) v2(193.24,58.19) v2(193.31,176.36) v2(193.3,102.4) v2(193.3,101) v2(193.63,75.65) v2(193.73,76.24) v2(194.27,75.59) v2(194.51,58.19) v2(194.88,15.64) v2(195.01,15.05) v2(195.15,85.11) v2(195.23,80.76) v2(195.26,81.34) v2(195.5,91.2) v2(195.45,14.67) v2(195.47,0.45) v2(195.72,116.31) v2(195.72,58.19) v2(195.91,173.06) v2(196.1,95.45) v2(196.5,79.2) v2(196.85,163.46) v2(196.91,82.16) v2(197.04,80.84) v2(196.99,58.19) v2(197.44,168.68) v2(197.38,161.69) v2(197.35,81.33) v2(197.54,83.5) v2(198.13,58.19) v2(198.44,67.46) v2(198.38,63.84) v2(198.6,146.87) v2(199,85.65) v2(199,84.95) v2(199,82.85) v2(199.02,67.46) v2(198.96,63.84) v2(199.21,56.6) v2(199.34,58.19) v2(199.39,31.87) v2(199.39,30.52) v2(199.47,150.79) v2(199.47,149.37) v2(199.47,147.94) v2(199.54,63.84) v2(199.53,56.09) v2(199.58,84.97) v2(199.6,81.45) v2(199.61,67.46) v2(199.73,48.21) v2(199.73,47.58) v2(199.73,46.94) v2(199.73,46.31) v2(199.73,45.67) v2(199.73,45.09) v2(199.73,44.5) v2(199.73,43.9) v2(199.73,43.31) v2(199.73,42.73) v2(199.73,42.12) v2(199.73,41.53) v2(199.73,40.95) v2(199.73,40.34) v2(199.73,39.75) v2(199.73,39.17) v2(199.73,38.56) v2(199.73,37.98) v2(199.73,37.39) v2(199.85,56.6) v2(200.13,63.84) v2(200.17,56.09) v2(200.29,48.47) v2(200.31,47.83) v2(200.31,47.2) v2(200.31,46.56) v2(200.31,45.93) v2(200.31,45.34) v2(200.31,44.76) v2(200.31,44.15) v2(200.31,43.56) v2(200.31,42.98) v2(200.31,42.37) v2(200.31,41.79) v2(200.31,41.2) v2(200.31,40.59) v2(200.31,40.01) v2(200.31,39.42) v2(200.31,38.82) v2(200.31,38.23) v2(200.31,37.63) v2(200.31,37.04) v2(200.4,101) v2(200.55,58.19) v2(200.74,31.87) v2(200.74,30.52) v2(200.89,150.79) v2(200.89,149.37) v2(200.89,147.94) v2(200.88,48.15) v2(200.88,47.51) v2(200.88,46.88) v2(200.88,46.24) v2(200.88,45.61) v2(200.88,45.03) v2(200.88,44.44) v2(200.88,43.83) v2(200.88,43.25) v2(200.88,42.66) v2(200.88,42.05) v2(200.88,41.47) v2(200.88,40.89) v2(200.88,40.28) v2(200.88,39.69) v2(200.88,39.11) v2(200.88,38.5) v2(200.88,37.91) v2(200.88,37.33) v2(201.14,110.88) v2(201.1,82.75) v2(201.2,85.45) v2(201.44,48.54) v2(201.45,47.9) v2(201.45,47.26) v2(201.45,46.63) v2(201.45,45.99) v2(201.45,45.36) v2(201.45,44.77) v2(201.45,44.19) v2(201.45,43.58) v2(201.45,42.99) v2(201.45,42.41) v2(201.45,41.8) v2(201.45,41.22) v2(201.45,40.63) v2(201.45,40.02) v2(201.45,39.44) v2(201.45,38.85) v2(201.45,38.24) v2(201.45,37.66) v2(201.45,37.08) v2(201.44,4.72) v2(201.69,110.14) v2(201.7,84.25) v2(201.7,81.45) v2(201.75,58.19) v2(201.94,159.22) v2(202.01,48.16) v2(202.02,47.51) v2(202.01,46.89) v2(202.02,46.24) v2(202.02,45.61) v2(202.02,45.03) v2(202.02,44.44) v2(202.02,43.83) v2(202.02,43.25) v2(202.02,42.66) v2(202.02,42.05) v2(202.02,41.47) v2(202.02,40.89) v2(202.02,40.28) v2(202.02,39.69) v2(202.02,39.11) v2(202.02,38.5) v2(202.02,37.91) v2(202.02,37.32) v2(202.1,118.85) v2(202.32,150.79) v2(202.32,149.37) v2(202.32,147.94) v2(202.26,120.74) v2(202.59,47.9) v2(202.59,47.26) v2(202.59,46.63) v2(202.59,45.99) v2(202.59,45.36) v2(202.59,44.77) v2(202.59,44.19) v2(202.59,43.58) v2(202.59,42.99) v2(202.59,42.41) v2(202.59,41.8) v2(202.59,41.22) v2(202.59,40.63) v2(202.59,40.02) v2(202.59,39.44) v2(202.59,38.85) v2(202.59,38.24) v2(202.59,37.66) v2(202.59,37.08) v2(202.77,158.33) v2(202.9,58.19) v2(203.09,0.45) v2(203.18,147.11) v2(203.17,82.79) v2(203.26,83.98) v2(203.64,70.26) v2(203.55,4.72) v2(203.66,69.37) v2(203.66,68.48) v2(203.8,83.55) v2(204.04,56.98) v2(204.1,159.28) v2(204.1,58.19) v2(204.17,120.55) v2(204.2,118.71) v2(204.36,56.48) v2(204.61,168.68) v2(204.6,105.9) v2(204.6,105.2) v2(204.6,103.8) v2(204.6,102.4) v2(204.6,101) v2(204.6,99.6) v2(204.6,98.9) v2(204.6,97.5) v2(204.6,96.1) v2(204.6,95.4) v2(204.6,94) v2(204.6,91.2) v2(204.6,89.8) v2(204.6,89.1) v2(204.67,56.98) v2(204.86,15.66) v2(204.86,15.03) v2(204.99,56.48) v2(205.31,58.19) v2(205.4,82.7) v2(205.45,85.4) v2(205.75,84) v2(205.8,82.15) v2(205.89,84.91) v2(205.95,83.45) v2(206.3,117) v2(206.45,58.19) v2(207.04,9.03) v2(207.72,58.19) v2(207.66,22.33) v2(207.66,21.32) v2(208,88.35) v2(207.97,22.9) v2(207.97,21.82) v2(208.1,118.96) v2(208.07,87.76) v2(208.09,35.04) v2(208.29,22.33) v2(208.29,21.32) v2(208.4,79.2) v2(208.55,16.43) v2(208.61,22.9) v2(208.61,21.82) v2(208.68,35.04) v2(208.77,88.33) v2(208.93,58.19) v2(208.93,22.33) v2(208.93,21.32) v2(209.11,176.34) v2(209.24,23.54) v2(209.24,22.9) v2(209.24,21.82) v2(209.4,86.25) v2(209.42,35.04) v2(209.37,16.36) v2(209.48,88.36) v2(209.5,83.54) v2(209.6,168.48) v2(209.55,82.7) v2(209.59,80.92) v2(209.56,22.33) v2(209.88,79.78) v2(209.88,23.54) v2(209.88,22.9) v2(210.03,118.01) v2(210.02,81.31) v2(210.01,35.04) v2(210.14,58.19) v2(210.07,16.36) v2(210.21,133.98) v2(210.2,86.25) v2(210.2,83.55) v2(210.44,9.05) v2(210.71,0.45) v2(210.8,85.65) v2(210.88,82.08) v2(211.15,47.01) v2(211.15,46.38) v2(211.15,45.74) v2(211.15,45.16) v2(211.15,44.58) v2(211.15,43.97) v2(211.15,43.38) v2(211.15,42.8) v2(211.15,42.19) v2(211.15,41.6) v2(211.15,41.02) v2(211.15,40.41) v2(211.15,39.83) v2(211.15,39.24) v2(211.15,38.63) v2(211.15,38.05) v2(211.15,37.46) v2(211.15,36.85) v2(211.41,58.19) v2(211.53,81.43) v2(211.72,47.22) v2(211.72,46.63) v2(211.72,46) v2(211.72,45.41) v2(211.72,44.83) v2(211.72,44.22) v2(211.72,43.64) v2(211.72,43.05) v2(211.72,42.44) v2(211.72,41.86) v2(211.72,41.27) v2(211.72,40.66) v2(211.72,40.08) v2(211.72,39.5) v2(211.72,38.89) v2(211.72,38.3) v2(211.72,37.71) v2(211.72,37.11) v2(211.72,36.52) v2(212.2,82.05) v2(212.17,47.61) v2(212.29,47.01) v2(212.29,46.38) v2(212.29,45.74) v2(212.29,45.16) v2(212.29,44.58) v2(212.29,43.97) v2(212.29,43.38) v2(212.29,42.8) v2(212.29,42.19) v2(212.29,41.6) v2(212.29,41.02) v2(212.29,40.41) v2(212.29,39.83) v2(212.29,39.24) v2(212.29,38.63) v2(212.29,38.05) v2(212.29,37.46) v2(212.29,36.85) v2(212.29,36.27) v2(212.35,31.74) v2(212.35,30.4) v2(212.26,21.09) v2(212.26,19.15) v2(212.9,82.15) v2(212.86,20.12) v2(213.25,58.13) v2(213.45,21.09) v2(213.45,19.15) v2(213.6,82.15) v2(213.69,31.74) v2(213.69,30.4) v2(213.88,58.13) v2(215.03,102.09) v2(215.09,58.13) v2(215.35,85.35) v2(215.7,99.2) v2(215.72,58.13) v2(215.83,102.09) v2(215.98,28.46) v2(216.1,101.3) v2(216.4,97.2) v2(216.49,58.13) v2(216.95,102.21) v2(217.12,58.13) v2(217.45,99.25) v2(217.6,24.22) v2(217.76,58.13) v2(217.95,101.31) v2(218.2,70.38) v2(218.39,58.13) v2(218.52,69.87) v2(218.64,8) v2(218.84,70.38) v2(218.77,35.22) v2(219.03,58.13) v2(219.13,101.31) v2(219.15,69.87) v2(219.25,14.44) v2(219.36,35.22) v2(219.65,9.74) v2(219.65,6.26) v2(219.66,58.13) v2(220.11,101.75) v2(220.17,56.79) v2(220.26,58.13) v2(220.49,56.29) v2(220.8,56.79) v2(220.89,58.13) v2(220.87,49) v2(221.12,56.29) v2(221.53,58.13) v2(221.45,49) v2(221.65,9.74) v2(221.65,6.26) v2(222.16,58.13) v2(222.39,25.23) v2(222.66,8) v2(223.92,54.51) v2(223.98,61.05) v2(224.35,90.58) v2(224.61,61.05) v2(224.55,54.51) v2(224.6,18.01) v2(225.07,32.42) v2(225.25,61.05) v2(225.19,54.51) v2(225.25,37.11) v2(225.29,16.01) v2(225.74,35.51) v2(225.82,54.51) v2(225.88,61.05) v2(225.92,0.45) v2(226.8,43.22) v2(226.82,40.36) v2(226.89,41.15) v2(227.09,168.87) v2(228.11,176.05) v2(228.49,123.79) v2(228.6,39.88) v2(228.74,54.51) v2(228.8,61.05) v2(229.44,61.05) v2(229.38,54.51) v2(229.44,20.22) v2(229.47,140.08) v2(229.64,167.5) v2(230.01,54.51) v2(230.11,133.23) v2(230.07,61.05) v2(230.07,17.42) v2(230.37,16.15) v2(230.65,169.24) v2(230.65,165.76) v2(230.65,54.51) v2(230.71,61.05) v2(231.54,142.45) v2(231.66,123.85) v2(232.65,169.24) v2(232.65,165.76) v2(232.85,170.34) v2(233.17,139.48) v2(233.54,0.45) v2(233.66,167.5) v2(233.69,145.63) v2(233.82,54.44) v2(234.46,54.44) v2(234.97,21.83) v2(235.09,54.44) v2(235.6,135.91) v2(235.6,135.28) v2(235.73,54.44) v2(235.92,64.98) v2(235.92,64.35) v2(235.92,63.71) v2(235.92,63.08) v2(235.92,62.44) v2(235.92,61.81) v2(236.11,135.6) v2(236.11,134.96) v2(236.36,70.89) v2(236.36,70.26) v2(236.36,69.62) v2(236.36,68.99) v2(236.36,68.35) v2(236.36,67.72) v2(236.49,66.57) v2(236.49,65.94) v2(236.49,65.3) v2(236.49,64.67) v2(236.49,64.03) v2(236.49,63.4) v2(236.49,62.76) v2(236.49,62.13) v2(237,70.57) v2(237,69.94) v2(237,69.3) v2(237,68.67) v2(237,68.03) v2(237.06,66.89) v2(237.06,66.25) v2(237.06,65.62) v2(237.06,64.98) v2(237.06,64.35) v2(237.06,63.71) v2(237.06,63.08) v2(237.06,62.44) v2(237.06,61.81) v2(237.5,71.53) v2(237.45,16.64) v2(237.57,70.89) v2(237.57,70.26) v2(237.57,69.62) v2(237.57,68.99) v2(237.57,68.35) v2(237.63,66.57) v2(237.63,65.94) v2(238.14,71.53) v2(238.14,70.57) v2(238.14,69.94) v2(238.14,69.3) v2(238.14,68.67) v2(238.52,54.44) v2(238.71,71.21) v2(239.16,54.44) v2(239.54,152.74) v2(239.54,150.96) v2(239.79,54.44) v2(239.85,149.5) v2(239.85,148.23) v2(240.02,151.85) v2(240.43,54.44) v2(240.43,17.11) v2(240.49,152.74) v2(240.49,150.96) v2(240.93,17.55) v2(241.16,0.45) v2(243.03,55.46) v2(243.03,54.82) v2(243.4,96.28) v2(243.93,127.62) v2(243.85,106.02) v2(244.03,101.12) v2(244.04,58.95) v2(244.04,58.32) v2(244.04,57.24) v2(244.04,56.6) v2(244.08,98.89) v2(245.84,80.28) v2(247.19,165.85) v2(247.22,92.23) v2(247.22,91.59) v2(247.69,159.4) v2(247.7,151.78) v2(247.7,144.16) v2(247.7,136.54) v2(247.69,128.92) v2(247.7,121.3) v2(247.69,113.68) v2(247.71,106.06) v2(248.05,67.27) v2(248.09,53.62) v2(248.69,98.5) v2(248.78,0.45) v2(249.1,55.36) v2(249.1,51.88) v2(249.17,90.9) v2(251.1,55.36) v2(251.1,51.88) v2(252.11,53.62) v2(252.55,22.32) v2(252.55,14.7) v2(252.55,7.08) v2(253.2,62.18) v2(253.2,29.91) v2(253.82,62.8) v2(253.82,61.55) v2(254.39,85.34) v2(254.45,62.18) v2(256.24,66.64) v2(258.83,79.15) v2(260.39,71.69) v2(263.82,30.16) v2(265.62,66.15) v2(271.44,30.16) v2(273.24,66.15) v2(279.06,30.16) v2(280.85,66.14) v2(286.68,30.16) v2(287,70.65) v2(290.53,60.92) v2(291.16,63.65) v2(291.8,63.65) v2(293.19,39.52) v2(294.21,39.46) v2(294.3,30.16) v2(294.52,71.9) v2(295.09,42.99) v2(295.09,41.92) v2(295.09,40.86) v2(296.23,42.99) v2(296.23,41.92) v2(296.23,40.86) v2(296.92,39.78) v2(296.88,36.47) v2(297.83,63.52) v2(297.76,57.57) v2(298.65,36.54) v2(298.91,67.46) v2(299.1,56.75) v2(299.1,56.11) v2(299.1,55.48) v2(299.67,55.16) v2(300.3,55.16) v2(301.92,30.16) v2(302.14,71.95) v2(302.08,38.06) v2(302.72,56.24) v2(302.72,38.06) v2(304.24,45.59) v2(304.31,47.2) v2(305.96,78.53) v2(309.54,30.16) v2(310.95,62.2) v2(312.09,51.6) v2(312.09,33) v2(313.1,53.34) v2(313.1,49.86) v2(313.1,34.74) v2(313.1,31.26) v2(313.19,58) v2(314.2,59.74) v2(314.2,56.26) v2(315.1,53.34) v2(315.1,49.86) v2(315.1,34.74) v2(315.1,31.26) v2(316.11,51.6) v2(316.11,33) v2(316.2,59.74) v2(316.2,56.26) v2(316.9,83.07) v2(317,77.01) v2(317.21,58) v2(317.96,36.75) v2(319.5,83.57) v2(319.75,47.75) v3(23.26,23.7) v3(24.94,12.18) v3(58.89,55.33) v3(58.97,25.6) v3(63.54,63.41) v3(72.53,43.99) v3(73.29,27.77) v3(92.37,130.25) v3(112.47,123.89) v3(118.98,125.31) v3(144.79,129.45) v3(145.73,35.1) v3(147.58,165.52) v3(153.89,152.86) v3(157.68,151.18) v3(159.65,124.74) v3(161.03,151.9) v3(174.92,121.55) v3(189.38,68.55) v3(195.26,37.51) v3(201.54,147.5) v3(205.44,37.93) v3(209.92,21.72) v3(213.17,36.51) v3(213.95,37.41) v3(219.23,102.09) v3(229.59,58.19) v3(235.85,67.27) v3(239.55,20.19) v3(246.65,92.38)
