# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEX_TERMP: length 3.8
  BOTTOM w0.1: UG9.BL44 178.83,109.75 178.49,109.41
  BOTTOM w0.114: 178.49,109.41 177.52,109.41 v1(176.72,108.61) 176.4,108.29 RG23.2
PEX_VDD_ENP: length 327.3
  TOP w0.114: PR8217.1 188.85,52.59 189.12,52.86 v2(190.58,52.86) ; v2(173.55,166.52) 173.55,166.62 171.95,168.22 165.89,168.22 165.18,167.51 165.18,166.58 163.04,164.45 163.04,158.47 161.95,157.38 v2(161.81,157.38)
  IN2 w0.097: v2(231.09,145.12) 228.23,145.12 227.98,144.88 224.03,144.88 222.39,146.52 205.94,146.52 205.75,146.34 203.12,146.34 202.73,146.73 202.73,147.81 202.9,147.98 202.9,152.11 201.25,153.76 199.72,153.76 198.9,152.93 198.7,152.93 197.63,151.86 192.55,151.86 192.1,152.31 192.1,152.97 194.51,155.38 194.51,157 193.57,157.95 193.57,158.13 193.18,158.52 193.02,158.52 190.41,161.13 190.03,161.13 187.61,163.54 174.53,163.54 173.55,164.53 v2(173.55,166.52)
  IN5 w0.097: v2(231.09,145.12) 245.51,130.71 245.51,89.94 249.32,86.13 249.32,71.84 251.87,69.29 254.76,69.29 255.83,68.22 255.83,66.89 254.17,65.23 254.17,64.71 255.63,63.24 255.63,58.26 253.57,56.2 253.57,46.15 253.45,46.02 242.45,46.02 239.94,48.53 227.13,48.53 223.17,44.57 223.17,35.17 222.74,34.73 219.5,34.73 216.59,31.83 216.59,30.56 216.35,30.32 214.55,30.32 214.02,29.79 209.65,29.79 206.89,32.56 205.32,32.56 202.73,29.97 202.54,29.97 202.27,29.7 198.97,29.7 198.65,29.38 196.6,29.38 193.59,32.4 193.59,36.55 191.72,38.41 191.72,42.39 191.01,43.1 191.01,48.16 190.8,48.36 190.8,51.3 190.58,51.52 v2(190.58,52.86)
  BOTTOM w0.114: v1(158.51,158.71) 159.02,158.2 160.35,158.2 160.62,157.94 PR801.1
  BOTTOM w0.254: v2(161.81,157.38) 160.99,157.38 160.73,157.63 PR801.1 159.7,156.72 PR823.1 ; v2(161.81,157.38) 161.81,157.06 162.22,156.66 162.22,156.24 161.95,155.97 161.94,155.97 PC801.1 162.02,155.54 162.83,155.54 163.15,155.22 163.64,155.22 163.77,155.09 PU800.11 ; v2(161.81,157.38) 161.86,157.33 162.04,157.33 PR802.1
PI0: length 6.3
  BOTTOM w0.114: UV21.56 157.87,102.11 157.49,101.73 156.87,101.73 156.59,101.45 156.04,101.45 RV623.1 155.09,100.5 155.09,99.2 RV622.1
PLTRST_CPU#: length 152.3
  TOP w0.089: v2(102.25,109.45) 102.25,108.74 102.76,108.23 CH195.1
  IN2 w0.097: v2(173.88,57.68) 171.22,57.68 169.46,59.45 166.45,59.45 164.79,61.11 157.17,61.11 156.12,60.05 89.06,60.05 v2(88.16,60.95)
  IN4 w0.137: v2(102.25,109.45) 102.25,109.05 100.68,107.48 100.68,105.53 100.4,105.25 100.4,101.57 100.19,101.36 100.19,92.31 99.71,91.83 99.71,90.57 98.24,89.11 98.24,75.27 91.97,68.99 91.97,64.81 88.16,61.01 v2(88.16,60.95)
  BOTTOM w0.076: v2(102.25,109.45) 102.44,109.27 102.97,109.27 103.03,109.33 103.61,109.33 103.73,109.45 103.94,109.45 CPU1.BP35
  BOTTOM w0.089: 174.13,54.84 174.51,54.47 174.51,52.36 174.46,52.31 174.46,52.31 174.27,52.12 UH1.AK2
  BOTTOM w0.114: v2(173.88,57.68) 173.88,57.14 174.13,56.89 174.13,54.84
PM_SLP_S3#: length 282.7
  TOP w0.114: v2(259.28,46.38) 258.78,46.89 257.44,46.89 257.25,46.7 QE1.5 ; CE41.1 90.3,4.35 90.67,4.73 UE5.6 90.67,7.01 91.52,7.85 91.52,9.49 92.04,10.01 92.04,16.35 v2(92.56,16.88) ; v2(110.5,17.78) v3(110.5,13.52) 108.47,11.49 108.47,6.16 112.62,2 116.02,2 116.15,2.13 Q8.2
  IN1 w0.097: v2(251.92,39.46) 251.92,42.82 255.98,46.89 258.78,46.89 v2(259.28,46.38)
  IN2 w0.097: v2(92.56,16.88) 92.97,16.47 95.21,16.47 96.15,17.41 101.76,17.41 102.5,18.15 106.53,18.15 106.9,17.78 v2(110.5,17.78) 111.76,17.78 117.08,23.1 136.97,23.1 137.95,24.08 141.8,24.08 143.67,25.95 145.45,25.95 148.65,29.15 151.54,29.15 155.91,33.52 155.91,34.82 156.45,35.37 156.45,37.46 157.97,38.98 167.29,38.98 167.65,39.34 171.45,39.34 172.68,40.58 172.68,41.61 173.53,42.47 175.86,42.47 176.26,42.87 176.26,43.54 177.14,44.41 177.25,44.41 178.58,45.74 v2(178.58,46.27)
  IN2 w0.104: v2(189.65,23.88) 189.4,23.63 189.4,18.8 190.26,17.95 190.26,13.49 194.2,9.55 201.96,9.55 203.72,7.78 211.74,7.78 213.5,9.55 214.67,9.55 218.28,13.16 225.12,13.16 225.48,12.8 236.02,12.8 239.12,15.9 239.12,31.66 246.37,38.91 251.37,38.91 v2(251.92,39.46)
  IN5 w0.097: v2(178.58,46.27) 178.58,46.14 178.96,45.76 180.68,45.76 181.46,44.98 184.31,44.98 184.6,44.69 184.6,44.18 185.79,43 185.79,37.38 186.2,36.97 186.2,36.16 186.54,35.81 188.13,35.81 189.09,34.85 189.09,24.98 189.65,24.42 v2(189.65,23.88)
  BOTTOM w0.089: v2(178.58,46.27) 178.86,45.99 178.9,45.99 UH1.AW15
PM_SLP_S3_H: length 9.5
  TOP w0.114: 117.49,7.14 118.07,7.72 R307.2 ; 117.49,7.14 Q7.2 Q7.5 ; 117.49,7.14 117.74,6.88 117.74,6.25 116.87,5.37 v1(115.91,5.37) 115.83,5.37 115.5,5.04 Q8.6 115.5,3.88 115.71,3.66 115.96,3.66 116.15,3.85 Q8.5
PM_SLP_S4#: length 182.3
  TOP w0.114: v2(97.9,13.93) 97.9,13.98 97.55,14.32 97.55,17.1 98.26,17.81 98.26,19.97 97.87,20.36 UE5.73 ; Q9.2 119.1,1.84 118.78,1.52 112.42,1.52 107.99,5.96 107.99,12.06 v3(108.4,12.47) 108.85,12.93 v2(108.85,13.34)
  IN2 w0.089: 170.56,28.24 170.92,28.6 171.69,28.6 172.3,29.21 172.3,30.75 173.09,31.53 173.09,31.69 173.76,32.37 173.76,37.26 174.98,38.49 176.16,38.49 176.72,39.04 177.68,39.04 177.86,38.86 178.3,38.86 178.48,39.04 178.94,39.04 179.19,39.3 179.19,41.07 179.08,41.17 179.08,43.01 179.69,43.61 180.14,43.61 182.03,45.5 183.65,45.5 v2(184.09,45.94) ; 169.13,28.24 168.95,28.42 167.43,28.42 167.25,28.24
  IN2 w0.097: 169.13,28.24 169.18,28.19 170.51,28.19 170.56,28.24 ; v2(97.9,13.93) 97.94,13.88 97.94,13.87 98.07,13.75 102.91,13.75 103.56,13.1 108.62,13.1 v2(108.85,13.34) 109.37,13.85 113.31,13.85 116.44,16.99 116.78,16.99 118.42,18.63 138.59,18.63 139.42,19.46 142.78,19.46 144.45,21.13 148.15,21.13 150.29,23.28 151.68,23.28 152.59,24.2 153.64,24.2 156.16,26.72 163.91,26.72 165.21,28.02 167.03,28.02 167.25,28.24
  IN4 w0.137: v2(166.8,18.01) 168.54,19.75 168.54,24.56 169.45,25.46 178.76,25.46 183.58,30.28 183.58,37.22 184.23,37.87 184.23,39.01 183.15,40.09 183.15,41.24 183.79,41.88 183.79,43.46 182.83,44.42 182.83,44.68 v2(184.09,45.94)
  BOTTOM w0.089: v2(184.09,45.94) 183.52,45.37 182.19,45.37 181.96,45.6 181.76,45.6 181.51,45.85 UH1.BD15
  BOTTOM w0.114: v2(166.8,18.01) 166.74,18.07 PR1301.2
PM_SLP_S4_H: length 4.2
  TOP w0.114: v1(120.41,5.18) 120.21,4.98 119.64,4.98 R325.2 119.1,5.3 Q9.5 119.1,3.95 119.07,3.92 119.07,3.92 118.95,3.79 118.57,3.79 118.45,3.91 Q9.6
PM_SLP_S5#: length 266.5
  TOP w0.114: v2(250.46,39.46) 250.59,39.59 v3(250.59,41.92) 250.59,46.32 257.13,52.86 264.36,52.86 265.38,51.84 QE4.5 ; v2(94.61,16.85) 94.61,16.41 94.03,15.83 94.03,12.75 94.46,12.32 94.46,10.25 94.21,10 94.21,9.3 93.91,9 93.91,5.75 UE5.14 93.87,3.66 CE45.1
  IN2 w0.097: v2(179.24,47.23) 179.24,47.22 178.68,46.66 178.44,46.66 177.51,45.73 177.51,44.94 177.17,44.6 176.92,44.6 175.57,43.25 173.54,43.25 172.91,42.62 172.91,42.36 172.22,41.67 165.8,41.67 165.29,41.16 161.1,41.16 159.11,39.17 157.84,39.17 156.24,37.57 156.24,35.47 155.69,34.92 155.69,33.58 151.47,29.36 148.54,29.36 145.39,26.21 143.54,26.21 141.62,24.28 137.87,24.28 136.88,23.29 116.99,23.29 112.05,18.35 102.42,18.35 101.73,17.67 95.43,17.67 v2(94.61,16.85)
  IN2 w0.104: v2(189.78,23.31) 189.78,18.71 190.46,18.03 190.46,13.58 194.29,9.75 202.04,9.75 203.81,7.99 211.65,7.99 213.42,9.75 214.57,9.75 218.19,13.37 225.21,13.37 225.56,13.02 235.93,13.02 238.91,15.99 238.91,31.75 246.55,39.39 250.39,39.39 v2(250.46,39.46)
  IN5 w0.097: v2(189.78,23.31) 190.03,23.55 190.03,24.35 189.32,25.06 189.32,35.06 188.29,36.09 186.67,36.09 186.46,36.3 186.46,37.04 186.01,37.5 186.01,43.09 185.02,44.08 185.02,44.93 184.52,45.43 181.88,45.43 180.7,46.61 179.65,46.61 179.24,47.02 v2(179.24,47.23)
  BOTTOM w0.089: UH1.BA13 179.52,46.78 179.24,47.05 v2(179.24,47.23)
PM_SLP_SUS#: length 106
  TOP w0.114: UE5.38 101.7,9.34 100.76,10.27 100.76,12.83 100,13.59 100,13.81 100.03,13.83 100.03,16.38 v2(100.28,16.63)
  IN2 w0.097: v2(100.28,16.63) 100.63,16.98 102.17,16.98 102.94,17.75 106.36,17.75 107.11,17.01 111.55,17.01 115.52,20.98 116.38,20.98 118.1,22.7 137.55,22.7 138.31,23.46 142.08,23.46 143.98,25.36 145.55,25.36 146.95,26.76 150.14,26.76 156.08,32.7 156.49,32.7 158.06,34.28 158.06,37.71 158.78,38.42 161.47,38.42 162.07,37.82 166.57,37.82 167,38.25 171.39,38.25 173.05,39.91 173.05,40.47 173.49,40.91 174.54,40.91 174.93,41.3 175.25,41.3 176.85,42.9 176.85,43.01 177.21,43.37 177.4,43.37 177.72,43.69 177.72,43.97 v2(179.97,46.22)
  BOTTOM w0.089: UH1.BB13 180.18,46.72 179.97,46.51 v2(179.97,46.22)
  BOTTOM w0.114: v2(100.28,16.63) v1(100.28,16.09)
POK: length 152.3
  TOP w0.254: PR17.2 46.86,5.63 PR14.1 46.49,5.17 v2(46.14,5.17) ; v2(112.54,19.65) 112.16,19.65 DE2.1 111.47,20.34 DE3.1 111.47,23.59 DE4.1
  IN3 w0.254: v2(112.54,19.65) 112.54,18.76 115.72,15.57 115.72,10.68 116.47,9.93 122.06,9.93 122.51,10.37 v2(123.27,10.37)
  IN4 w0.254: v2(33.67,30.02) 33.79,29.89 33.79,29.25 33.41,28.87 33.41,26.59 33.79,26.22 33.79,21.01 35.1,19.7 35.1,14.17 35.64,13.63 47.45,13.63 48.65,12.43 48.65,10.5 45.99,7.83 45.99,5.49 46.14,5.33 v2(46.14,5.17)
  IN5 w0.254: v2(46.14,5.17) 49.61,5.17 50.05,4.72 55.74,4.72 56.85,5.84 62.72,5.84 64.29,4.27 67.14,4.27 67.72,3.7 67.72,2.11 68.75,1.08 79.91,1.08 83.11,4.28 84.74,4.28 85.8,5.34 96.26,5.34 96.28,5.37 96.61,5.37 97.3,6.06 100.63,6.06 101.32,6.75 121.93,6.75 123.14,7.96 123.14,10.25 v2(123.27,10.37)
  BOTTOM w0.114: v1(33.48,30.49) 33.48,30.2 v2(33.67,30.02)
  BOTTOM w0.203: PU100.7 34.11,29.57 v2(33.67,30.02)
POWER_LED: length 384.7
  TOP w0.114: v2(264.17,50.44) 264.73,51 QE4.6 264.73,52.01 v1(264.63,52.11) ; v2(165.24,164.5) 166.19,165.45 UE7.4 ; v2(112.56,8.71) 111.71,8.71 111.44,8.98 QE8.2 111.79,9.54 114.35,12.1 RE28.2 114.35,14.44 115.6,15.68 116.93,15.68 119.31,18.06 v2(119.31,20.09)
  IN2 w0.097: v2(157.76,89.78) 160.82,89.78 161.83,90.78 161.83,97.84 163.04,99.06 163.04,106.93 167.38,111.26 167.38,132.54 161.85,138.06 161.85,146.72 159.5,149.07 159.5,151.2 157.76,152.93 157.76,157.03 158.68,157.95 158.68,161.63 159.32,162.28 162.99,162.28 165.22,164.5 v2(165.24,164.5)
  IN3 w0.124: v2(112.56,8.71) 113.82,7.45 129.11,7.45 130.6,8.95 135.87,8.95 141.12,14.2 145.57,14.2 146.29,14.91 149.77,14.91 150.65,15.8 162.85,15.8 165.2,13.45 166.4,13.45 166.68,13.17 174.34,13.17 175.46,14.29 189.44,14.29 194.88,8.84 201.42,8.84 202.11,9.54 215.19,9.54 218.06,12.41 231.78,12.41 232.51,13.13 234.66,13.13 237.97,16.44 237.97,17.64 248.51,28.18 248.51,29.19 251.79,32.47 251.79,33.24 256.43,37.88 256.43,42.09 264.17,49.84 v2(264.17,50.44)
  IN4 w0.137: v2(119.31,20.09) 119.31,20.28 121.97,22.95 128.93,22.95 133.13,27.14 133.13,28.67 134.34,29.87 134.34,37.3 135.1,38.07 135.1,42.13 136.11,43.15 136.11,49.46 135.48,50.1 135.48,58.2 140.04,62.76 144.82,62.76 147.35,65.29 147.35,69.07 149.51,71.23 149.51,74.58 150.72,75.79 150.72,83.07 157.43,89.78 v2(157.76,89.78)
PQ703_S: length 16.3
  TOP w0.254: v2(52.97,35.77) 53.23,36.03 PR734.1
  IN2 w0.254: v2(52.97,35.77) 53.91,35.77 54.29,35.39 54.29,31.18 56.06,29.41 60.12,29.41 v2(62.41,27.12)
  vias: v1(61.88,23.02) v2(62.41,26.49) v2(62.41,25.85) v2(62.41,25.22) v2(62.41,24.59) v2(62.41,23.93) v2(62.41,23.32) v2(62.41,22.69) v2(62.41,22.09) v2(62.41,21.49) v2(62.94,27.44) v2(62.94,26.8) v2(62.94,26.17) v2(62.94,25.53) v2(62.94,24.31) v2(62.98,24.9) v2(62.95,23.7) v2(62.95,23.07) v2(62.95,22.43) v2(62.95,21.8)
PROC_DETECT#: length 205.5
  IN2 w0.097: v2(169.57,30.5) 168.74,31.33 165.11,31.33 164.8,31.01 161.49,31.01 160.07,29.59 155.73,29.59 152.99,26.85 152.26,26.85 150.61,25.2 147.68,25.2 145.57,23.09 143.85,23.09 142.26,21.49 138.37,21.49 138.04,21.16 118.26,21.16 116.07,18.97 114.35,18.97 111.79,16.4 102.86,16.4 102.16,15.71 97.23,15.71 v2(97.04,15.9)
  IN5 w0.097: v2(96.53,108.95) 97.04,108.44 97.04,106.41 96.79,106.15 96.79,105.58 97.38,104.99 97.38,94.8 93.83,91.26 93.83,83.84 86.27,76.27 86.27,59.88 80.63,54.25 80.63,48.39 78.11,45.87 78.11,27.71 79.29,26.53 79.29,25.92 79.41,25.8 82.31,25.8 84.76,28.25 89.98,28.25 90.91,27.32 93.26,27.32 94.13,26.45 97.75,26.45 98.39,25.81 98.39,22.54 97.04,21.19 v2(97.04,15.9)
  BOTTOM w0.089: UH1.Y44 169.29,30.78 v2(169.57,30.5)
  BOTTOM w0.114: RH519.1 96.88,109.3 v2(96.53,108.95) ; v2(97.04,15.9) v1(97.04,16.51)
PS_ID: length 223
  TOP w0.114: v2(224.58,14.57) 224.58,14.3 v3(224.27,13.99) 224.02,13.75 215.37,13.75 214.87,13.25 214.87,11.39 214.06,10.58 180.63,10.58 179.88,11.33 178.79,11.33 177.86,12.26 v2(177.86,12.59) ; UE5.16 94.67,6.69 94.49,6.87 94.49,8.96 95.09,9.57 95.09,10.11 94.68,10.52 94.68,12.79 94.31,13.16 94.31,14.94 94.63,15.26 v2(94.63,15.67)
  TOP w0.254: v2(284.75,41.13) 285.15,40.73 PR3.1 PR4.2
  IN1 w0.097: v2(94.63,15.67) 95.24,16.28 98.57,16.28 99.65,17.36 110.64,17.36 111.34,18.06 130.02,18.06 131.48,19.51 154.3,19.51 156.41,17.4 159.03,17.4 160.41,16.03 162.48,16.03 163.05,15.45 163.06,15.45 163.28,15.23 163.74,15.23 164.94,14.02 165.28,14.02 166.83,12.47 176.02,12.47 176.26,12.23 177.51,12.23 v2(177.86,12.59)
  IN4 w0.137: v2(224.58,14.57) 225.23,13.92 231.55,13.92 251.8,34.16 264.92,34.16 265.83,35.08 273.64,35.08 278.08,39.52 283.14,39.52 v2(284.75,41.13)
PSID: length 7.4
  BOTTOM w0.254: PL2.2 23.88,47.89 24.11,48.12 v1(24.33,48.12) 24.45,48.12 24.74,48.41 26.87,48.41 27.16,48.7 PJPDC1.2
PSID-1: length 4.3
  TOP w0.114: PQ2.2 281.07,38.39 280.04,37.35 v1(280.04,36.79)
  TOP w0.254: PR6.1 279.96,38.99 PR9.2 280.53,38.99 PQ2.2
PSID-2: length 5
  TOP w0.114: v1(282.68,36.09) PQ2.1
  TOP w0.254: PQ2.1 283.36,38.48 PR8.2 283.96,39.16 283.84,39.28 PQ7.2
PSID-3: length 2.9
  TOP w0.114: PR4.1 v1(285.6,43.52)
  TOP w0.254: PR4.1 285.11,42.08 PQ7.3
PWM1_GT: length 25.7
  IN1 w0.254: v2(90.12,136.31) 90.37,136.06 95.26,136.06 97.48,138.28 107.31,138.28 107.66,137.93 v2(111.96,137.93)
  BOTTOM w0.114: v2(111.96,137.93) 111.79,137.93 v1(111.47,138.25)
  BOTTOM w0.203: v2(90.12,136.31) 90.12,135.55 90.25,135.42 PU500.12
  BOTTOM w0.254: PR590.1 v2(111.96,137.93)
PWM1_VCORE: length 36.6
  IN5 w0.254: v2(128.6,138.22) 127.39,138.22 126.18,139.43 101.23,139.43 v2(100.34,140.31)
  BOTTOM w0.203: PU500.25 96.91,135.42 97.92,136.43 97.92,137.89 v1(99.85,139.82) v2(100.34,140.31)
  BOTTOM w0.254: PR552.1 128.82,138 v2(128.6,138.22)
PWM2_GT: length 33.1
  IN1 w0.254: v2(90.82,136.63) 95.26,136.63 97.48,138.85 107.44,138.85 107.71,138.58 112.11,138.58 112.98,137.71 116.22,137.71 116.47,137.97 119.58,137.97 v2(119.77,138.16)
  BOTTOM w0.203: v2(90.82,136.63) 90.9,136.71 91.18,136.71 91.33,136.57 PU500.13
  BOTTOM w0.254: v2(119.77,138.16) 120.06,138.44 v1(120.19,138.44) 120.73,138.44 PR591.1
PWM2_VCORE: length 44.1
  TOP w0.114: v2(136.92,137.69) 137.32,137.69 v1(137.43,137.58)
  IN1 w0.254: v2(136.92,137.69) 136.82,137.58 116.66,137.58 116.41,137.33 97.99,137.33 97.42,136.76 97.42,135.36 v2(97.55,135.24)
  BOTTOM w0.203: PU500.26 96.95,135.02 97.04,135.11 97.42,135.11 v2(97.55,135.24)
  BOTTOM w0.254: PR563.1 137.13,137.9 v2(136.92,137.69)
PWM3_VCORE: length 51.1
  IN1 w0.254: v2(145.05,137.8) 143.93,137.8 143.33,137.2 116.98,137.2 116.73,136.95 101.61,136.95 99.64,134.98 v2(98.18,134.98)
  BOTTOM w0.114: v2(145.05,137.8) v1(144.65,138.2)
  BOTTOM w0.203: v2(98.18,134.98) 98.12,134.98 97.87,134.73 97.17,134.73 97.06,134.62 PU500.27
  BOTTOM w0.254: PR573.1 145.57,137.8 v2(145.05,137.8)
PWM_SA: length 67.1
  IN2 w0.254: v2(97.93,130.92) 101.14,130.92 109.53,139.31 149.46,139.31 153.94,134.83 153.94,134.07 152.86,132.99 v2(152.86,132.38)
  BOTTOM w0.114: v2(152.86,132.38) 152.86,132.63 v1(152.64,132.84)
  BOTTOM w0.203: PU500.35 97.43,131.42 v2(97.93,130.92)
  BOTTOM w0.254: PR5001.2 v2(152.86,132.38)
PWR_B#: length 15.4
  TOP w0.254: JPWR.7 170.66,156.82 169.84,156.01 168.33,156.01 167.91,156.42 165.11,156.42 163.78,155.09 163.78,154.33 164.3,153.81 RE153.1 166.08,153.81 166.71,153.18 QE13.3 v3(166.71,151.63) 166.71,151.55 166.77,151.49 166.77,150.58 RE154.2
PWR_B_7313#: length 19.8
  TOP w0.114: UE3.17 181.52,148.57 181.12,148.17 v1(180.81,148.17) 180.52,148.17 v2(180.02,148.68) ; QE13.4 167.22,154.89 v2(167.31,154.8)
  IN1 w0.097: v2(180.02,148.68) 178.76,148.68 176.29,151.15 176.29,153.46 175.08,154.66 167.45,154.66 v2(167.31,154.8)
PWR_B_EC: length 296.2
  TOP w0.114: v2(71.38,7.03) 71.35,7.06 70.57,7.06 70.44,7.18 UE6.22 ; v2(165.24,159.22) 165.05,159.03 165.05,156.87 163.4,155.22 v1(163.4,154.01) 163.4,153.76 164.67,152.49 165.81,152.49 166.06,152.73 QE13.2
  IN4 w0.137: v2(88.34,19.33) 87.6,18.58 87.6,16.39 88.8,15.19 88.8,13.82 88.7,13.71 88.7,11.37 86.52,9.19 81.29,9.19 79.55,7.45 71.79,7.45 v2(71.38,7.03)
  IN5 w0.097: v2(88.34,19.33) 86.29,21.38 83.52,21.38 82.81,20.67 77.65,20.67 76.57,21.76 75.38,22.95 75.38,47.5 77.88,50 77.88,55.53 83.64,61.3 83.64,90.89 85.11,92.36 85.11,142.97 86.68,144.54 88.78,144.54 89.49,145.25 92.51,145.25 93.48,146.21 108.27,146.21 116.22,154.16 118.9,154.16 120.25,155.51 120.25,156.32 124.18,160.25 129.58,160.25 130.04,160.71 130.66,160.71 131.17,161.21 131.17,162.24 130.84,162.57 130.84,164.4 132.18,165.75 132.18,166.46 133.82,168.1 133.82,169.15 136.56,171.89 142.62,171.89 143.37,172.64 145.83,172.64 146.23,172.24 146.23,169.75 147.29,168.68 151.5,168.68 153.61,170.79 153.61,173.04 155.46,174.9 162.67,174.9 164.55,173.01 164.55,167.91 165.24,167.22 165.24,166.23 165.73,165.74 165.73,159.71 v2(165.24,159.22)
PWR_G#: length 9.7
  TOP w0.114: RE156.2 v3(172.75,150.71)
  TOP w0.254: JPWR.5 171.66,156.54 171.11,155.99 170.33,155.99 170.27,155.93 170.27,155.93 170.12,155.78 170.12,155.06 170.65,154.53 RE155.1 171.17,154.51 171.67,154.01 172.42,154.01 172.92,153.5 172.92,152.93 QE21.3 172.93,151.99 172.82,151.87 RE156.2
PWR_G_7313#: length 12.9
  TOP w0.114: v2(174.7,155.22) 173.06,155.22 172.93,155.09 QE21.4 ; v2(179.52,149.06) v1(179.52,149.74) 179.87,150.09 UE3.16
  IN1 w0.097: v2(179.52,149.06) 178.68,149.06 176.54,151.19 176.54,153.58 174.91,155.22 v2(174.7,155.22)
PWR_G_EC: length 255.2
  TOP w0.114: QE21.2 172.28,152.63 172.01,152.36 171.46,152.36 170.83,151.73 170.32,151.73 166.32,147.72 166.32,146.83 165.78,146.3 164.77,146.3 163.84,145.37 163.84,142.79 162.79,141.74 v1(154.54,141.74) 153.7,141.74 153.43,142.01 v2(153.43,142) ; v2(64.91,6.5) 65.09,6.68 UE6.10
  IN4 w0.137: v2(81.29,26.31) 80.88,25.9 80.88,17.54 69.42,6.08 69.42,5.42 69.29,5.29 66.44,5.29 65.23,6.5 v2(64.91,6.5)
  IN5 w0.097: v2(81.29,26.31) 80.9,26.71 80.18,26.71 78.78,28.1 78.78,45.59 81.31,48.11 81.31,54.08 86.86,59.64 86.86,75.89 94.63,83.65 94.63,91.1 98.18,94.66 98.18,102.47 98.95,103.23 98.95,105.64 98.11,106.48 98.11,110.48 95.98,112.62 95.98,113.39 94.16,115.21 94.16,116.16 93.93,116.4 92.2,116.4 89.74,118.86 89.74,127.42 89.21,127.95 89.21,130.25 87.96,131.5 87.96,132.57 88.59,133.2 88.59,136.06 87.97,136.69 87.97,139.72 88.2,139.95 91.79,139.95 92.93,141.1 97.5,141.1 97.84,141.44 131.61,141.44 132.02,141.03 136.3,141.03 138.28,143.02 143.58,143.02 145.19,141.4 152.83,141.4 v2(153.43,142)
PWR_LED#: length 221.4
  TOP w0.114: UE5.92 90.27,18.89 91.52,17.64 92.84,17.64 93.46,17.02 93.46,14.5 93.12,14.16 93.12,12.33 93.49,11.96 93.49,11.04 v2(93.07,10.63) ; QE4.2 v2(265.38,50)
  IN3 w0.124: v2(93.07,10.63) 92.66,11.04 92.66,11.84 93.23,12.41 94.82,12.41 95.42,11.81 98.66,11.81 103.52,6.95 129.43,6.95 130.82,8.34 136.09,8.34 141.37,13.61 145.63,13.61 146.47,14.46 149.95,14.46 150.79,15.29 160.43,15.29 163.61,12.12 174.66,12.12 176.38,13.84 183.88,13.84 184.46,13.26 189.26,13.26 194.14,8.38 202.17,8.38 203.11,7.44 215.17,7.44 218.99,11.26 234.07,11.26 239.17,16.37 239.17,16.69 249.4,26.91 249.4,28.56 252.31,31.48 252.31,33 259.79,40.48 259.79,43.71 265.38,49.3 v2(265.38,50)
  BOTTOM w0.114: v2(93.07,10.63) v1(92.65,10.21)
PWR_R#: length 14.6
  TOP w0.114: RE157.1 175.91,154.02 v1(175.48,153.59)
  TOP w0.254: RE158.2 178.2,151.97 QE22.3 178.2,153.69 177.62,154.27 176.71,154.27 176.47,154.51 RE157.1 175.34,155.08 175.34,155.41 175.06,155.69 172.67,155.69 172.33,156.03 171.79,156.03 v2(171.68,155.92)
  IN2 w0.097: v2(171.68,155.92) 171.68,156.09 170.15,157.63 v2(170.15,159.21)
PWR_R_7313#: length 5.9
  TOP w0.114: QE22.4 178.2,154.32 179.14,153.38 179.14,152.44 179.35,152.23 v1(179.35,151.8) 179.35,151.03 179.79,150.59 UE3.15
PWR_R_EC: length 260
  TOP w0.114: QE22.2 177.55,152.69 177.3,152.44 176.72,152.44 176.03,153.12 v2(175.72,153.12) ; UE6.6 66.65,10.43 66.86,10.65 v1(66.86,11.03) v2(66.5,11.39) ; v2(152.73,142) 152.73,141.91 153.43,141.2 162.76,141.2 164.16,142.6 164.16,145.14 v2(164.86,145.84)
  IN4 w0.137: v2(164.86,145.84) 165.24,145.84 168.46,149.06 175.85,149.06 176.35,149.57 176.35,152.74 175.97,153.12 v2(175.72,153.12) ; v2(66.5,11.39) 66.92,10.97 73.64,10.97 80.41,17.74 80.41,25.57 v2(79.66,26.31)
  IN5 w0.097: v2(79.66,26.31) 79.66,26.59 78.34,27.92 78.34,45.77 80.86,48.29 80.86,54.19 86.47,59.8 86.47,76.19 94.12,83.84 94.12,91.23 97.67,94.78 97.67,110.3 89.29,118.68 89.29,127.31 88.89,127.7 88.81,127.79 88.81,130.09 87.51,131.38 87.51,132.75 88.15,133.39 88.15,135.88 87.52,136.5 87.52,140.28 89,141.76 97.56,141.76 97.74,141.94 109.48,141.94 110.66,143.12 111.41,143.12 112.89,141.64 131.73,141.64 132.11,141.26 136.21,141.26 138.19,143.24 143.64,143.24 145.25,141.63 152.35,141.63 v2(152.73,142)
PWR_SRC_ON: length 5
  TOP w0.114: QV1.3 119.29,155.65 119.45,155.5 119.45,154.65 CV15.2 RV9.2 RV12.1 119.1,151.92 v1(118.7,151.51)
PWR_VGA_CORE_BOOT1: length 0.9
  TOP w0.114: 252.63,58.61 v1(252.63,57.71)
PWR_VGA_CORE_BOOT1_1: length 1.5
  TOP w0.114: v1(248.68,59.21) 248.87,59.02 250.14,59.02
PWR_VGA_CORE_BOOT2: length 1.7
  TOP w0.114: v1(251.36,66.79) 251.77,66.79 252.71,65.85
PWR_VGA_CORE_BOOT2_1: length 0.7
  TOP w0.114: 249.96,65.89 v1(249.96,66.57)
PWR_VGA_CORE_LGATE1: length 13
  TOP w0.114: 237.33,60.5 v1(236.82,60.5)
  IN1 w1.016: 238.46,60.86 240.36,62.76 246.65,62.76 246.97,63.08 248.24,63.08 249.51,61.81
  vias: v2(237.38,59.97) v2(238.01,59.97) v2(250.7,61.62) v2(251.28,61.62)
PWR_VGA_CORE_LGATE2: length 12.7
  TOP w0.114: v1(239.54,66.13) 239.92,66.51 v2(239.92,66.76)
  IN1 w1.016: 240.17,65.68 240.17,64.67 240.96,63.88 245.51,63.88 245.98,64.35 248.93,64.35 250.08,63.21
  vias: v2(240.55,66.76) v2(250.78,62.7) v2(251.41,62.7)
PWR_VGA_CORE_PHASE1: length 9.7
  IN1 w1.016: 242.01,60.1 242.01,60.98 242.65,61.62 245.94,61.62 247.21,60.35 250.01,60.35
  vias: v1(239.79,57.47) v2(239.16,59.21) v2(239.16,58.19) v2(239.47,58.7) v2(239.79,59.21) v2(239.79,58.19) v2(240.11,58.7) v2(240.43,59.21) v2(240.43,58.19) v2(240.74,58.7) v2(241.06,59.21) v2(241.06,58.19) v2(241.38,58.7) v2(241.7,59.27) v2(241.7,58.19) v2(242.01,58.7) v2(242.33,59.27) v2(242.33,58.19) v2(250.97,60.48) v2(251.6,60.48)
PWR_VGA_CORE_PHASE2: length 6.7
  IN1 w1.016: 250.97,65.11 249.91,66.17 244.68,66.17
  vias: v1(242.81,68.15) v2(241.31,66.28) v2(241.31,65.68) v2(241.38,72.1) v2(241.95,66.28) v2(241.95,65.68) v2(242.01,72.1) v2(242.65,72.1) v2(242.58,66.28) v2(242.58,65.68) v2(243.22,66.28) v2(243.22,65.68) v2(243.28,72.1) v2(243.6,72.6) v2(243.92,73.11) v2(243.92,72.1) v2(244.24,72.6) v2(250.97,64.22) v2(251.6,64.22)
PWR_VGA_CORE_SS: length 6.7
  TOP w0.114: v1(260.62,64.35) 260.22,63.96 PC8217.1
  TOP w0.203: PU8200.11 254.62,64.07 254.78,64.22 256.38,64.22 256.42,64.27 258.79,64.27 PC8217.1
PWR_VGA_CORE_TON: length 1.8
  TOP w0.203: PU8200.9 255.92,62.58 255.98,62.51 256.88,62.51 PR8202.1
PWR_VGA_CORE_TON_1: length 4.7
  TOP w0.114: PR8201.1 258.91,62.77 259.6,63.46 260.62,63.46 v1(261.06,63.02)
  TOP w0.254: PR8201.1 PR8202.2 257.97,63.73 PC8205.1
PWR_VGA_CORE_UGATE1: length 8.7
  IN1 w1.016: 252.3,59.4 251.86,58.95 247.03,58.95 246.01,59.97 245.19,59.97 244.93,60.22
  BOTTOM w0.114: v2(244.04,59.97) 244.43,59.97 v1(244.57,60.11)
  vias: v2(243.41,59.97) v2(253.28,59.77) v2(253.28,59.13)
PWR_VGA_CORE_UGATE2: length 5.1
  IN1 w1.016: 248.43,68.29 250.2,68.29 252.55,65.94
  vias: v1(247.49,67.92) v2(246.9,68.03) v2(247.35,68.48) v2(253.38,65.24) v2(253.38,64.6)
PWRSHARE_EN_EC#: length 102.5
  TOP w0.114: v1(23.74,48.03) 23.55,48.22 v2(23.06,48.22) 23.06,48.22 UU1.5 ; UE5.119 85.9,10.94 85.72,10.76 v2(85.72,10.62)
  IN5 w0.097: v2(85.72,10.62) 82.63,10.62 81.74,11.51 72.4,11.51 70.25,9.36 66.81,9.36 65.86,10.31 63.24,10.31 62.5,11.06 50.91,11.06 50.65,10.8 41.55,10.8 39.35,13 35.35,13 34.92,13.42 34.92,17.33 32.04,20.22 32.04,33.6 31.38,34.25 31.38,34.93 32.07,35.62 32.07,41.31 30.88,42.51 30.88,46.82 29.92,47.78 29.92,48.41 29.61,48.73 27.95,48.73 27.64,48.41 23.26,48.41 v2(23.06,48.22)
REGN_CHG: length 13.8
  TOP w0.203: v2(57.67,31.67) 57.67,31.82 58.01,32.16 PU700.24
  TOP w0.254: v2(63.83,35.94) PR714.1
  IN2 w0.254: v2(57.67,31.67) 59.11,33.11 59.7,33.11 60.08,33.49 60.08,36.3 60.59,36.81 62.97,36.81 v2(63.83,35.94)
  BOTTOM w0.114: v2(57.67,31.67) v1(57.67,32.3)
  BOTTOM w0.508: v2(57.67,31.67) 57.67,31.16 PC710.1
REMOTE1+: length 107.2
  IN4 w0.254: v2(106.06,130.69) 105.96,130.58 102.74,130.58 100.07,127.91 89.72,127.91 88.98,127.17 88.98,125.54 89.36,125.16 89.36,121.39 86.76,118.79 86.76,91.29 84.41,88.94 84.41,82.15 79.43,77.18 75.24,77.18 68.28,70.21 68.28,64.77 69.23,63.82 69.23,60.37 68.78,59.92 68.78,58.83 v2(68.47,58.51)
  BOTTOM w0.254: 69.64,59.72 68.47,58.54 v2(68.47,58.51) 68.61,58.36 68.61,57.6 C2502.1 ; Q2407.2 107.73,132.82 Q2407.1 107.12,132.12 C2500.1 106.41,130.35 v2(106.06,130.69)
REMOTE1-: length 106.1
  IN4 w0.254: v2(69.17,58.13) 69.17,58.44 69.29,58.57 69.29,59.71 69.74,60.16 69.74,64.03 68.78,64.98 68.78,70 75.45,76.67 79.64,76.67 84.91,81.94 84.91,88.73 87.26,91.08 87.26,118.58 89.87,121.18 89.87,125.37 89.49,125.75 89.49,126.96 89.93,127.41 100.28,127.41 102.95,130.07 105.95,130.07 v2(106.06,129.97)
  BOTTOM w0.254: Q2407.3 108.98,131.29 C2500.2 107.32,129.63 106.38,129.63 106.06,129.94 v2(106.06,129.97) ; v2(69.17,58.13) 69.29,58 69.29,57.36 68.82,56.89 C2502.2 67.85,56.89 67.24,57.5 R368.1
REMOTE2+: length 205.5
  TOP w0.254: v2(192.8,27.77) 192.67,27.77 192.29,28.15 192.29,28.87 C2505.1 192.53,29.95 192.15,30.33 Q2408.2 192.15,31.69 Q2408.1
  IN2 w0.254: v2(67.45,58.89) 67.45,59.08 67.96,59.59 69.99,59.59 72.02,57.56 74.12,57.56 78.04,53.63 78.04,49.46 76.81,48.23 76.81,29.38 78.42,27.77 81.41,27.77 83.33,29.69 126.05,29.69 126.22,29.86 139,29.86 139.9,30.76 139.9,36.18 141.56,37.83 143.91,37.83 144.35,38.27 144.35,41.3 145.3,42.25 148.41,42.25 153.94,47.78 156.33,47.78 157.94,49.38 157.94,50.65 159.33,52.05 160.41,52.05 161.24,52.88 162.57,52.88 164.67,54.97 173.11,54.97 174.27,53.81 176.74,53.81 177.22,54.29 182.32,54.29 182.56,54.06 186.76,54.06 187.19,53.62 188.57,53.62 189.82,52.38 189.82,49.08 191.15,47.75 191.15,34.51 193.31,32.35 193.31,28.16 192.93,27.77 v2(192.8,27.77)
  BOTTOM w0.254: U2407.4 68.16,59.65 v1(67.71,59.65) 67.2,59.65 C2504.1 67.08,58.89 v2(67.45,58.89)
REMOTE2-: length 200.4
  TOP w0.254: Q2408.3 193.45,29.11 C2505.2 193.45,29.05 v2(192.8,28.41)
  IN2 w0.254: v2(68.28,59.08) 69.74,59.08 71.77,57.05 73.86,57.05 77.54,53.38 77.54,49.67 76.3,48.44 76.3,29.17 78.21,27.27 81.62,27.27 83.54,29.18 126.26,29.18 126.43,29.35 139.26,29.35 140.41,30.5 140.41,35.9 141.79,37.28 144.14,37.28 144.86,38 144.86,40.92 145.56,41.62 148.54,41.62 154.19,47.27 156.61,47.27 158.44,49.11 158.44,49.17 158.45,49.17 158.45,49.59 158.44,49.59 158.44,50.4 159.52,51.48 160.6,51.48 161.59,52.47 162.86,52.47 165.02,54.63 172.96,54.63 174.13,53.47 176.88,53.47 177.36,53.95 182.17,53.95 182.57,53.55 186.55,53.55 186.98,53.12 188.36,53.12 189.28,52.19 189.28,48.9 190.64,47.54 190.64,34.25 192.8,32.09 v2(192.8,28.41)
  BOTTOM w0.254: C2504.2 66.76,58.57 66.89,58.43 67.46,58.43 67.72,58.17 R368.2 67.95,58.24 67.95,58.75 v2(68.28,59.08) 69.27,60.07 U2407.3
REMOTE3+: length 247
  IN1 w0.254: v2(221.27,32.89) 220.87,32.49 220.87,25.23 222.39,23.71 227.64,23.71 231.64,19.71 231.64,16.53 229.3,14.19 225.21,14.19 224.8,13.79 218.25,13.79 215.23,10.77 205.2,10.77 204.23,9.79 193.85,9.79 189.06,14.58 187.2,14.58 185.39,16.39 181.99,16.39 180.08,18.3 177.58,18.3 176.93,18.95 171.04,18.95 169.16,20.83 168.75,20.83 163.16,26.41 157.66,26.41 151.95,32.12 150.13,32.12 147.87,29.86 126.28,29.86 125.52,29.1 125.11,29.1 124.85,28.85 110.52,28.85 109.51,29.86 86.68,29.86 84.4,27.58 79.47,27.58 78.83,28.23 78.83,45.73 81.52,48.42 81.52,48.98 81.65,49.11 81.65,56.05 76.46,61.24 v2(66.44,61.24)
  BOTTOM w0.254: v2(221.27,32.89) 221.27,33.28 220.87,33.68 Q2411.1 220.22,34.33 Q2411.2 220.22,36.53 C2511.1 ; U2407.5 68.03,60.22 66.82,60.22 66.5,59.91 C2510.1 66.12,60.93 v2(66.44,61.24)
REMOTE3-: length 247.2
  IN1 w0.254: v2(64.78,58.89) 66.43,60.54 76.44,60.54 81.14,55.84 81.14,49.32 81.01,49.19 81.01,48.63 78.32,45.94 78.32,28.02 79.26,27.08 84.61,27.08 86.89,29.36 109.3,29.36 110.31,28.35 125.07,28.35 125.32,28.6 125.73,28.6 126.49,29.36 148.08,29.36 150.34,31.61 151.74,31.61 157.45,25.91 162.95,25.91 168.54,20.32 168.95,20.32 170.83,18.44 176.72,18.44 177.93,17.23 180.43,17.23 181.78,15.88 185.17,15.88 186.99,14.07 188.85,14.07 193.64,9.28 204.44,9.28 205.41,10.26 215.44,10.26 218.46,13.28 225.01,13.28 225.42,13.68 229.51,13.68 232.15,16.32 232.15,19.92 227.85,24.22 222.65,24.22 221.38,25.49 221.38,32.27 221.72,32.62 221.72,33.51 v2(221.6,33.63)
  BOTTOM w0.254: C2511.2 221.52,36.66 Q2411.3 221.52,34.55 221.6,34.47 v2(221.6,33.63) ; v2(64.78,58.89) 65.11,58.89 C2510.2 R185.2
RESET_N: length 2.7
  BOTTOM w0.114: 129.36,150.77 129.62,150.52 130,150.52 130.53,149.99 RT102.1
  BOTTOM w0.127: 129.36,150.77 129.12,151.02 128.62,151.02 UT4.F11
RF_+1VALWP: length 3.1
  TOP w0.114: PR306.1 v1(213.31,22.7)
  TOP w0.254: PR306.1 214.29,22.7 214.77,22.22 214.77,21.27 214.61,21.12 PU300.5
RING2: length 21.1
  TOP w0.114: v2(21.73,38.38) v1(22.24,38.38)
  IN5 w1.016: 20.62,37.54 19.13,36.05 19.13,32.17 18.68,31.73 18.68,29.05 19.05,28.68 19.05,27.1 18.68,26.73 18.68,19.48 17.66,18.46
  vias: v2(17.16,17.51) v2(17.79,17.51) v2(21.09,38.4)
RING2_R: length 37.8
  IN3 w0.508: 16.42,18.59 16.42,14.15 14.04,11.76 4.08,11.76 3.69,12.15 JACK1.4
  IN5 w0.508: 16.27,18.52 16.27,14.01 14.02,11.76 4.09,11.76 3.69,12.16 JACK1.4
  vias: v2(16.12,19.28) v2(16.73,19.28) v3(16.21,15.45)
RJ45_CT:
  vias: v1(214.1,160.15)
RJ45_CT0: length 3.3
  BOTTOM w0.127: v1(210.12,159.03) RL12.1
  BOTTOM w0.508: RL12.1 TL1.15
RJ45_CT1: length 3.4
  BOTTOM w0.127: RL11.1 v1(213.34,159.03)
  BOTTOM w0.508: TL1.16 212.36,158.2 212.29,158.27 RL11.1
RJ45_CT2: length 2.3
  BOTTOM w0.508: TL1.21 RL10.1
RJ45_CT3: length 3.4
  BOTTOM w0.127: RL9.1 220.78,159.03 v1(220.96,159.21)
  BOTTOM w0.508: RL9.1 219.91,158.22 219.98,158.15 TL1.22
RJ45_MDI0+: length 13.5
  TOP w0.267: JLAN.1 214.78,164.24 214.45,163.92 214.45,163.22 215.07,162.6 215.07,161.71 213.15,159.79 209.63,159.79 208.93,159.09 208.93,158.39 v2(208.87,158.33)
  BOTTOM w0.267: v2(208.87,158.33) 208.93,158.27 208.93,157.82 208.55,157.44 TL1.13
RJ45_MDI0-: length 13.5
  TOP w0.267: v2(209.45,158.33) 209.45,158.39 209.31,158.53 209.31,158.93 209.79,159.41 v4(210.77,159.41) 213.31,159.41 215.45,161.55 215.45,162.76 214.83,163.37 214.83,163.76 215.25,164.17 215.51,164.17 JLAN.2
  BOTTOM w0.267: TL1.14 209.82,157.38 209.31,157.88 209.31,158.19 v2(209.45,158.33)
RJ45_MDI1+: length 10.9
  IN4 w0.216: v2(213.97,158.55) 214.12,158.71 214.12,159.49 215.25,160.62 216.42,160.62 217.48,161.67 217.48,162.99 216.82,163.65 JLAN.3
  BOTTOM w0.267: TL1.17 213.63,157.39 214.09,157.85 214.09,158.42 213.97,158.53 v2(213.97,158.55)
RJ45_MDI1-: length 10.9
  IN4 w0.216: JLAN.6 219.78,163.98 219.11,163.98 217.82,162.69 217.82,161.53 216.56,160.27 215.4,160.27 214.47,159.34 214.47,158.64 v2(214.56,158.55)
  BOTTOM w0.267: v2(214.56,158.55) 214.47,158.46 214.47,157.89 214.9,157.45 TL1.18
RJ45_MDI2+: length 9.3
  IN5 w0.229: v2(216.51,158.62) 216.63,158.73 216.63,160.41 218.51,162.29 218.51,164.05 218.38,164.18 217.97,164.18 217.84,164.05 JLAN.4
  BOTTOM w0.267: v2(216.51,158.62) 216.6,158.53 216.6,157.85 216.17,157.42 TL1.19
RJ45_MDI2-: length 9.3
  IN5 w0.229: v2(217.1,158.62) 216.98,158.73 216.98,160.27 218.86,162.14 JLAN.5
  BOTTOM w0.267: TL1.20 217.44,157.4 216.98,157.85 216.98,158.5 v2(217.1,158.62)
RJ45_MDI3+: length 8.9
  IN5 w0.229: JLAN.7 220.9,161.74 221.71,160.94 221.71,158.73 v2(221.59,158.61)
  BOTTOM w0.267: TL1.23 221.25,157.42 221.72,157.89 221.72,158.44 221.59,158.57 v2(221.59,158.61)
RJ45_MDI3-: length 8.9
  IN5 w0.229: v2(222.18,158.61) 222.06,158.73 222.06,161.09 221.31,161.84 221.31,164.11 221.44,164.24 221.79,164.24 221.92,164.11 JLAN.8
  BOTTOM w0.267: v2(222.18,158.61) 222.1,158.54 222.1,157.89 222.52,157.47 TL1.24
ROM_CS#: length 19.6
  TOP w0.114: v2(180.1,81.45) 180.1,82.51 179.72,82.89 177.5,82.89 177.18,82.57 v1(175.64,82.57) 174.07,82.57 173.37,81.88 173.37,79.13 172.3,78.07 170.13,78.07 169.69,77.62 v2(169.69,75.65)
  BOTTOM w0.114: UG16.1 169.56,76.27 RG538.2 169.58,75.75 v2(169.69,75.65) ; UG9.BJ4 v2(180.1,81.45)
ROM_SCLK: length 31.2
  IN1 w0.097: v2(171.78,78.89) 172.67,78.89 173.56,78 179.9,78 180.03,78.13 180.03,80.12 v2(179.4,80.75)
  IN5 w0.097: v2(171.78,78.89) 171.78,78.45 171.47,78.14 170.75,78.14 168.96,76.35 168.96,74.25 169.68,73.53 169.68,71.5 172.99,68.2 v2(172.99,66.64)
  BOTTOM w0.114: RG148.2 173.32,66.97 v2(172.99,66.64) ; RG86.1 RG89.2 v2(171.78,78.89) 171.22,78.89 171.03,78.7 RG75.2 ; UG9.BK3 v2(179.4,80.75)
ROM_SI: length 31.8
  IN1 w0.097: v2(171.78,76.92) 171.34,77.37 171.34,79.02 171.72,79.4 172.48,79.4 173.56,78.32 179.08,78.32 179.21,78.45 179.21,79.86 v2(179.39,80.04)
  IN5 w0.097: v2(171.78,76.92) 171.78,77.62 171.46,77.94 170.83,77.94 169.16,76.27 169.16,74.33 169.88,73.61 169.88,71.59 173.69,67.78 v2(173.69,66.64)
  BOTTOM w0.114: RG87.2 RG84.1 v2(171.78,76.92) 171.59,77.11 RG77.2 ; UG9.BK2 v2(179.39,80.04) ; v2(173.69,66.64) 173.32,66.27 RG149.2
ROM_SO: length 34.5
  TOP w0.114: v1(164.8,74.7) 164.88,74.79 v2(164.88,75.22)
  IN2 w0.097: v2(170.32,74) 170.26,74.07 170.19,74.07 169.04,75.22 v2(164.88,75.22) ; v2(179.4,81.45) 179.78,81.83 179.78,82.51 179.59,82.7 175.46,82.7 173.69,84.48 v2(173.69,85.37)
  IN4 w0.137: v2(170.32,74) 170.38,74.07 170.45,74.07 170.89,74.51 170.89,76.86 173.5,79.46 173.5,82.32 174.13,82.96 174.13,84.92 v2(173.69,85.37)
  BOTTOM w0.114: RG85.1 RG88.2 173.57,85.25 v2(173.69,85.37) ; v2(164.88,75.22) 164.92,75.18 RG539.2 ; UG9.BK4 v2(179.4,81.45) ; v2(170.32,74) 170.26,74.07 170.19,74.07 170,74.26 169.31,74.26 168.79,74.77 UG16.4
RPD_G1: length 3.7
  BOTTOM w0.076: UT4.K9 127.8,153.33 127.8,153.67 127.82,153.69 127.82,153.74 127.81,153.75
  BOTTOM w0.089: 128.57,155.03 127.81,154.28 127.81,153.75
  BOTTOM w0.114: 128.57,155.03 128.77,155.23 v1(128.9,155.23) 129.11,155.44 RT64.1
RPD_G2: length 4.2
  BOTTOM w0.076: 129.17,154.23 128.84,154.23 128.3,153.69 128.3,153.46 128.05,153.21 UT4.K10
  BOTTOM w0.114: 129.17,154.23 129.61,154.23 ; RT65.1 130.57,154.95 v1(130.27,155.26)
  BOTTOM w0.127: 129.61,154.23 129.77,154.39 130.53,154.39 RT65.1
RST#: length 3.3
  TOP w0.114: v1(70.03,10.36) RE91.2 CE55.2 68.15,10.36 UE6.3
RT8812_PVCC: length 0.9
  TOP w0.114: 248.62,63.91 v1(247.75,63.91)
RTD3_CIO_PWR_EN: length 190.5
  TOP w0.089: v2(176.81,31.82) v1(177.32,31.82)
  TOP w0.114: RT16.2 138.85,154.19 v2(138.76,154.29)
  IN5 w0.097: v2(176.81,31.82) 176.91,31.92 176.91,33.45 176.1,34.25 176.1,37.06 174.55,38.6 173.5,38.6 173.1,39.01 173.1,43.17 172.36,43.91 170.81,43.91 170.13,44.59 170.13,46.84 168.51,48.45 168.51,54.02 163.52,59.01 163.52,70.25 163.8,70.53 163.8,76.46 167.34,80.01 167.34,84.88 171.38,88.92 171.38,110.17 173.05,111.85 173.05,140.51 175.45,142.91 175.45,147.27 172.69,150.04 168.91,150.04 167.62,151.33 167.62,153.94 167.78,154.1 167.78,156.36 167.59,156.55 165.83,156.55 164.13,158.26 164.13,161.47 163.24,162.36 156.99,162.36 154.05,159.42 154.05,155.69 153.14,154.78 152.26,154.78 151.85,154.38 151.85,152.82 152.31,152.36 153.07,152.36 153.3,152.13 153.3,151.3 153.17,151.17 144.54,151.17 143.97,151.75 143.97,153.43 143.21,154.19 138.86,154.19 v2(138.76,154.29)
  BOTTOM w0.089: v2(176.81,31.82) 176.81,31.47 UH1.AR44
RTD3_CIO_PWR_EN_R: length 6.7
  TOP w0.089: UT1.F1 143.71,158.28 143.71,158.29 143.66,158.29
  TOP w0.114: RT16.1 RT36.1 140.38,155.27 140.38,155.52 140.66,155.8 141.37,155.8 v1(142.09,156.53) 142.09,156.7 142.79,157.41 142.79,157.76 143.32,158.29 143.66,158.29
RTD3_USB_PWR_EN: length 181.3
  IN5 w0.097: v2(143.65,154.33) 144.19,153.79 144.19,151.84 144.63,151.4 147.33,151.4 147.59,151.65 147.59,153.33 147.99,153.74 149.41,153.74 150.06,154.39 150.55,154.39 151.19,155.03 152.14,155.03 153.08,155.03 153.83,155.78 153.83,159.52 156.9,162.58 163.33,162.58 164.35,161.57 164.35,158.35 165.83,156.87 169.21,156.87 171.9,154.18 171.9,151.11 175.65,147.36 175.65,142.79 173.88,141.02 173.88,112.4 171.58,110.09 171.58,88.83 167.54,84.8 167.54,79.93 164.02,76.41 164.02,70.43 163.75,70.16 163.75,59.1 168.73,54.11 168.73,48.49 170.31,46.91 170.31,45.32 170.87,44.77 173.91,44.77 174.25,44.43 174.25,39.92 176.99,37.18 176.99,34.11 v2(177.58,33.51)
  BOTTOM w0.114: RT12.2 144.63,155.07 v1(144.25,154.68) 143.89,154.33 v2(143.65,154.33) ; UH1.AR41 177.02,32.95 v2(177.58,33.51)
RTD3_USB_PWR_EN_R: length 5.1
  TOP w0.102: UT1.D4 v2(145.59,159.1)
  BOTTOM w0.114: v2(145.59,159.1) 145.4,159.3 v1(145.05,159.3) 145.04,159.3 144.49,158.75 144.49,157.35 144.53,157.31 144.53,156.67 144.64,156.55 144.64,156.25 144.62,156.22 ; RT37.1 144.62,156.22 ; 144.62,156.22 RT12.1
SERIRQ: length 128.9
  TOP w0.114: UE5.3 89.47,6.73 90.87,8.13 90.87,9.76 91.02,9.91 91.02,11.55 91.62,12.14 v2(91.62,13.83)
  IN2 w0.097: v2(91.62,13.83) 92.17,14.38 93.7,14.38 94.23,14.9 97.19,14.9 97.51,15.22 102.26,15.22 103.05,16.01 111.95,16.01 114.52,18.57 116.23,18.57 118.42,20.77 138.21,20.77 138.54,21.1 142.42,21.1 144.02,22.69 147.65,22.69 149.68,24.73 150.74,24.73 152.39,26.38 153.18,26.38 155.99,29.19 162.45,29.19 162.65,29.4 168.77,29.4 168.99,29.62 170.33,29.62 170.62,29.33 171.36,29.33 171.57,29.55 171.57,37.27 172.72,38.42 173.88,38.42 175.41,39.94 176.01,39.94 176.03,39.97 178.49,39.97 178.82,40.31 178.82,40.85 178.72,40.96 178.72,43.22 179.3,43.81 179.3,44.69 v2(179.86,45.25)
  BOTTOM w0.089: 184.56,41.57 184.37,41.57 v1(183.98,41.96) 183.78,42.16 183.78,43.22 182.77,44.24 181.62,44.24 181.5,44.12 181.5,43.93 181.38,43.81 181.07,43.81 181.01,43.75 180.55,43.75 180.42,43.89 180.42,43.98 179.89,44.51 UH1.BA17 179.89,45.25 179.88,45.25 v2(179.86,45.25)
  BOTTOM w0.114: 184.56,41.57 186.26,41.57 186.7,42.02 187.54,42.02 RH111.1
SLEEVE: length 19.2
  IN5 w1.016: 19.28,37.92 17.92,36.56 17.92,34.91 16.65,33.64 16.65,27.27 15.51,26.13 15.51,23.41 16.84,22.08
  BOTTOM w0.114: v1(18.86,22.86) 18.23,22.23 RA26.2
  vias: v2(16.9,21.06) v2(17.54,21.06) v2(19.63,38.59) v2(20.27,38.59)
SLEEVE_R: length 32.9
  TOP w0.114: v3(14.17,19.65) 14.53,19.29 v2(14.89,19.29)
  IN1 w0.508: JACK1.3 6.29,12.29 6.82,11.76 13.71,11.76 14.89,12.94 14.89,16.92 15.17,17.19 15.17,18.62
  IN4 w0.508: JACK1.3 6.29,12.29 6.82,11.76 14.03,11.76 16.35,14.08 16.35,16.02 15.48,16.89 15.48,18.36
  vias: v2(15.48,19.28)
SLP_S3: length 4.8
  TOP w0.114: UE1.26 v1(259.62,44.18) 259.07,44.18 258.78,44.47 257.91,44.47 QE1.3 257.9,43.4 RE15.2
SLP_S5: length 4.3
  TOP w0.114: RE16.2 266.46,49.67 QE4.3 266.03,48.49 v1(265.79,48.25) 265.42,47.87 UE1.21
SM_PG_CTRL: length 59.7
  TOP w0.114: RH525.2 92.67,77.18 92.34,77.51 88.3,77.51 v3(87.58,76.79) 87.39,76.61 87.39,68.32 81.33,62.26 v2(81.33,61.58)
  TOP w0.127: UC1.4 94.45,76.3 93.88,75.73 93.23,75.73 RH525.2
  TOP w0.254: v2(56.6,52.02) PR211.2
  IN5 w0.097: v2(56.6,52.02) 55.57,53.04 55.57,54.91 60.7,60.03 77.91,60.03 79.46,61.58 v2(81.33,61.58)
SML0CLK: length 224.5
  TOP w0.089: RH501.2 180.54,31.88 v2(180.08,32.33)
  IN1 w0.089: v2(180.08,32.33) 179.88,32.6 179.05,32.6 178.8,32.35 176.67,32.35 176.29,31.96 174.89,31.96 173.75,33.11 173.75,37.81 172.99,38.57 172.99,42.64 172.17,43.46 170.83,43.46 168.8,45.49 168.8,49.55 168.23,50.13 166.7,50.13 166.26,50.57 165.11,50.57 164.99,50.44 164.99,47.5 164.76,47.27 163.53,47.27 162.98,47.82 160.77,47.82 160.15,47.2 159.4,47.2 159.01,46.81 158.69,46.81 158.67,46.79 158.65,46.79
  IN1 w0.097: 158.65,46.79 157.91,46.79 157.6,47.1 157.6,50.93 158.64,51.97 158.64,52.98 157.21,54.41 157.21,61.08 157.97,61.84 157.97,63.05 157.81,63.21 157.81,68.48 155.31,70.98 155.31,77.5 152.77,80.04 152.77,91.24 159.04,97.51 159.04,103.32 160,104.28 160,112.88 163.29,116.17 163.29,118.62 161.14,120.77 161.14,134.52 157.23,138.43 148.01,138.43 147.48,138.96 137.81,138.96 136.71,140.06 129.87,140.06 129.35,140.58 114.47,140.58 107.81,147.25 87.68,147.25 87.55,147.12 87.55,146.85 v2(87.73,146.67)
  BOTTOM w0.089: UH1.AY44 179.65,31.9 v2(180.08,32.33)
  BOTTOM w0.114: UM4.11 86.22,147.61 86.38,147.45 87.2,147.45 87.54,147.1 87.54,146.85 v2(87.73,146.67)
SML0DATA: length 223.8
  TOP w0.089: v2(180.19,33.02) 180.44,32.77 RH502.2
  IN1 w0.089: 158.65,47.01 158.67,47.01 158.69,46.99 158.94,46.99 159.33,47.38 160.08,47.38 160.7,47.99 163.05,47.99 163.6,47.45 164.68,47.45 164.81,47.57 164.81,50.52 165.04,50.75 166.33,50.75 166.78,50.3 168.3,50.3 168.98,49.63 168.98,45.56 170.9,43.64 172.24,43.64 173.17,42.71 173.17,38.64 173.93,37.88 173.93,33.18 174.97,32.14 176.22,32.14 176.6,32.52 178.73,32.52 178.98,32.78 179.85,32.78 v2(180.19,33.02)
  IN1 w0.097: 158.65,47.01 158.01,47.01 157.82,47.19 157.82,50.83 158.86,51.87 158.86,53.08 157.43,54.51 157.43,60.98 158.19,61.75 158.19,63.14 158.03,63.3 158.03,68.57 155.54,71.07 155.54,77.59 152.99,80.14 152.99,91.15 159.26,97.42 159.26,103.23 160.22,104.19 160.22,112.78 163.52,116.08 163.52,118.72 161.37,120.86 161.37,134.61 157.33,138.66 148.1,138.66 147.57,139.19 137.9,139.19 136.8,140.28 129.96,140.28 129.44,140.8 114.57,140.8 107.9,147.47 87.58,147.47 87.32,147.21 87.32,146.85 v2(87.14,146.67)
  BOTTOM w0.089: v2(180.19,33.02) 180.25,33.02 180.38,33.16 UH1.BB39
  BOTTOM w0.114: UM4.10 86.22,147.05 86.38,147.21 87.1,147.21 87.3,147 87.3,146.82 v2(87.14,146.67)
SML1CLK: length 13.3
  IN5 w0.089: v2(178.82,31.95) 178.86,31.22 178.74,31.09 178.5,31.07 178.3,30.87 178.3,29.19 177.49,28.39 177.49,28.31 177.44,28.27 177.44,28.24
  IN5 w0.097: 177.44,28.24 177.44,27.41 174.85,24.82 174.85,24.38 v2(174.67,24.2)
  BOTTOM w0.089: v2(178.82,31.95) 178.77,32 UH1.AW42
  BOTTOM w0.114: QH5.6 174.22,25.94 174.67,25.49 v2(174.67,24.2) 174.83,24.03 174.83,23.85 RH460.2
SML1DATA: length 13.3
  IN5 w0.089: 177.67,28.24 177.67,28.31 178.48,29.12 178.48,30.8 178.57,30.9 178.75,30.91 178.89,30.79 v2(178.93,30.06)
  IN5 w0.097: 177.67,28.24 177.67,27.32 175.07,24.72 175.07,24.38 v2(175.25,24.2)
  BOTTOM w0.089: v2(178.93,30.06) 178.95,30.08 178.95,30.44 178.84,30.55 UH1.AW45
  BOTTOM w0.114: QH5.3 175.45,24.64 175.29,24.8 175.29,25.03 175.16,25.16 175.01,25.16 174.91,25.06 174.91,24.54 v2(175.25,24.2) 175.07,24.02 175.07,23.84 RH461.2
SNB_1.0VS_VGAP: length 2.1
  TOP w0.114: PC802.1 161.34,150 v1(161.33,150.01)
  TOP w0.508: PR803.2 162.56,149.69 PC802.1
SNB_VCCIO: length 1
  BOTTOM w0.114: 94.68,99.12 v1(95.67,99.12)
SNUB_CHG: length 2.7
  TOP w0.114: PR713.2 v1(48.82,22.62)
  TOP w0.508: PR713.2 50.36,23.77 PC715.1
SPEAKER_SEL: length 99.9
  TOP w0.114: v2(119.77,8.58) 119.77,8.92 119.66,9.03 UE10.2 ; v2(35.76,10.25) 35.76,10.18 v1(35.26,9.68)
  IN2 w0.097: v2(119.77,8.58) 119.77,7.37 119.08,6.68 116.58,6.68 115.27,5.37 85.46,5.37 83.06,7.77 70.56,7.77 69.86,7.07 69.86,5.1 69.36,4.6 66.63,4.6 65.74,5.49 65.74,6.72 64.69,7.77 62.76,7.77 61.06,9.47 44.29,9.47 41.99,11.77 37.42,11.77 36.4,10.76 36.21,10.76 35.76,10.31 v2(35.76,10.25)
  BOTTOM w0.114: v2(35.76,10.25) 35.76,10.31 36.21,10.76 37.82,10.76 38.55,11.48 JSPK.5
SPI_MOCLK: length 243.2
  TOP w0.114: v2(262.97,36.21) CE57.1 263.82,36.44 UE1.2
  IN2 w0.097: v2(71.96,6.39) 71.39,5.81 71.39,5.29 71.9,4.79 79.33,4.79 79.77,5.23 85.04,5.23 85.3,4.97 115.44,4.97 116.74,6.28 121.31,6.28 123.64,8.61 124.39,8.61 126.29,10.51 132.4,10.51 132.94,11.04 139.22,11.04 140.25,12.07 145.25,12.07 146.43,13.25 151.39,13.25 153.22,15.08 160.53,15.08 164.26,11.35 180.07,11.35 182.73,8.7 182.73,6.39 183.68,5.44 202.31,5.44 202.62,5.13 212.84,5.13 213.15,5.44 217.58,5.44 218.04,4.98 223.39,4.98 227.67,9.25 236.66,9.25 240.64,13.22 240.64,13.22 243.27,15.86 243.27,28.15 250.7,35.57 262.33,35.57 v2(262.97,36.21)
  BOTTOM w0.114: RE11.2 68.52,14.56 68.78,14.82 68.78,15.39 69.48,16.09 v1(71.9,16.09) 72.15,15.84 72.15,15.15 74.92,12.38 74.92,8.75 73.18,7.01 72.7,7.01 72.07,6.39 v2(71.96,6.39)
SPI_MOCS#: length 237.6
  TOP w0.114: UE1.31 260.7,40.18 260.24,39.71 260.24,38.7 250.78,29.23 v3(250.78,29.22) 250.78,28.21 v2(251.02,27.96)
  IN3 w0.124: v2(251.02,27.96) 251.02,25.48 235.27,9.74 226.39,9.74 221.88,5.23 217.35,5.23 216.16,6.43 185.3,6.43 v2(183.81,4.94)
  IN5 w0.097: v2(115.01,19.94) 115.42,19.53 117.92,19.53 120.42,17.03 123.9,17.03 125.99,19.13 139.8,19.13 140.48,18.44 145.26,18.44 145.7,18 150.12,18 150.7,17.42 158.04,17.42 166.53,8.92 172.47,8.92 172.94,8.45 174.72,8.45 174.82,8.34 180.4,8.34 v2(183.81,4.94)
  BOTTOM w0.114: v2(115.01,19.94) 114.73,19.94 113.68,18.88 104.43,18.88 102.78,17.23 98.52,17.23 94.98,20.76 86.02,20.76 82.67,17.42 80.53,17.42 79.11,18.84 74.37,18.84 72.47,16.94 72.47,15.14 75.13,12.47 75.13,8.66 72.21,5.74 72.21,4.68 UE2.1 RE12.2
SPI_MOSI: length 224.7
  TOP w0.114: v2(251.2,28.52) 251.2,29.35 253.15,31.3 v3(253.64,31.3) 260.49,38.15 260.49,39.08 260.79,39.38 UE1.32
  IN2 w0.097: v2(68.28,15.14) 68.47,15.33 69.17,15.33 69.23,15.39 70.55,15.39 74.77,19.61 84.78,19.61 86.66,21.49 93.04,21.49 93.45,21.89 102.45,21.89 103.29,22.73 107.71,22.73 v2(108.12,22.32)
  IN3 w0.124: v2(251.2,28.52) 251.41,28.31 251.41,25.49 235.21,9.3 226.42,9.3 222.1,4.98 217.18,4.98 215.96,6.2 185.66,6.2 v2(184.39,4.94)
  IN5 w0.097: v2(108.12,22.32) 108.27,22.17 108.27,21.95 108.6,21.61 112.29,21.61 113.18,20.72 117.01,20.72 120.5,17.23 123.78,17.23 125.87,19.33 149.18,19.33 150.83,17.68 158.11,17.68 164.52,11.27 164.52,11.22 166.62,9.12 172.55,9.12 173.02,8.65 174.8,8.65 174.91,8.54 180.79,8.54 v2(184.39,4.94)
  BOTTOM w0.114: RE9.2 67.65,15.14 v2(68.28,15.14)
SPI_MOSO: length 232.1
  TOP w0.114: v1(261.82,35.77) 262.27,36.22 v2(262.39,36.22) 262.39,36.31 263.02,36.94 UE1.1
  IN2 w0.097: v2(262.39,36.22) 262.39,35.91 262.26,35.78 250.63,35.78 243.08,28.23 243.08,15.94 240.56,13.42 240.55,13.42 236.58,9.45 227.59,9.45 223.31,5.18 218.12,5.18 217.66,5.63 213.06,5.63 212.76,5.33 202.7,5.33 202.4,5.63 183.76,5.63 182.93,6.47 182.93,8.78 180.13,11.58 164.31,11.58 160.61,15.28 153.14,15.28 151.31,13.45 146.35,13.45 145.17,12.27 140.16,12.27 139.14,11.24 132.85,11.24 132.32,10.71 126.2,10.71 124.33,8.83 123.58,8.83 121.23,6.48 116.66,6.48 115.35,5.17 85.38,5.17 85.07,5.49 v2(73.23,5.49)
  BOTTOM w0.114: v2(73.23,5.49) 73.5,5.49 75.71,3.28 75.71,2.44 74.44,1.17 71.61,1.17 RE10.2
SPK_L+_CONN: length 25
  TOP w1.016: DA7.2 37.24,11.14 32.91,11.14 32.06,11.98 31.13,11.98 30.81,12.3
  IN2 w1.016: 22.11,27.18 22.91,26.38 22.91,18.53 24.4,17.04 24.4,15.52 25.35,14.57 26.45,14.57 28.4,12.62
  vias: v1(29.67,11.96) v2(21.78,28.02) v2(22.38,28.02) v2(29.35,12.36) v2(29.98,12.36) v2(38.59,10.73) v2(39.07,11.07)
SPK_L-_CONN: length 25.1
  TOP w1.016: 33.75,12.77 34.11,12.41 35.92,12.41 36.11,12.59 39.54,12.59 41.69,10.44 41.69,9 41.42,8.72 39.07,8.72
  IN2 w1.016: 24.22,27.04 24.22,24.97 24.59,24.6 ; 32.84,15.03 32.55,15.33 28.43,15.33 27.56,16.19 27.56,17.21 26.64,18.13 25.4,18.13
  vias: v1(33.42,13.8) v2(23.56,28.03) v2(24.15,28.03) v2(32.95,14.07) v2(32.95,13.49) v2(36.25,9.29) v2(36.27,8.68)
SPK_R+_CONN: length 28.5
  TOP w0.102: v1(40.72,7.71) 40.14,7.13 v2(39.23,7.13)
  IN1 w1.016: 20.33,13.7 20.52,13.89 20.52,16.72 19.89,17.36 19.89,19.08 20.33,19.52 20.33,21.19
  IN5 w1.016: 35.45,6.31 35,6.31 34.05,7.26 34.05,8.85 33.16,9.74 31.57,9.74 30.35,10.97 29.05,10.97 27.45,9.36 25.82,9.36 24.21,10.97 22.81,10.97 21.41,12.36
  vias: v2(20.07,22.55) v2(20.07,21.94) v2(20.27,12.74) v2(20.84,13) v2(36.21,7.33) v2(36.25,6.68) v2(38.6,7.13)
SPK_R-_CONN: length 32.2
  TOP w0.102: v1(35.26,4.72) 35.3,4.68 v2(36.27,4.68)
  IN2 w1.016: 21.07,22.84 21.07,21.75 20.35,21.02 20.35,15.97 22.49,13.82
  IN5 w1.016: 23.51,13.7 30.37,13.7 30.94,13.12 30.94,12.62 32.42,11.14 36.59,11.14 37.48,10.25 37.48,5.19 37.35,5.06
  vias: v2(19.98,23.86) v2(20.58,23.86) v2(22.14,13) v2(22.75,13) v2(36.25,5.29) v2(38.6,4.84) v2(39.23,4.84)
STRAP0: length 3.9
  TOP w0.089: RG90.2 RG78.1
  TOP w0.114: v2(178.68,80.73) 178.72,80.73 178.98,80.47 178.98,79.88 179.15,79.72 v1(179.15,79.5) 179.15,78.59 RG90.2
  BOTTOM w0.114: UG9.BL3 v2(178.68,80.73)
STRAP1: length 6.6
  TOP w0.114: v2(178.7,81.45) 178.36,81.11 v3(178.13,81.11) 177.56,81.11 177.43,80.99 177.43,78.05 RG79.1 RG91.2
  BOTTOM w0.114: UG9.BL4 v2(178.7,81.45)
STRAP2: length 10.3
  BOTTOM w0.114: v1(177.88,74.15) 177.74,74.01 176.94,74.01 ; 176.94,74.01 177.43,74.51 177.43,75.67 RG92.2 176.53,76.57 176.53,78.5 176.34,78.69 176.34,79.89 178.2,81.75 UG9.BM4 ; 176.94,74.01 RG80.1
STRAP3: length 75.2
  IN2 w0.097: v2(174.4,73.8) 174.4,66.71 176.69,64.41 176.69,63.53 v2(177.12,63.11)
  IN4 w0.137: v2(177.12,63.11) 178.03,62.19 178.03,58.83 179.55,57.31 179.55,53.37 180.89,52.03 180.89,50.62 181.52,49.99 181.52,44.93 180.21,43.61 180.21,42.29 180.29,42.2 180.29,41.56 180.15,41.42 180.15,40.22 181.36,39.02 181.36,38.35 181.35,38.34 181.35,30.13 179.13,27.91 168.88,27.91 v2(168.52,27.55)
  BOTTOM w0.114: v2(174.4,73.8) 174.98,74.38 v1(175.05,74.38) 175.41,74.01 175.96,74.01 ; DG8.2 168.38,26.19 168.38,27.41 v2(168.52,27.55) ; 175.96,74.01 175.46,74.51 175.46,75.67 RG93.2 176.28,76.48 176.28,78.45 176.13,78.6 176.13,80.12 178.3,82.3 UG9.BM5 ; 175.96,74.01 RG81.1
STRAP3_PCH: length 9.2
  BOTTOM w0.089: 167.99,28.24 167.97,28.26 167.97,29.17 v1(167.71,29.43) 166.8,30.34 165.47,30.34 164.99,30.82 164.99,31.55 UH1.L43
  BOTTOM w0.114: 167.99,28.24 167.99,28.24 167.99,27.13 167.14,26.29 DG8.1 167.18,25.98 RG558.2
STRAP4: length 4.2
  TOP w0.114: v2(179.4,82.15) 179.4,82.16 v1(178.98,82.57) 178.92,82.64 177.54,82.64 RG94.2 176.93,82.03 RG82.1
  BOTTOM w0.114: UG9.BK5 v2(179.4,82.15)
STRAP5: length 81.4
  TOP w0.114: RG95.2 RG83.1 181.12,79.08 181.43,79.4 181.43,80.83 v1(181.36,80.91) 181.36,81.49 v2(180.7,82.15)
  IN4 w0.137: v2(179.88,63.79) 179.38,63.79 178.27,62.69 178.27,58.93 179.79,57.41 179.79,53.45 181.75,51.49 181.75,44.81 180.44,43.51 180.44,42.39 180.53,42.3 180.53,41.46 180.39,41.32 180.39,40.32 181.6,39.11 181.6,38.25 181.59,38.24 181.59,30.03 179.22,27.67 169.5,27.67 v2(168.8,26.97)
  IN5 w0.097: v2(180.7,82.15) 180.73,82.15 181.29,81.58 181.29,78.99 180.91,78.61 180.91,74.43 183.63,71.71 183.63,70.83 182.78,69.97 182.78,66.59 179.99,63.79 v2(179.88,63.79)
  BOTTOM w0.114: DG9.2 168.95,24.79 168.95,26.82 v2(168.8,26.97) ; UG9.BJ5 v2(180.7,82.15)
