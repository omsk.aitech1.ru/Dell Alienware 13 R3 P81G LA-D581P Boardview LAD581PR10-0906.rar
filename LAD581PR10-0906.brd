# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
STRAP5_PCH: length 10.5
  BOTTOM w0.089: UH1.L44 164.74,30.7 165.28,30.16 166.54,30.16 167.65,29.05 167.65,28.24
  BOTTOM w0.114: 167.65,28.24 v1(167.65,27.46) 167.65,27.23 166.71,26.29 166.71,24.54 DG9.1 167.01,23.48 RG559.2
SUSACK#: length 124.4
  TOP w0.114: UE5.97 89.12,19.74 91.43,17.42 92.75,17.42 93.24,16.93 93.24,14.59 92.9,14.25 92.9,11.6 v2(93.07,11.43)
  IN2 w0.097: v2(182.25,42.83) 182.2,42.77 182.2,42.46 182.19,42.45 182.19,42.18 181.57,41.56 181.57,40.01 180.04,38.49 178.71,38.49 178.53,38.3 177.63,38.3 177.45,38.49 176.95,38.49 176.39,37.93 175.45,37.93 175.08,37.56 175.08,31.94 174.33,31.19 174.33,30.03 174.41,29.95 174.41,29.32 173.24,28.15 172.94,28.15 172.19,27.41 171.77,27.41 170.4,26.03 169.33,26.03 168.71,25.41 156.76,25.41 153.98,22.63 150.49,22.63 147.78,19.93 144.39,19.93 142.64,18.18 139.01,18.18 138.08,17.25 118.91,17.25 117.91,16.25 116.61,16.25 113.61,13.26 109.97,13.26 109.22,12.51 103.31,12.51 102.67,13.15 97.38,13.15 96.8,12.57 94.41,12.57 93.27,11.43 v2(93.07,11.43)
  BOTTOM w0.076: UH1.BB19 180.49,43.45 180.77,43.17 181.91,43.17
  BOTTOM w0.089: 181.91,43.17 v2(182.25,42.83)
  BOTTOM w0.114: v2(93.07,11.43) v1(93.07,11.97)
SUSCLK: length 203.6
  TOP w0.114: v2(188.64,23.28) v1(188.64,21.82)
  IN2 w0.097: v2(239.56,31.49) 239.56,16.03 235.64,12.11 v2(232.93,12.11)
  IN2 w0.104: v2(188.64,23.28) 188.64,19.27 190.05,17.86 190.05,13.41 194.12,9.34 201.87,9.34 203.64,7.58 211.82,7.58 213.59,9.34 214.82,9.34 218.39,12.92 224.75,12.92 225.11,12.56 232.48,12.56 v2(232.93,12.11)
  IN4 w0.137: v2(290.87,61.94) 290.87,61.77 290.63,61.53 285.89,61.53 266.89,42.53 250.5,42.53 239.56,31.6 v2(239.56,31.49)
  IN5 w0.097: v2(188.64,23.28) 188.99,23.63 188.99,24.75 188.88,24.87 188.88,34.7 188.58,34.99 186.41,34.99 185.92,35.48 185.92,36.75 185.34,37.33 185.34,42.81 183.97,44.18 182.77,44.18 182.38,44.56 179.02,44.56 177.4,46.18 v2(176.35,46.18)
  BOTTOM w0.089: v2(176.35,46.18) 176.05,45.86 UH1.AN15
  BOTTOM w0.114: v2(239.56,31.49) 236.37,28.3 JSSD1.68 ; v2(290.87,61.94) 291.46,62.54 293.23,62.54 293.51,62.25 JWLAN.42 ; JSSD2.68 233.02,4.4 232.36,5.06 232.36,11.54 v2(232.93,12.11)
SUSP#: length 756.7
  TOP w0.114: v2(110.47,21.23) v3(110.47,20.59) 109.36,19.48 109.36,12.74 108.23,11.6 108.23,6.06 112.52,1.76 116.46,1.76 116.8,2.1 Q8.3 ; U16.4 242.98,16.56 243.11,16.68 243.11,22.55 242.64,23.02 v2(234.96,23.02) ; U20.4 153.7,73.37 154.51,72.56 154.51,69.21 153.74,68.44 149.01,68.44 v2(148.99,68.41) ; v2(88.28,12.85) 88.28,12.3 88.12,12.14 UE5.116
  TOP w0.254: v2(56.6,52.97) PR209.1
  IN1 w0.097: v2(88.28,12.85) 88.71,13.27 88.93,13.27 90.82,15.16 90.82,15.98 92.96,18.12 95.69,18.12 99.31,21.74 103.99,21.74 105.6,20.13 109.37,20.13 v2(110.47,21.23)
  IN2 w0.097: v2(81.78,61.98) 82.21,61.98 83.18,62.96 141.94,62.96 147.42,68.43 148.9,68.43 148.92,68.41 v2(148.99,68.41) ; v2(142.25,142.59) 142.12,142.46 140.28,142.46 136.08,146.66 136.08,151.27 136.73,151.92 137.81,151.92 138.38,151.34 139.14,151.34 139.59,151.79 139.59,152.68 140.6,153.69 140.6,155.54 141.87,156.81 v2(142.76,156.81)
  IN3 w0.124: v2(234.96,23.02) 231.55,23.02 231.22,22.69 231.22,19.47 231.97,18.72 231.97,17.34 231.4,16.78 228.35,16.78 228.24,16.66 223.64,16.66 222.62,15.65 217.71,15.65 213.97,11.91 195.07,11.91 192.42,14.57 192.42,16.06 190.9,17.58 186.42,17.58 185.12,16.28 179.42,16.28 178.46,15.32 167.16,15.32 166.87,15.03 165.86,15.03 165.18,15.71 165.18,17.55 164.1,18.63 155.78,18.63 154.51,17.36 140.41,17.36 138.63,19.15 124.83,19.15 123.75,18.07 120.58,18.07 118.31,15.81 118.31,12.03 118.38,11.96 118.38,10.76 117.84,10.22 116.59,10.22 116.01,10.8 116.01,16.8 111.58,21.23 v2(110.47,21.23) ; v2(237.95,155.6) 237.95,153.38 237.25,152.68 237.25,146.9 233.51,143.16 197.18,143.16 196.18,144.16 189.37,144.16 189.06,144.46 175.2,144.46 172.78,142.04 168.99,142.04 162.93,135.98 152.8,135.98 149.24,139.53 144.54,139.53 142.25,141.83 v2(142.25,142.59)
  IN4 w0.137: v2(97.23,114.16) 96.66,114.16 94.42,116.39 88.85,116.39 87.77,115.32 87.77,88.61 87.01,87.84 87.01,66.51 82.48,61.98 v2(81.78,61.98)
  IN5 w0.097: v2(97.23,114.16) 94.76,116.62 92.29,116.62 89.96,118.95 89.96,133.2 88.82,134.35 88.82,136.15 88.19,136.78 88.19,137.75 89.93,139.49 92.93,139.49 94.31,140.87 97.59,140.87 97.94,141.22 131.52,141.22 131.93,140.81 136.39,140.81 138.17,142.58 142.24,142.58 v2(142.25,142.59) ; v2(81.78,61.98) 81.78,61.4 80.15,59.78 60.76,59.78 55.8,54.81 55.8,53.26 56.08,52.97 v2(56.6,52.97) 57.51,52.97 60.79,56.25 74.16,56.25 76.02,54.38 76.02,51.78 73.54,49.3 73.54,41.28 73,40.74 73,22.69 76.65,19.04 80,19.04 82.86,16.17 84.41,16.17 84.93,15.66 86.19,15.66 86.56,15.28 86.56,14.56 v2(88.28,12.85)
  BOTTOM w0.114: v2(56.6,52.97) 54.72,52.97 54.43,53.26 54.43,57.13 53.84,57.72 R174.1 ; RT15.2 143.25,157.16 142.89,156.81 v2(142.76,156.81) ; PR807.2 v2(237.95,155.6)
  BOTTOM w0.127: v2(81.78,61.98) 82.42,61.98 87.01,66.57 87.01,67.31 89.67,69.97 89.67,71.71 98.58,80.62 UZ21.3
  BOTTOM w0.203: U17.3 55.93,60 55.25,59.32 54.35,59.32 R174.1
  BOTTOM w0.254: v2(97.23,114.16) 95.91,112.84 PR5007.1
SUSP#_R: length 4.4
  TOP w0.089: UT1.D2 144.35,158.98 143.7,158.98 143.66,159.01
  TOP w0.114: v2(142.58,158.71) 142.64,158.71 142.94,159.01 143.66,159.01
  BOTTOM w0.114: v2(142.58,158.71) 142.66,158.63 RT30.2 RT15.1 142.15,157.5 v1(141.84,157.19)
SW_1.2V: length 4.2
  IN1 w1.016: 69.13,48.82 64.94,48.82
  vias: v2(63.24,49.44) v2(63.72,49.09) v2(69.28,50.37) v2(69.28,49.74) v2(69.6,51.58) v2(69.6,50.94) v2(69.92,50.37) v2(69.92,49.74) v2(71.6,54.06) v2(71.6,53.43) v2(71.6,52.79) v2(71.6,52.16) v2(72.1,54.39) v2(72.1,53.75) v2(72.1,53.12) v2(72.1,52.48) v2(72.6,54.07) v2(72.6,53.44) v2(72.6,52.8) v2(72.6,52.17) v2(72.97,50.81) v2(72.97,50.18) v3(70.61,52.75)
SW_+1VALWP: length 8.4
  IN5 w1.016: 203.85,21.51 204.55,21.51 205.31,20.74 205.31,19.54 205.94,18.9 208.72,18.9
  BOTTOM w0.114: PR305.1 v3(204.8,26.12)
  vias: v2(203.02,21.89) v2(203.02,21.25) v2(209.88,19.73) v2(210.39,20.05)
SW_USB20_N1: length 6.2
  TOP w0.114: UU1.11 19.88,51.44 20.14,51.7 v4(20.69,51.7) 21.43,51.7 21.79,51.33 22.19,51.33 v2(22.43,51.57)
  BOTTOM w0.114: LU3.1 21.41,51.31 21.67,51.57 v2(22.43,51.57)
SW_USB20_P1: length 6
  TOP w0.114: v2(22.43,50.99) 22.31,51.11 21.7,51.11 21.33,51.48 21.03,51.48 21.02,51.46 20.42,51.46 20.4,51.48 20.24,51.48 20.11,51.35 20.11,51.15 20.17,51.09 20.31,51.09 20.38,51.02 UU1.10
  BOTTOM w0.114: LU3.4 21.91,50.6 21.84,50.67 21.72,50.67 21.63,50.76 21.63,51.22 21.76,51.35 22.11,51.35 22.25,51.21 22.25,51.12 22.38,50.99 v2(22.43,50.99)
SYNC_OUT: length 1.8
  TOP w0.114: UA4.38 21.75,20.22 21.55,20.03 20.72,20.03 TC24.1
SYS_PEX_RST_MON#: length 32.3
  IN3 w0.124: v2(185.04,62.81) 184.96,62.74 184.96,61.61 184.3,60.95 183.57,60.95 183.19,60.57 v2(183.19,59.97)
  IN5 w0.089: 181.88,78.95 v2(182.2,79.27)
  IN5 w0.097: v2(185.04,62.81) 184.96,62.81 183.43,64.35 183.43,67.64 184.35,68.57 184.35,71.55 181.37,74.54 181.37,78.44 181.88,78.95
  BOTTOM w0.114: RG21.1 188.1,64.53 187.45,63.88 v1(187.24,63.88) 186.93,63.58 185.57,63.58 185.04,63.05 v2(185.04,62.81) 184.74,62.51 183.91,62.51 183.69,62.29 RG537.2 ; v2(182.2,79.27) 182.32,79.27 183.2,80.15 UG9.BE2 ; DG1.2 182.92,60.01 182.98,59.94 183.16,59.94 v2(183.19,59.97)
SYS_PWROK: length 107.6
  TOP w0.114: CE46.1 96.61,26.01 96.22,25.61 96.22,24.65 97.13,23.73 v2(97.13,23.46) 97.47,23.11 UE5.74
  IN2 w0.097: v2(179.05,50.31) 178.68,49.94 178.11,49.94 177.22,49.05 174.25,49.05 173.94,49.36 173.05,49.36 172.67,48.98 172.67,47.34 172.09,46.76 170.52,46.76 169.91,46.16 168.68,46.16 168.49,45.96 167.2,45.96 167.07,46.09 165.97,46.09 165.63,45.74 160.61,45.74 160.12,45.26 156.46,45.26 153.93,42.72 152.5,42.72 147.91,38.12 147.21,38.12 145.13,36.04 143.22,36.04 142.64,35.46 142.64,30.82 140.03,28.22 126.83,28.22 126.71,28.1 117.11,28.1 116.24,27.23 113.79,27.23 110.23,23.66 97.34,23.66 v2(97.13,23.46)
  BOTTOM w0.089: v2(179.05,50.31) 179.05,50.65 179.41,51.01 179.41,51.55 179.72,51.85 179.72,52.19 UH1.AY1
SYS_RESET#: length 6.9
  BOTTOM w0.089: UH1.AW1 178.84,52.58 179.19,52.93 179.4,52.93 181.28,54.81 181.28,55.17
  BOTTOM w0.114: 181.28,55.17 v1(181.28,55.36) 181.28,55.92 CH175.1 ; CH175.1 180.89,56.26 RH5.2 ; CH175.1 RH571.1
SYSON: length 208.6
  TOP w0.114: UE5.95 89.07,22.36 89,22.44 89,22.96 CE42.1 86.94,25.01 86.94,25.56 v2(86.63,25.87) ; Q9.3 119.75,1.67 119.36,1.28 112.32,1.28 107.75,5.86 107.75,12.5 108.4,13.15 108.4,19.47 109.76,20.83 109.76,22.86 v3(108.63,24) 106.88,25.74 v2(105.87,25.74) ; v2(149.05,72.47) 149.23,72.47 149.76,73 U19.4
  TOP w0.254: v2(56.6,51.07) PR208.2
  IN1 w0.097: v2(75.17,49.17) 76.72,50.72 76.72,53.87 75.23,55.37 64.38,55.37 63.58,54.57 63.58,53.3 62.97,52.7 58.02,52.7 56.6,51.27 v2(56.6,51.07)
  IN2 w0.097: v2(75.17,49.17) 74.88,48.88 74.88,45.61 75.8,44.7 75.8,28.51 78.63,25.68 86.44,25.68 v2(86.63,25.87) 86.63,26.44 87.42,27.23 88.01,27.23 89,28.22 92.57,28.22 95.01,25.78 98.08,25.78 98.95,24.92 101.58,24.92 101.98,25.32 105.13,25.32 105.55,25.74 v2(105.87,25.74)
  IN4 w0.137: v2(149.05,72.47) 149.05,71.16 141.82,63.93 138.51,63.93 130.63,56.05 130.63,42.65 129.21,41.23 129.21,32.6 128.3,31.68 128.3,28.89 127.93,28.52 127.93,27.19 126.49,25.74 v2(105.87,25.74)
TB_STAT#_CHG: length 12.7
  TOP w0.203: v2(53.93,36.73) 54.9,36.73 55.9,35.73 PU700.16
  TOP w0.254: v2(53.21,30.99) PQ705.2
  BOTTOM w0.254: v2(53.93,36.73) 54.12,36.73 54.61,36.23 PR718.1 54.97,36.08 55.1,35.96 55.1,35.41 54.63,34.94 54.63,33.47 53.92,32.76 53,32.76 v1(52.59,32.35) 52.59,31.6 v2(53.21,30.99)
TBT_A_AUX_N: length 4.5
  TOP w0.089: v2(150.81,152.6) 150.47,152.27 UT1.W15
  BOTTOM w0.114: CT44.2 150.4,149.14 150.42,149.16 150.42,150.12 150.56,150.27 150.56,151.24 150.26,151.55 v4(150.26,151.78) 150.26,151.98 150.81,152.53 v2(150.81,152.6)
TBT_A_AUX_N_C: length 45.2
  IN2 w0.097: v2(137.04,151.47) 137.24,151.27 137.44,151.27 137.69,151.02 137.69,149.8 137.49,149.6 137.49,146.86 139.03,145.32 145.6,145.32 145.99,145.71 150.83,145.71 151.01,145.89 151.01,146.04 v2(150.81,146.24)
  IN5 w0.097: v2(122.39,154.32) 122.2,154.13 122.2,153.51 122.55,153.16 127.67,153.16 129.15,151.68 135.82,151.68 136.23,151.27 136.84,151.27 v2(137.04,151.47)
  BOTTOM w0.076: 122.4,153.69 123.26,152.83 123.86,152.83 124.05,152.64 UT4.J2
  BOTTOM w0.089: v2(122.39,154.32) 122.19,154.12 122.19,153.9 122.4,153.69
  BOTTOM w0.114: RT70.2 121.1,156.29 121.71,156.29 122.21,155.78 122.21,154.5 v2(122.39,154.32) ; v2(150.81,146.24) 150.94,146.36 150.94,146.87 150.73,147.09 150.73,147.83 150.57,147.98 150.57,148.26 CT44.1
TBT_A_AUX_P: length 3.9
  TOP w0.089: UT1.Y15 150.48,151.62 v2(150.81,151.94)
  BOTTOM w0.114: v2(150.81,151.94) 150.6,151.94 150.52,151.87 150.52,151.66 150.83,151.35 v4(150.83,150.52) 150.83,150.16 150.69,150.01 150.69,149.39 150.97,149.11 CT43.2
TBT_A_AUX_P_C: length 45.1
  IN2 w0.097: v2(137.04,150.88) 137.22,151.07 137.36,151.07 137.49,150.93 137.49,149.88 137.29,149.69 137.29,146.78 138.95,145.12 145.68,145.12 146.07,145.51 150.91,145.51 151.21,145.81 151.21,146.04 v2(151.4,146.24)
  IN5 w0.097: v2(121.81,154.32) 122,154.13 122,153.43 122.46,152.96 127.59,152.96 129.07,151.48 135.74,151.48 136.15,151.07 136.85,151.07 v2(137.04,150.88)
  BOTTOM w0.076: 122.27,153.56 122.28,153.55 122.29,153.55 122.33,153.52 122.34,153.52 123.19,152.67 123.26,152.67 123.34,152.58 UT4.J1
  BOTTOM w0.089: 122.27,153.56 122.01,153.83 122.01,154.12 v2(121.81,154.32)
  BOTTOM w0.114: RT73.1 121.06,156.02 121.6,156.02 121.95,155.67 121.95,154.46 v2(121.81,154.32) ; v2(151.4,146.24) 151.21,146.43 151.21,146.98 150.99,147.2 150.99,147.94 150.84,148.09 150.84,148.31 CT43.1
TBT_A_USB20_L_NB: length 8.8
  IN5 w0.104: v2(158.76,172.02) 158.95,171.82 158.95,170.84 159.4,170.39 159.4,168.85 159.9,168.35 159.9,168.25 v2(159.69,168.04)
  BOTTOM w0.114: v2(159.69,168.04) 159.85,167.88 159.85,167.68 159.72,167.56 DT10.4 DT10.7 159.72,166.1 159.86,165.96 159.86,165.35 159.76,165.25 LT3.3 ; v2(158.76,172.02) 158.93,172.2 158.93,172.38 158.75,172.57 JUSBC1.B7
TBT_A_USB20_L_NT: length 6.8
  BOTTOM w0.114: LT2.2 158.67,165.24 158.55,165.36 158.55,165.95 158.72,166.12 DT10.8 DT10.2 158.72,167.48 158.58,167.62 158.58,168.02 v4(158.95,168.39) 159.4,168.84 159.4,169.78 159.42,169.79 159.42,170.33 159.4,170.35 159.4,170.57 159.5,170.67 JUSBC1.A7
TBT_A_USB20_L_PB: length 8.8
  IN5 w0.104: v2(160.27,168.04) 160.09,168.21 160.09,168.43 159.59,168.93 159.59,170.47 159.15,170.92 159.15,171.84 v2(159.34,172.03)
  BOTTOM w0.114: LT3.2 160.26,165.24 160.08,165.41 160.08,165.96 160.22,166.09 DT10.6 DT10.5 160.22,167.54 160.08,167.68 160.08,167.84 v2(160.27,168.04) ; v2(159.34,172.03) 159.16,172.21 159.16,172.38 159.25,172.47 JUSBC1.B6
TBT_A_USB20_L_PT: length 6.8
  BOTTOM w0.114: LT2.3 158.17,165.25 158.33,165.41 158.33,165.98 158.22,166.09 DT10.9 DT10.1 158.22,167.47 158.35,167.6 158.35,167.61 158.36,167.62 158.36,168.11 158.59,168.35 158.59,168.37 158.97,168.75 159,168.75 159.18,168.93 v4(159.18,170.06) 159.18,170.58 159,170.75 JUSBC1.A6
TBT_A_USB20_N: length 38.7
  TOP w0.089: v2(152.74,159.11) 153.05,159.42 UT1.D20
  IN5 w0.104: v2(125.17,154.82) 125.24,154.89 125.24,155.38 125.53,155.67 126.38,155.67 127.25,154.79 127.78,154.79 129.65,156.66 131,156.66 133.02,158.68 134.2,158.68 136,160.48 136,162.23 137.33,163.56 140.01,163.56 140.5,164.05 144.42,164.05 145.72,162.75 146.16,162.75 146.63,162.28 146.63,160.95 147.01,160.57 150.89,160.57 152.43,159.03 152.66,159.03 v2(152.74,159.11)
  BOTTOM w0.076: UT4.K5 125.37,153.41 125.3,153.48 125.3,153.91 125.41,154.01 125.41,154.34 125.33,154.41 125.33,154.66 v2(125.17,154.82)
TBT_A_USB20_NB: length 48.1
  IN5 w0.104: v2(161.52,164.31) 161.45,164.38 161.45,164.88 161.21,165.12 157.78,165.12 157.27,165.63 153.31,165.63 151.89,164.21 147.6,164.21 147.4,164.01 146.22,164.01 144.97,165.26 140.01,165.26 139.92,165.17 137.12,165.17 133.51,161.56 133.51,161.05 131.55,159.09 131.03,159.09 130.6,158.66 127.46,158.66 127.08,158.29 127.08,157.91 v2(126.98,157.81)
  BOTTOM w0.076: UT4.L7 126.64,153.67 126.64,156.05 127.17,156.58 127.17,156.72
  BOTTOM w0.089: 127.17,156.72 127.17,156.74
  BOTTOM w0.114: v2(161.52,164.31) 161.52,163.56 160.88,162.92 160.16,162.92 159.9,163.18 159.9,163.42 159.76,163.56 LT3.4 ; 127.17,156.74 127.17,157.62 v2(126.98,157.81)
TBT_A_USB20_NT: length 45.4
  IN5 w0.104: v2(158.67,163.03) 158.51,163.19 158.51,163.46 157.92,164.05 157.06,164.05 155.38,162.37 150.14,162.37 150.01,162.24 147.53,162.24 146.4,163.37 145.99,163.37 144.72,164.65 140.25,164.65 140.16,164.56 137.45,164.56 135.4,162.5 135.4,160.79 134.17,159.56 133.04,159.56 130.86,157.38 126.75,157.38 126.22,157.91 125.92,157.91 v2(125.75,158.08)
  BOTTOM w0.076: 126.2,154.25 126,154.05 126,153.64 UT4.L6
  BOTTOM w0.089: 126.2,154.25 126.44,154.5 126.44,155.37 126.37,155.44 126.37,156.72 126.39,156.74
  BOTTOM w0.114: v2(125.75,158.08) 125.95,157.88 126.13,157.88 126.39,157.62 126.39,156.74 126.39,156.74 ; v2(158.67,163.03) LT2.1
TBT_A_USB20_P: length 38.7
  TOP w0.089: UT1.E20 152.87,158.77 152.75,158.64 v2(152.75,158.43)
  IN5 w0.104: v2(125.86,154.82) 125.7,154.82 125.55,154.97 125.55,154.98 125.43,155.1 125.43,155.3 125.61,155.47 126.3,155.47 127.17,154.6 127.86,154.6 129.73,156.46 131.08,156.46 133.1,158.48 134.28,158.48 136.19,160.4 136.19,162.15 137.41,163.37 140.09,163.37 140.58,163.85 144.34,163.85 145.64,162.56 146.08,162.56 146.44,162.2 146.44,160.87 146.93,160.38 150.81,160.38 152.35,158.84 152.47,158.84 152.75,158.56 v2(152.75,158.43)
  BOTTOM w0.076: v2(125.86,154.82) 125.63,154.82 125.52,154.72 125.52,154.68 125.5,154.65 125.5,154.51 125.57,154.44 125.57,153.95 125.47,153.84 125.47,153.67 UT4.L5
TBT_A_USB20_PB: length 47.9
  IN5 w0.104: v2(160.94,164.31) 160.98,164.31 161.25,164.58 161.25,164.8 161.13,164.93 157.7,164.93 157.19,165.44 153.39,165.44 151.97,164.02 147.68,164.02 147.48,163.82 146.14,163.82 144.89,165.07 140.09,165.07 140,164.97 137.2,164.97 133.71,161.48 133.71,160.97 131.63,158.9 131.11,158.9 130.68,158.47 127.54,158.47 127.27,158.21 127.27,158.07 127.53,157.81 v2(127.69,157.81)
  BOTTOM w0.076: 127.39,156.74 127.39,156.71 127.33,156.65 127.33,156.51 126.8,155.98 126.8,153.52 UT4.K7
  BOTTOM w0.114: LT3.1 160.26,163.57 160.12,163.43 160.12,163.27 160.25,163.14 160.79,163.14 161.3,163.66 161.3,163.95 v2(160.94,164.31) ; 127.39,156.74 127.39,157.68 127.52,157.81 v2(127.69,157.81)
TBT_A_USB20_PT: length 45.3
  IN5 w0.104: v2(125.75,157.49) 125.98,157.72 126.14,157.72 126.67,157.18 130.94,157.18 133.12,159.37 134.25,159.37 135.59,160.71 135.59,162.42 137.53,164.36 140.24,164.36 140.33,164.46 144.64,164.46 145.91,163.18 146.32,163.18 147.45,162.05 150.09,162.05 150.22,162.18 155.46,162.18 157.14,163.85 157.84,163.85 158.32,163.38 158.32,163.27 v2(158.09,163.03)
  BOTTOM w0.076: UT4.K6 125.8,153.33 125.8,153.69 125.83,153.72 125.83,154.12 126.03,154.32 126.03,154.33 126.06,154.36 126.06,154.37 126.07,154.38
  BOTTOM w0.089: 126.07,154.38 126.27,154.57 126.27,155.3 126.19,155.37 126.19,156.71 126.17,156.73 126.17,156.74
  BOTTOM w0.114: v2(158.09,163.03) 158.17,163.12 LT2.4 ; 126.17,156.74 126.17,156.74 126.17,157.53 126.04,157.66 125.92,157.66 v2(125.75,157.49)
TBT_CIO_PLUG_EVENT#: length 185.7
  TOP w0.089: 142.58,151.86 142.73,151.86 v2(142.74,151.88) 143.05,151.88 143.71,152.53 144.35,152.53 144.57,152.31 UT1.W2
  TOP w0.114: 142.58,151.86 141.91,151.86 RT29.2
  IN5 w0.097: v2(142.74,151.88) 143.52,151.88 144.45,150.95 153.27,150.95 153.52,151.21 153.52,152.22 153.16,152.58 152.4,152.58 152.08,152.91 152.08,154.28 152.35,154.56 153.24,154.56 154.28,155.6 154.28,159.33 157.08,162.14 163.15,162.14 163.9,161.38 163.9,158.09 166.63,155.36 166.63,154.14 167.42,153.35 167.42,151.25 168.83,149.84 172.61,149.84 174.98,147.47 174.98,144.13 172.86,142.01 172.86,111.97 171.18,110.29 171.18,89 167.15,84.97 167.15,81.14 165.62,79.61 165.62,78.56 163.49,76.43 163.49,71.23 163.08,70.83 163.08,57.77 166.74,54.12 166.74,51.32 167.89,50.16 167.89,46.04 170.58,43.35 172.13,43.35 172.48,43 172.48,38.84 173.27,38.05 173.53,38.05 173.76,37.82 173.76,34.41 174.13,34.04 174.13,33.12 174.69,32.56 v2(175.59,32.56)
  BOTTOM w0.089: v2(175.59,32.56) 176.21,32.56 176.33,32.44 176.33,32.03 UH1.AN43
  BOTTOM w0.114: v2(142.74,151.88) v1(143.29,151.88)
TBT_EE_CLK: length 16.3
  TOP w0.089: UT1.AB4 145.26,150.69 145.26,150.16 144.41,149.31 144.41,149.22 143.4,148.21 142.73,148.21 142.58,148.37
  TOP w0.114: v2(141.92,148.45) 142.5,148.45 142.58,148.37
  BOTTOM w0.114: v1(143.08,148.17) 142.8,148.45 v2(141.92,148.45) 140,148.45 138.44,146.9 138.44,146.43 140.34,144.53 UT2.6 140.34,142.47 140.58,142.23 RT101.1
TBT_EE_CS_N: length 18.4
  TOP w0.089: UT1.AC3 145.03,150.26 144.23,149.45 144.23,149.29 143.72,148.79 143.64,148.79 143.24,148.39 142.88,148.39 142.58,148.69 142.58,148.8
  TOP w0.114: 142.58,148.8 142.45,148.93 v2(142.45,149.15)
  IN2 w0.097: v2(138.33,147.43) 139.02,148.11 139.02,149.74 139.41,150.14 141.68,150.14 142.45,149.37 v2(142.45,149.15)
  BOTTOM w0.114: v1(135.59,151.12) 135.79,151.32 RT100.1 136.41,151.88 136.69,152.16 RT50.2 137.07,152.16 137.44,151.79 137.44,151.46 137.8,151.1 UT2.1 137.8,149.58 137.74,149.52 137.74,148.03 v2(138.33,147.43)
TBT_EE_DI: length 17
  TOP w0.089: UT1.AB3 144.8,150.68 144.8,150.28
  TOP w0.102: v2(143.09,148.75) 143.31,148.97 143.65,148.97 144.05,149.37 144.05,149.53 144.8,150.28
  IN2 w0.097: v2(143.09,148.75) 143.09,147.93 142.64,147.47 141.32,147.47 140.62,148.17 139.71,148.17 138.94,147.4 v2(138.94,146.76)
  BOTTOM w0.114: v2(138.94,146.76) 138.94,146.27 139.97,145.24 140.98,145.24 141.61,144.62 UT2.5 141.61,142.44 141.85,142.2 RT98.1 v1(142.7,142.01)
TBT_EE_DO: length 12.4
  TOP w0.089: UT1.AC4 145.49,150.05 144.09,148.64 v1(144.09,148.41) 143.71,148.03 142.58,148.03
  TOP w0.114: 142.58,148.03 v2(142.33,148.03) ; v2(139.4,149.47) 139.5,149.56 RT99.1
  IN2 w0.097: v2(139.4,149.47) 139.4,148.99 139.78,148.61 140.92,148.61 141.5,148.03 v2(142.33,148.03)
  BOTTOM w0.114: v2(139.4,149.47) 139.07,149.8 UT2.2 139.07,151.17 138.88,151.36 138.53,151.36 137.99,151.91 RT49.1
TBT_EE_WP_N: length 7
  TOP w0.089: UT1.V1 143.42,152.76 v2(143.26,152.59)
  BOTTOM w0.114: UT2.3 140.34,151.27 RT48.2 139.68,152.36 v1(140.84,152.36) 140.98,152.36 141.39,152.76 143.09,152.76 v2(143.26,152.59)
TBT_FORCE_PWR: length 158.1
  TOP w0.114: RT13.2 138.09,151.93 138.23,151.79 v2(138.69,151.79) ; v2(158.19,134.39) v1(158.71,134.39)
  IN1 w0.097: v2(167.45,32.83) 165.87,34.42 165.87,39.95 163.76,42.06 162.38,42.06 161.66,42.79
  IN1 w0.102: v2(158.19,134.39) 159.3,133.28 159.3,119.73 160.5,118.53 160.5,115.56 159.8,114.86 157.41,114.86 152.54,109.99 152.54,107.59 150.92,105.98 150.92,78.92 153.58,76.27 153.58,70 155.12,68.46 155.12,50.75 155.91,49.97 155.91,46.14 158.94,43.1 161.34,43.1 161.66,42.79
  IN2 w0.097: v2(138.69,151.79) 138.31,152.17 136.67,152.17 135.84,151.34 135.84,146.58 140.29,142.14 151.34,142.14 152.2,141.27 155.08,141.27 158.19,138.15 v2(158.19,134.39)
  BOTTOM w0.089: v2(167.45,32.83) 167.16,32.55 166.78,32.55 166.5,32.27 UH1.P43
TBT_FORCE_PWR_R: length 15.5
  TOP w0.102: v2(145.6,157.79) UT1.H4
  TOP w0.114: RT13.1 RT35.1 137.28,153.43 137.01,153.16 136.67,153.16 v1(136.64,153.19) 136.47,153.36 136.47,154.37 136.62,154.51 v2(136.87,154.51)
  IN5 w0.097: v2(136.87,154.51) 137.71,155.35 137.71,156.09 138.62,157.01 139.94,157.01 140.49,156.46 141.86,156.46 143.19,157.79 v2(145.6,157.79)
  BOTTOM w0.114: v2(136.87,154.51) 136.96,154.42 RT94.2
TBT_HDMI_DDC_CLK: length 2.5
  TOP w0.089: UT1.Y2 144.34,152.07 143.96,152.07 143.96,152.06 143.74,152.06 142.78,151.1 T9.1
TBT_HDMI_DDC_DATA: length 5
  TOP w0.089: 142.79,150.86 143.77,151.84 UT1.Y1
  TOP w0.127: T7.1 140.2,150.46 142.39,150.46 142.79,150.86
TBT_HOLD_N: length 6.7
  BOTTOM w0.508: UT2.7 139.07,144.52 137.37,146.23 v1(135.97,146.23) 134.53,146.23 RT51.2
TBT_I2C_SCL: length 29.1
  TOP w0.089: 142.58,153.99 142.81,153.99 v2(143.02,153.78) 143.15,153.66 143.54,153.66 143.76,153.44 144.35,153.44 UT1.U2
  TOP w0.114: RT27.2 142.58,153.99
  IN5 w0.097: v2(122.2,150) 122.24,150 123.2,149.03 123.53,149.03 124.11,148.46 128,148.46 128.71,149.17 129.61,149.17 130.35,148.44 136.55,148.44 139.56,151.44 140,151.44 142.18,153.62 142.86,153.62 v2(143.02,153.78)
  BOTTOM w0.076: UT4.D2 123.8,150.33 123.43,150.33 123.37,150.27 122.78,150.27 122.51,150 v2(122.2,150)
TBT_I2C_SDA: length 28.2
  TOP w0.089: 142.58,153.42 142.65,153.42 v2(142.86,153.22) 143.06,153.42 143.52,153.42 143.68,153.26 144.07,153.26 UT1.U1
  TOP w0.114: RT26.2 142.58,153.42
  IN5 w0.097: v2(122.06,149.36) 122.24,149.54 122.38,149.54 123.11,148.81 123.44,148.81 124.02,148.23 128.09,148.23 128.8,148.95 129.52,148.95 130.25,148.21 136.65,148.21 139.65,151.22 140.1,151.22 142.28,153.4 142.68,153.4 v2(142.86,153.22)
  BOTTOM w0.076: v2(122.06,149.36) 122.11,149.36 122.85,150.1 123.43,150.1 123.45,150.08 UT4.D1
TBT_PCIE_WAKE#: length 209.8
  TOP w0.114: v2(96.72,25.38) 98.66,23.45 98.66,22.65 99.07,22.24 UE5.70 ; RT10.2 140.2,152.24 138.82,150.86 v1(138.38,150.86) 137.62,150.1 137.62,145.36 135.66,143.41 135.66,142.65 v2(135.92,142.39)
  IN5 w0.097: v2(135.92,142.39) 135.03,143.28 132.44,143.28 131.25,142.09 113.08,142.09 111,144.17 104.72,144.17 102.94,142.39 97.63,142.39 97.47,142.23 88.84,142.23 87.07,140.46 87.07,135.36 87.65,134.78 87.65,133.59 87.05,132.99 87.05,91.45 85.48,89.88 85.48,60.29 79.71,54.52 79.71,48.98 77.19,46.46 77.19,26.44 78.46,25.16 82.62,25.16 84.08,26.62 88.49,26.62 89.04,26.07 91.3,26.07 91.92,26.69 92.94,26.69 94.24,25.38 v2(96.72,25.38)
TBT_PCIE_WAKE_N: length 5.1
  TOP w0.089: 142.58,151.45 142.88,151.45 143.72,152.3 UT1.W1
  TOP w0.114: 142.58,151.45 142.43,151.45 141.71,150.74 141.24,150.74 v1(141.15,150.82) 141.12,150.85 RT28.2 RT10.1
TBT_RBIAS: length 1.6
  TOP w0.089: v2(146.9,157.79) 146.9,157.79 UT1.H6
  BOTTOM w0.102: v2(146.9,157.79) 146.9,157.88 147.33,158.31 147.33,158.41 147.56,158.63 RT25.1
TBT_RESET_N: length 27.6
  TOP w0.102: v2(145.6,158.44) 145.27,158.12 UT1.F4
  TOP w0.114: v2(136.83,155.29) 137.78,155.29 138.09,154.98 RT23.1
  IN5 w0.097: v2(145.6,158.44) 143.46,158.44 142.43,157.42 138.67,157.42 137.4,156.15 137.4,155.87 v2(136.83,155.29) 136.26,154.72 136.26,153.25 137.5,152.01 137.5,150.74 137.2,150.44 134.25,150.44 133.95,150.74 133.16,150.74 132.88,150.45 v2(130.85,150.45)
  BOTTOM w0.114: v2(145.6,158.44) 144.87,158.44 RT80.2 ; v1(131.95,150.37) 131.76,150.56 130.96,150.56 v2(130.85,150.45) 130.81,150.41 130.81,150.16 131.12,149.86 RT102.2
TBT_RESET_N_EC: length 235
  TOP w0.114: v2(134.18,141.87) 135.07,142.76 135.07,143.18 137.38,145.49 137.38,149.78 v1(137.27,149.89) 137.27,150.37 137.49,150.6 137.49,151.79 136.26,153.02 136.26,154.53 136.63,154.9 137.27,154.9 RT23.2 ; UE5.15 94.27,6.67 94.17,6.77 94.17,8.95 94.7,9.48 v2(94.7,9.94)
  IN5 w0.097: v2(94.7,9.94) 96.92,9.94 98.63,11.65 99.91,11.65 100.15,11.9 100.15,13.11 99.2,14.06 98.31,14.06 96.63,15.74 96.63,21.1 98.16,22.63 98.16,25.72 97.66,26.22 94.04,26.22 93.17,27.09 90.82,27.09 89.89,28.02 84.82,28.02 82.39,25.6 78.64,25.6 77.64,26.61 77.64,46.28 80.16,48.8 80.16,54.33 85.87,60.05 85.87,89.65 87.49,91.27 87.49,124.42 89.06,125.99 89.06,127.15 87.96,128.25 87.96,130.66 87.29,131.33 87.29,132.85 87.92,133.48 87.92,135.78 87.3,136.41 87.3,140.37 88.91,141.98 97.5,141.98 97.69,142.16 109.39,142.16 110.57,143.34 111.5,143.34 112.98,141.86 131.82,141.86 132.21,141.48 133.79,141.48 v2(134.18,141.87)
TBT_RSENSE: length 1.4
  TOP w0.102: UT1.J6 v2(146.9,157.15)
  BOTTOM w0.102: RT25.2 147.5,157.75 v2(146.9,157.15)
TBT_RST#_R: length 18.1
  TOP w0.089: UT1.L4 v2(145.6,156.49)
  TOP w0.114: v2(154.79,161.17) 154.79,161.56 v1(155.06,161.84) 155.36,162.14 RT1.2
  IN5 w0.097: v2(154.79,161.17) 153.43,159.81 153.43,155.95 152.91,155.43 151.98,155.43 151.02,155.43 150.38,154.79 149.89,154.79 149.24,154.14 148.52,154.14 148.09,154.57 148.09,155.38 146.98,156.49 v2(145.6,156.49)
TBT_SRC_CFG1: length 3.6
  TOP w0.089: UT1.AA1 143.59,151.38 143.02,150.81 143.02,150.73
  TOP w0.127: 143.02,150.73 142.28,150 RT11.1
TBT_SRC_HPD: length 3.9
  TOP w0.089: UT1.G1 143.66,157.82
  TOP w0.114: 143.66,157.82 143.64,157.82 143.51,157.69 143.51,156.67 142.9,156.05 142.51,156.05 142.16,155.7 RT4.1
TBT_SVR_IND:
  vias: v1(143.12,160.31) v2(142.63,160.03) v2(142.63,159.34) v2(143.2,159.65)
TBT_TCK: length 76.3
  TOP w0.102: v2(145.6,153.89) UT1.T4
  TOP w0.114: v2(95.77,153.88) 95.77,151.41 96.03,151.15 96.6,151.15 97.16,150.59 JTAG.4 99.13,150.59 v1(99.28,150.74) ; RT7.2 140.53,147.72 v2(140.35,147.53)
  IN3 w0.124: v2(95.77,153.88) 96.17,153.49 96.17,152.22 97.1,151.28 97.1,147.92 98.62,146.4 104.21,146.4 108.01,142.6 109.6,142.6 110.67,141.53 116.78,141.53 117.41,140.89 129.24,140.89 129.63,140.5 138.08,140.5 140.61,143.03 140.61,145.76 140.35,146.02 140.35,147.53 v2(140.35,147.53)
  BOTTOM w0.114: v2(140.35,147.53) 140.39,147.58 143,147.58 143.96,148.54 143.96,152.23 145.6,153.86 v2(145.6,153.89)
TBT_TDI: length 73.6
  TOP w0.089: UT1.Y4 v2(145.6,151.94)
  TOP w0.114: v3(98.02,154.9) 97.55,154.9 v2(96.98,154.33) 96.6,153.95 96.6,152.81 96.81,152.59 JTAG.2 ; v2(139.4,147.15) 139.39,147.16 139.39,148 RT9.2
  IN3 w0.124: v2(96.98,154.33) 97.23,154.08 97.23,151.79 97.61,151.41 97.61,148.04 98.81,146.85 104.4,146.85 108.15,143.1 109.99,143.1 110.75,142.34 117.18,142.34 117.76,141.77 129.55,141.77 130.08,141.25 138.19,141.25 139.4,142.45 v2(139.4,147.15)
  BOTTOM w0.114: v2(145.6,151.94) 144.89,151.24 144.89,148.45 142.63,146.18 141.31,146.18 140.77,145.63 139.92,145.63 139.48,146.07 139.48,147.07 v2(139.4,147.15)
TBT_TDO: length 75.4
  TOP w0.102: v2(145.6,152.59) UT1.W4
  TOP w0.114: v2(142.18,146.59) 142.18,146.79 v3(141.8,147.16) 141.16,147.8 RT6.2 ; v2(95.2,153.76) 95.2,150.14 95.75,149.59 JTAG.5
  IN3 w0.124: v2(142.18,146.59) 140.84,145.25 140.84,142.94 138.17,140.27 129.5,140.27 129.16,140.61 117.34,140.61 116.68,141.27 109.74,141.27 109.18,141.83 108.45,141.83 104.11,146.17 98.53,146.17 96.87,147.83 96.87,151.19 95.94,152.12 95.94,153.02 v2(95.2,153.76)
  BOTTOM w0.114: v2(145.6,152.59) 144.65,151.65 144.65,148.55 142.7,146.59 v2(142.18,146.59)
TBT_TEST_EN: length 6.7
  TOP w0.114: RT17.1 139.93,157.15 v1(140.16,157.38) ; 141.25,156.5 142.36,157.61 142.36,157.94 143.17,158.75 144.1,158.75 UT1.E1
  TOP w0.127: 141.25,156.5 140.53,156.5 140.25,156.22 RT17.1
TBT_TEST_PWG: length 2.7
  TOP w0.102: UT1.AB5 146.18,150.69 146.18,150.63 146.18,150.16 145.57,149.55 145.57,149.3 RT18.1
TBT_TMS: length 73.7
  TOP w0.102: UT1.V4 145.27,152.92 v2(145.6,153.24)
  TOP w0.114: JTAG.3 96.54,151.59 96.34,151.79 v2(96.34,154.33) ; v2(139.96,146.14) 139.96,146.18 139.89,146.24 v3(139.89,146.76) RT8.2
  IN3 w0.124: v2(139.96,146.14) 140.03,146.07 140.03,142.77 138.1,140.84 129.89,140.84 129.26,141.48 117.64,141.48 117.01,142.11 110.63,142.11 109.91,142.83 108.1,142.83 104.3,146.62 98.71,146.62 97.36,147.98 97.36,151.34 96.6,152.1 96.6,154.08 v2(96.34,154.33)
  BOTTOM w0.114: v2(139.96,146.14) 140,146.14 140.25,145.88 140.68,145.88 142.09,147.3 143.07,147.3 144.41,148.65 144.41,152.06 v2(145.6,153.24)
TBT_TMU_CLK_OUT: length 3.2
  TOP w0.089: 142.99,152.85 143.01,152.85 143.14,152.99 144.34,152.99 UT1.V2
  TOP w0.114: 142.99,152.85 142.7,152.56 T2.1 142.5,152.56 142.21,152.85 RT34.1
TBT_XTAL_25_IN: length 9.6
  TOP w0.089: UT1.D22 154.01,159.43 154.42,159.43 155.52,160.54
  TOP w0.127: YT1.1 161.98,160.82 161.13,159.97 158.87,159.97 158.52,160.32 CT37.1 158.2,160.61 157.99,160.61 157.86,160.74 v1(155.73,160.74) 155.52,160.54
TBT_XTAL_25_OUT: length 6.4
  TOP w0.089: UT1.D23 154.44,159.2 155.05,159.81 155.52,159.81
  TOP w0.127: YT1.3 158.82,159.12 CT38.1 158.17,159.77 157.93,159.77 157.59,160.11 v1(156.95,160.11) 155.99,160.11 155.69,159.81 155.52,159.81
TBTA_CC1: length 56
  TOP w0.114: v1(125.88,158.66) 126.11,158.43 126.29,158.43 v2(126.39,158.53)
  TOP w0.254: v2(157.67,166.2) 157.88,166.2 DT11.1
  IN4 w0.254: v2(127.97,156.68) 128.17,156.88 128.17,158.16 127.93,158.41 126.51,158.41 v2(126.39,158.53)
  IN5 w0.508: v2(126.39,158.53) 126.37,158.54 126.37,158.72 126.98,159.33 130.29,159.33 130.71,159.75 131.35,159.75 132.9,161.3 132.9,161.93 134.71,163.74 134.71,164.63 135.14,165.06 135.14,166.08 136.18,167.12 137.2,167.12 138.13,168.05 140.65,168.05 141.17,167.52 146.16,167.52 146.75,166.93 147.35,166.93 148.57,165.71 152.25,165.71 152.82,166.28 157.59,166.28 v2(157.67,166.2)
  BOTTOM w0.254: v2(126.39,158.53) 127.82,158.53 128.21,158.14 128.21,157.36 127.97,157.12 v2(127.97,156.68) ; UT4.L9 127.55,154.42 128.47,155.35 CT112.1
  BOTTOM w0.279: 158.83,170.37 158.5,170.7 JUSBC1.A5
  BOTTOM w0.305: 158.83,170.37 158.83,169.06 158.18,168.41 158.02,168.41 157.91,168.31 ; v2(127.97,156.68) 127.97,156.37 128.27,156.07 CT112.1
  BOTTOM w0.508: v2(157.67,166.2) 157.69,166.23 157.69,168.09 157.91,168.31
TBTA_CC2: length 51.2
  TOP w0.203: v2(159.93,172.06) 159.93,172.22 159.56,172.59 DT12.1
  IN1 w0.508: v2(131.46,163.23) 131.46,160.96 130.48,159.98 130.48,158.39 v2(130.85,158.03)
  IN5 w0.508: v2(159.93,172.06) 159.93,172.75 159.64,173.04 157.66,173.04 156.22,171.6 156.22,171.04 154.38,169.2 152.69,169.2 151.61,168.12 147.14,168.12 146.64,168.63 142.34,168.63 140.81,170.17 135.83,170.17 134.23,168.57 134.23,167.65 132.77,166.19 132.77,165.76 131.46,164.45 v2(131.46,163.23)
  BOTTOM w0.203: 128.36,154.28 128.05,153.97 UT4.L10
  BOTTOM w0.279: JUSBC1.B5 159.75,172.42 159.93,172.24 v2(159.93,172.06)
  BOTTOM w0.508: 128.36,154.28 128.77,154.68 129.19,154.68 129.7,155.2 129.7,155.55 130.21,156.07 CT113.1 130.96,156.07 131.27,156.37 131.27,156.89 131.4,157.02 v1(131.4,157.5) 131.37,157.5 v2(130.85,158.03)
TBTA_DEBUG1: length 2.9
  BOTTOM w0.089: UT4.L2 124.05,153.67 123.84,153.88 123.84,154.47
  BOTTOM w0.102: 123.84,154.47 123.41,154.9 123.41,155.17
  BOTTOM w0.114: 123.41,155.17 123.41,155.49
  BOTTOM w0.127: RT71.1 123.41,155.66 123.41,155.49
TBTA_DEBUG2: length 3.4
  BOTTOM w0.076: 123.14,155.12 123.14,154.9 123.67,154.36 123.67,153.81 123.8,153.69 123.8,153.33 UT4.K2
  BOTTOM w0.114: 123.14,155.12 v1(123.09,155.17)
  BOTTOM w0.127: v1(123.09,155.17) 123.09,155.81 RT72.1
TBTA_DIG_AUD_N: length 3.5
  BOTTOM w0.076: 124.3,153.76 124.3,153.38 124.55,153.13 UT4.K3
  BOTTOM w0.089: 124.56,155.35 124.5,155.29 124.47,155.29 124.04,154.86 124.04,154.4 124.3,154.14 124.3,153.76
  BOTTOM w0.114: 124.56,155.35 124.78,155.57 RT69.1
TBTA_DIG_AUD_P: length 3.3
  BOTTOM w0.089: UT4.L3 124.55,153.76 124.48,153.83 124.48,154.21 124.22,154.48 124.22,154.79 124.47,155.04 124.59,155.04 124.73,155.17
  BOTTOM w0.114: 124.73,155.17 125.58,156.02 RT68.1
TBTA_HPD: length 28.9
  TOP w0.102: UT1.M4 v2(145.6,155.84)
  TOP w0.114: RT41.1 137.27,154.07 136.92,153.71 136.92,153.72 v2(136.91,153.72)
  IN2 w0.097: v2(136.91,153.72) 133.87,150.69 133.87,150.01 131.83,147.97 131.83,147.51 v2(132.81,146.53)
  IN4 w0.137: v2(132.81,146.53) 132.64,146.7 129.52,146.7 129.16,147.06 v2(128.72,147.06)
  IN5 w0.097: v2(145.6,155.84) 145.37,156.07 142.89,156.07 142.53,155.71 138.97,155.71 136.99,153.72 v2(136.91,153.72)
  BOTTOM w0.076: 127.42,148.07 127.8,148.45 127.8,149.33 UT4.C10
  BOTTOM w0.089: 127.42,148.07 127.42,147.59 127.64,147.36
  BOTTOM w0.114: v2(128.72,147.06) 128.56,146.9 128.11,146.9 127.64,147.36
TBTA_I2C_INT: length 41.5
  TOP w0.102: UT1.J4 v2(145.6,157.14)
  IN5 w0.097: v2(123.12,149.71) 123.57,149.71 124.28,149 127.78,149 128.44,149.66 129.8,149.66 130.47,148.98 136.38,148.98 137.79,150.39 137.79,152.06 136.49,153.35 136.49,153.99 136.62,154.11 137.07,154.11 138.86,155.9 142.44,155.9 144.08,157.54 145.25,157.54 145.6,157.19 v2(145.6,157.14)
  BOTTOM w0.114: v2(145.6,157.14) 145.15,156.7 145.15,154.84 144.17,153.86 143.54,153.86 143.18,154.22 142.72,154.22 v1(141.81,153.3) 141.76,153.25 140.53,153.25 139.54,154.24 RT32.2 ; v2(123.12,149.71) 123.24,149.58 UT4.C1
TBTA_I2C_SCL1_R: length 4.5
  BOTTOM w0.076: 125.3,147.36 125.3,148.83 UT4.B5
  BOTTOM w0.114: 125.3,147.36 125.3,147.12 v1(124.86,146.67) 124.81,146.63 124.81,146.3 RT60.2 RT57.2
TBTA_I2C_SDA1_R: length 3.8
  BOTTOM w0.089: UT4.A5 125.55,147.36
  BOTTOM w0.114: 125.55,147.36 v2(125.55,146.81) 125.17,146.42 125.17,146.09 RT59.2 RT58.2
TBTA_LDO_BMC: length 2.7
  BOTTOM w0.203: CT98.1 121.43,150.04 121.9,150.51 123.28,150.51 123.36,150.58 UT4.E1
TBTA_LSRX: length 35.1
  TOP w0.089: 145.27,160.93 145.49,160.71 UT1.A4
  TOP w0.114: RT42.1 145.03,164.72 144.92,164.61 144.92,162.05 145.1,161.87 v2(145.1,161.46) 145.1,161.46 145.1,161.1 145.27,160.93
  IN5 w0.097: v2(124.63,154.6) 124.63,153.98 124.83,153.78 132.46,153.78 133.93,155.25 133.93,155.79 137.58,159.44 137.58,162.23 138.09,162.74 141.67,162.74 141.82,162.88 144.41,162.88 145.3,161.99 145.3,161.66 v2(145.1,161.46)
  BOTTOM w0.076: UT4.K4 124.8,153.33 124.8,153.82 124.68,153.94 124.68,154.55 v2(124.63,154.6)
  BOTTOM w0.114: v2(145.1,161.46) v1(145.1,160.92)
TBTA_LSTX: length 32.9
  TOP w0.089: UT1.A5 145.95,160.93
  TOP w0.114: v2(145.93,161.48) 145.93,160.95 145.95,160.93
  TOP w0.127: RT40.1 145.93,162.78 146.35,162.37 146.35,161.89 v2(145.93,161.48)
  IN5 w0.097: v2(145.93,161.48) 145.52,161.89 145.52,162.05 144.49,163.08 141.74,163.08 141.61,162.96 137.99,162.96 137.39,162.35 137.39,159.52 133.71,155.84 133.71,155.34 132.39,154.01 125.23,154.01 v2(125.05,154.19)
  BOTTOM w0.102: v2(125.05,154.19) UT4.L4
  BOTTOM w0.114: v2(145.93,161.48) 145.93,161.55 RT21.2 v1(145.09,163.32)
TBTA_MRESET: length 2.6
  BOTTOM w0.076: UT4.E11 128.83,150.58 128.97,150.44
  BOTTOM w0.127: 128.97,150.44 129.8,149.61 129.96,149.61 130.51,149.06 RT63.1
TBTA_ROSC: length 3.3
  BOTTOM w0.076: 122.5,151.96 122.88,151.96 123.01,151.83 123.8,151.83 UT4.G2
  BOTTOM w0.127: 122.5,151.96 121.68,151.96 121.54,152.1 RT75.1
TBTA_SBU1: length 58
  TOP w0.114: DT13.1 161.21,168.21 v2(161.25,168.17)
  IN5 w0.097: v2(161.25,168.17) 161.25,167.63 161.01,167.39 159.43,167.39 158.53,168.3 157.66,168.3 157.59,168.36 152.77,168.36 150.64,166.23 148.62,166.23 147.52,167.33 146.92,167.33 146.33,167.92 141.7,167.92 141.12,168.51 137.74,168.51 136.88,167.64 135.22,167.64 133.49,165.92 133.49,165.57 134.27,164.79 134.27,164.14 131.85,161.72 131.85,161.22 130.87,160.24 130.41,160.24 129.96,159.79 126.36,159.79 125.35,158.78 125.35,157.14 125.77,156.71 127.06,156.71 127.77,156 127.77,155.63 127.57,155.44 v2(127.57,155.21)
  BOTTOM w0.076: v2(127.57,155.21) 127.42,155.21 127.29,155.08 127.29,153.69 127.3,153.69 127.3,153.48 127.29,153.47 127.29,153.32 UT4.K8
  BOTTOM w0.114: JUSBC1.A8 160,170.7 159.65,170.35 159.65,168.95 159.87,168.73 v1(160.68,168.73) v2(161.25,168.17)
TBTA_SBU2: length 58.2
  TOP w0.114: v2(158.18,172.11) 158.48,172.41 DT14.1
  IN5 w0.097: v2(127.2,155.66) 127.25,155.61 127.43,155.61 127.55,155.73 127.55,155.91 126.96,156.49 125.68,156.49 125.13,157.04 125.13,158.88 126.26,160.01 129.87,160.01 130.32,160.46 130.77,160.46 131.62,161.31 131.62,161.81 134.05,164.23 134.05,164.69 133.27,165.48 133.27,166.01 135.12,167.87 136.78,167.87 137.65,168.73 141.21,168.73 141.8,168.15 146.42,168.15 147.01,167.56 147.61,167.56 148.71,166.45 150.54,166.45 152.68,168.59 157.68,168.59 157.75,168.52 158.62,168.52 158.7,168.44 158.8,168.44 158.93,168.57 158.93,170.06 158.43,170.55 157.88,170.55 157.75,170.41 157.75,170.03 157.62,169.9 157.43,169.9 157.3,170.03 157.3,171.49 157.44,171.64 158.13,171.64 158.26,171.76 158.26,172.02 v2(158.18,172.11)
  BOTTOM w0.076: v2(127.2,155.66) 127.27,155.6 127.27,155.41 127.13,155.27 127.13,153.66 UT4.L8
  BOTTOM w0.114: v2(158.18,172.11) 158.25,172.18 JUSBC1.B8
TBTB_I2C_INT: length 6.2
  TOP w0.089: UT1.E2 144.52,158.74 144.28,158.5 143.66,158.5
  TOP w0.114: RT33.2 139.97,155.46 140.67,156.16 v1(140.8,156.16) 141.23,156.16 142.58,157.51 142.58,157.85 143.23,158.5 143.66,158.5
TMDS_C_TX0N: length 2.5
  TOP w0.089: v2(187.92,157.78) 187.72,157.98 187.72,158.23 RX31.1
  BOTTOM w0.089: RV643.1 188.07,158.7 LV4.1 187.91,158.26 187.76,158.12 187.76,157.94 v2(187.92,157.78) 187.92,157.22 CV1060.1
TMDS_C_TX0P: length 2.5
  TOP w0.089: v2(187.29,157.78) 187.43,157.92 187.43,158.27 RX32.1
  BOTTOM w0.089: RV646.1 187.24,158.7 LV4.4 187.41,158.26 187.5,158.17 187.5,157.99 v2(187.29,157.78) 187.29,157.22 CV1059.1
TMDS_C_TX1N: length 2.5
  TOP w0.089: RX35.1 182.13,158.1 182.13,158.01 182.34,157.8 v2(182.35,157.8)
  BOTTOM w0.089: CV1062.1 182.35,157.8 v2(182.35,157.8) 182.32,157.83 LV5.1 182.49,158.7 RV642.1
TMDS_C_TX1P: length 2.4
  TOP w0.089: v2(181.75,157.8) 181.75,157.88 181.89,158.02 181.89,158.34 RX36.1
  BOTTOM w0.089: CV1061.1 181.71,157.65 181.75,157.69 v2(181.75,157.8) 181.82,157.87 LV5.4 181.65,158.7 RV639.1
TMDS_C_TX2N: length 2.5
  TOP w0.089: v2(180.23,157.93) 180.09,158.07 180.09,158.41 RX37.1
  BOTTOM w0.089: CV1064.1 180.25,157.91 v2(180.23,157.93) 180.18,157.98 180.18,158.16 180.35,158.33 LV6.1 180.52,158.83 RV645.1
TMDS_C_TX2P: length 2.5
  TOP w0.089: v2(179.64,157.92) 179.85,158.12 179.85,158.42 RX38.1
  BOTTOM w0.089: RV638.1 179.68,158.83 LV6.4 179.85,158.13 v2(179.64,157.92) 179.61,157.89 CV1063.1
TMDS_C_TXCN: length 2.6
  TOP w0.089: RX33.1 184.67,158.1 184.67,157.95 184.89,157.73 v2(184.91,157.73)
  BOTTOM w0.089: RV641.1 185.03,158.63 LV3.1 184.86,157.78 v2(184.91,157.73) 184.69,157.52 184.69,157.34 CV1057.1
TMDS_C_TXCP: length 2.5
  TOP w0.089: v2(184.32,157.73) 184.43,157.84 184.43,158.22 RX34.1
  BOTTOM w0.089: CV1058.1 184.26,157.14 184.45,157.34 184.45,157.6 v2(184.32,157.73) 184.36,157.76 LV3.4 184.19,158.63 RV640.1
TMDS_CTRLCLK_R: length 17.9
  IN2 w0.089: v2(173.94,164.78) 174.44,164.28 175.81,164.28 178.38,166.86 184.21,166.86 JHDMI.15
  BOTTOM w0.089: v2(173.94,164.78) 172.44,164.78 RV651.1
TMDS_CTRLDAT_R: length 16.4
  IN5 w0.089: JHDMI.16 183.38,163.98 v2(177.12,163.98)
  BOTTOM w0.089: v2(177.12,163.98) 172.6,163.98 RV650.1
TMDS_L_TX0N: length 3.6
  BOTTOM w0.089: RV643.2 188.07,159.61 LV4.2 187.91,160.11 187.77,160.25 187.77,160.53 RV501.2 188.05,161.05 187.85,161.25 187.85,161.89 187.66,162.08 187.66,162.09 RV27.1
TMDS_L_TX0P: length 3.3
  BOTTOM w0.089: RV646.2 187.24,159.61 LV4.3 187.41,160.05 187.53,160.17 187.53,160.41 RV501.1 187.14,160.84 187.61,161.31 187.61,161.79 187.49,161.91 187.31,161.91 187.16,161.76 RV28.1
TMDS_L_TX1N: length 3.9
  BOTTOM w0.089: RV29.1 182.2,162.22 182.2,161.99 182.25,161.94 182.25,161.2 182.25,161.2 182.53,160.92 RV502.2 182.2,160.48 182.2,160.23 182.32,160.11 LV5.2 182.49,159.61 RV642.2
TMDS_L_TX1P: length 3.2
  BOTTOM w0.089: RV30.1 181.64,162.02 181.82,162.02 182.01,161.84 182.01,161.3 181.61,160.91 RV502.1 181.94,160.48 181.94,160.3 181.82,160.18 LV5.3 181.65,159.61 RV639.2
TMDS_L_TX2N: length 4.1
  BOTTOM w0.089: RV645.2 180.52,159.74 LV6.2 180.35,160.18 180.22,160.31 180.22,160.6 RV503.2 180.16,161.33 180.16,161.44 v4(179.74,161.87) 179.54,162.07 178.98,162.07 RV33.1
TMDS_L_TX2P: length 3.6
  BOTTOM w0.089: RV638.2 179.68,159.74 LV6.3 179.85,160.17 179.98,160.3 179.98,160.6 RV503.1 179.92,161.21 179.92,161.34 179.43,161.83 178.98,161.83 RV34.1
TMDS_L_TXCN: length 3.8
  BOTTOM w0.089: RV641.2 185.03,159.55 LV3.2 184.74,159.84 184.74,160.16 RV500.2 185.32,160.86 185.12,161.06 185.12,161.89 184.42,162.58 RV673.1
TMDS_L_TXCP: length 3.3
  BOTTOM w0.089: RV674.1 184.58,161.9 184.76,161.9 184.88,161.79 184.88,161.33 184.41,160.86 RV500.1 184.48,160.67 184.48,160.24 184.36,160.11 LV3.3 184.19,159.55 RV640.2
TMDS_R_TX0N: length 12.9
  BOTTOM w0.089: RV27.2 185.97,162.31 185.97,162.32 185.85,162.32 185.69,162.48 185.69,162.9 186.06,163.27 186.78,163.27 v4(187.4,163.89) 187.7,164.19 187.7,166.38 187.01,167.08 181.86,167.08 181.73,167.2 181.73,167.38 JHDMI.9
TMDS_R_TX0P: length 13.4
  BOTTOM w0.089: RV28.2 185.87,162.08 185.75,162.08 185.45,162.38 185.45,163 185.96,163.51 v4(186.17,163.51) 186.68,163.51 187.46,164.29 187.46,166.28 186.91,166.83 181.76,166.83 181.49,167.1 181.49,167.36 JHDMI.7
TMDS_R_TX1N: length 4.4
  BOTTOM w0.089: JHDMI.6 180.23,165.83 180.23,164.36 180.1,164.24 180.1,162.71 180.23,162.59 180.41,162.59 RV29.2
TMDS_R_TX1P: length 4.9
  BOTTOM w0.089: JHDMI.4 179.98,165.82 179.98,164.46 179.86,164.34 v4(179.86,163.79) 179.86,162.61 180.13,162.35 180.26,162.35 RV30.2
TMDS_R_TX2N: length 7.3
  BOTTOM w0.089: JHDMI.3 178.66,167.31 178.66,167.16 178.3,166.8 178.03,166.8 177.74,166.51 v4(177.74,163.6) 177.74,163.33 177.18,162.77 177.18,162.14 177.24,162.08 177.42,162.08 RV33.2
TMDS_R_TX2P: length 7.6
  BOTTOM w0.089: RV34.2 177.41,161.84 177.14,161.84 176.94,162.04 176.94,162.87 177.5,163.43 177.5,166.61 177.93,167.04 178.2,167.04 178.41,167.26 178.41,167.44 JHDMI.1
TMDS_R_TXCN: length 4.6
  BOTTOM w0.089: RV673.2 183.45,162.57 183.2,162.32 183.1,162.32 183.01,162.41 183.01,162.95 183.22,163.16 v4(183.22,163.66) 183.22,165.82 JHDMI.12
TMDS_R_TXCP: length 5.1
  BOTTOM w0.089: JHDMI.10 182.98,165.82 182.98,163.26 182.77,163.05 182.77,162.31 183,162.08 183.07,162.08 RV674.2
TMDS_SCLF: length 6.4
  BOTTOM w0.089: v1(169.18,163.16) 169.18,161.89 169.77,161.29 RV651.2 169.3,160.72 QV96.3 169.54,160.18 169.78,159.94 169.78,157.9 RV649.1
TMDS_SDAF: length 4
  BOTTOM w0.089: RV653.1 170.82,158.25 171.2,158.63 QV96.6 170.7,159.37 170.7,161.18 RV650.2
TMDS_TX0N: length 89
  IN2 w0.089: v2(188.11,156) 187.95,155.84 182.45,155.84 181.61,156.68 177.66,156.68 177.37,156.39 177.37,151.76 174.27,148.66 174.27,144.23 171.11,141.06 171.11,135.16 171.78,134.49 171.78,107.1 173.11,105.77 173.11,94.69 176.66,91.15 178.41,91.15 178.73,91.47 181.66,91.47 182.04,91.85 v2(182.2,91.85)
  BOTTOM w0.089: v2(188.11,156) 187.96,155.85 187.8,155.85 187.67,155.98 187.67,156.36 CV1060.2 ; UG9.BF18 v2(182.2,91.85)
TMDS_TX0P: length 88.9
  IN2 w0.089: v2(188.11,155.42) 187.95,155.58 182.35,155.58 181.5,156.42 177.77,156.42 177.63,156.29 177.63,151.65 174.53,148.55 174.53,144.12 171.37,140.95 171.37,135.27 172.04,134.6 172.04,107.21 173.37,105.88 173.37,94.8 176.76,91.41 178.3,91.41 178.63,91.73 180.97,91.73 181.06,91.82 181.06,92.16 181.19,92.28 181.69,92.28 181.79,92.19 181.79,92.01 181.63,91.85 v2(181.5,91.85)
  BOTTOM w0.089: CV1059.2 187.43,156.49 187.43,155.88 187.7,155.61 187.91,155.61 v2(188.11,155.42) ; UG9.BG18 v2(181.5,91.85)
TMDS_TX1N: length 77
  IN2 w0.089: v2(181.5,92.65) 181.36,92.79 181.36,93.11 181.03,93.44 176.68,93.44 175.22,94.89 175.22,95.71 174.02,96.91 174.02,106.31 172.73,107.59 172.73,134.82 172.23,135.33 172.23,140.57 175.29,143.63 175.29,148.22 178.39,151.32 178.39,155.54 178.57,155.72 180.99,155.72 v2(181.25,155.46)
  BOTTOM w0.089: v2(181.25,155.46) 181.49,155.46 182.07,156.04 182.17,156.04 182.35,156.22 CV1062.2 ; UG9.BG20 v2(181.5,92.65)
TMDS_TX1P: length 77.1
  IN2 w0.089: v2(180.85,92.57) 180.97,92.57 181.1,92.7 181.1,93.01 180.93,93.18 176.57,93.18 174.96,94.78 174.96,95.6 173.76,96.8 173.76,106.2 172.48,107.49 172.48,134.72 171.97,135.22 171.97,140.68 175.03,143.74 175.03,148.33 178.13,151.43 178.13,155.64 178.46,155.98 181.18,155.98 v2(181.25,156.05)
  BOTTOM w0.089: v2(181.25,156.05) 181.52,156.05 181.56,156 181.69,156 181.83,156.14 181.83,156.44 CV1061.2 ; v2(180.85,92.57) 181.01,92.57 181.13,92.7 181.13,92.92 UG9.BH20
TMDS_TX2N: length 76.1
  IN2 w0.089: v2(182.8,92.65) 182.8,93.25 182.67,93.38 182.32,93.38 181.01,94.68 177.36,94.68 175.54,96.51 175.54,97.9 174.56,98.88 174.56,106.63 173.19,108 173.19,112.25 173.84,112.9 173.84,134.34 172.67,135.5 172.67,140.42 175.85,143.61 175.85,143.61 175.85,143.61 175.84,143.61 175.88,143.65 175.88,148.23 178.83,151.18 178.83,154.53 179.39,155.1 v2(180.12,155.1)
  BOTTOM w0.089: UG9.BF20 182.67,92.95 182.8,92.82 v2(182.8,92.65) ; v2(180.12,155.1) 179.72,155.1 179.59,155.23 v4(179.59,155.71) 179.59,155.92 179.75,156.08 179.96,156.08 180.25,156.37 CV1064.2
TMDS_TX2P: length 76.1
  IN2 w0.089: v2(180.12,154.52) 179.8,154.84 179.5,154.84 179.08,154.43 179.08,151.07 176.14,148.12 176.14,143.54 176.03,143.43 176.03,143.41 172.93,140.32 172.93,135.61 174.09,134.45 174.09,112.79 173.45,112.15 173.45,108.11 174.81,106.74 174.81,98.99 175.8,98.01 175.8,96.61 177.47,94.94 181.12,94.94 182.42,93.64 182.78,93.64 183.06,93.36 183.06,93.09 v2(183.5,92.65)
  BOTTOM w0.089: UG9.BE20 v2(183.5,92.65) ; v2(180.12,154.52) 179.78,154.86 179.62,154.86 179.35,155.13 179.35,156.1 179.61,156.36 CV1063.2
TMDS_TXCN: length 99.8
  IN2 w0.089: v2(182.8,90.55) 182.92,90.67 182.92,91.07 182.79,91.19 182.58,91.19 182.33,90.94 179.42,90.94 178.92,90.44 173.74,90.44 172.41,91.77 172.41,105.41 171.09,106.73 171.09,133.74 166.77,138.07 166.77,147.72 168.37,149.33 173.84,149.33 176.13,151.61 176.13,156.62 176.89,157.38 181.86,157.38 182.66,156.58 183.23,156.58 183.39,156.74 183.39,157.51 183.24,157.66 v2(183.07,157.66)
  BOTTOM w0.089: v2(183.07,157.66) 183.12,157.71 183.36,157.71 183.43,157.64 v4(183.43,156.98) 183.43,156.38 184.04,155.78 184.42,155.78 184.69,156.04 184.69,156.37 184.88,156.56 CV1057.2 ; UG9.BF17 182.67,90.85 182.8,90.72 v2(182.8,90.55)
TMDS_TXCP: length 100
  IN2 w0.089: v2(183.34,158.27) 183.33,158.25 183.33,157.94 183.42,157.85 183.65,157.62 183.65,156.63 183.34,156.32 182.56,156.32 181.75,157.12 177,157.12 176.39,156.51 176.39,151.51 173.95,149.07 168.48,149.07 167.02,147.61 167.02,138.18 171.35,133.85 171.35,106.84 172.67,105.52 172.67,91.88 173.84,90.7 178.81,90.7 179.31,91.2 182.22,91.2 182.47,91.45 182.9,91.45 183.18,91.17 183.18,90.68 183.31,90.55 v2(183.5,90.55)
  BOTTOM w0.089: UG9.BE17 v2(183.5,90.55) ; v2(183.34,158.27) 183.33,158.26 183.33,158.08 183.68,157.74 183.68,156.48 184.14,156.02 184.32,156.02 184.45,156.14 184.45,156.36 CV1058.2
TON_1.2V: length 2.7
  TOP w0.114: PR206.2 v1(58.12,49.17)
  TOP w0.203: PR206.2 58.87,50.12 59.08,50.33 PU201.9
TP_CLK: length 139.7
  TOP w0.114: UE5.87 92.27,22.27 92.1,22.45 v2(92.1,22.87) 91.9,23.07 91.9,23.58 RE100.2
  IN1 w0.097: v2(208.84,9.05) 208.97,9.18 208.97,9.36 208.84,9.49 205.56,9.49 204.71,8.63 193.37,8.63 188.58,13.41 185.88,13.41 184.2,15.1 181.64,15.1 180.16,16.58 177.66,16.58 176.51,17.72 173.83,17.72 173.49,17.38 172.31,17.38 172.04,17.65 170.7,17.65 168.83,19.52 168.41,19.52 167.4,20.53 165.9,20.53 161.18,25.25 157.18,25.25 155.75,26.68 142.34,26.68 141.82,26.15 125.38,26.15 124.35,25.12 119.72,25.12 119.13,25.71 108.13,25.71 106.93,26.9 92.68,26.9 91.92,26.14 91.92,23.03 92.05,22.9 92.05,22.9 92.09,22.87 v2(92.1,22.87)
  BOTTOM w0.114: v2(208.84,9.05) 209.06,8.83 209.06,8 208.82,7.76 208.04,7.76 207.77,8.02 207.77,9.79 207.57,9.99 207.57,10.8 207.7,10.92 JTP.12
TP_DATA: length 141.4
  TOP w0.114: UE5.88 91.87,22.23 91.69,22.42 91.69,22.71 v2(91.52,22.88) 91.64,23.01 91.64,23.44 RE101.2
  IN1 w0.097: v2(91.52,22.88) 91.53,22.88 91.57,22.92 91.57,22.92 91.7,23.04 91.7,26.24 92.61,27.15 107,27.15 108.22,25.93 119.23,25.93 119.81,25.34 124.25,25.34 125.28,26.38 141.73,26.38 142.25,26.9 155.85,26.9 157.27,25.48 161.27,25.48 165.99,20.76 167.49,20.76 168.51,19.75 168.92,19.75 170.79,17.88 172.13,17.88 172.4,17.61 173.4,17.61 173.74,17.95 176.6,17.95 177.75,16.8 180.25,16.8 181.73,15.32 184.3,15.32 185.98,13.64 188.67,13.64 193.46,8.85 204.61,8.85 205.47,9.71 208.93,9.71 209.19,9.45 209.19,9.27 209.41,9.05 v2(209.42,9.05)
  BOTTOM w0.114: v2(209.42,9.05) 209.3,8.92 209.3,7.9 208.92,7.52 207.94,7.52 207.53,7.92 207.53,9.69 207.33,9.89 207.33,10.78 207.2,10.91 JTP.13
TP_LED_B#: length 226.7
  TOP w0.114: v2(220.87,23.27) v1(220.41,23.72) ; v2(179.92,151.1) 179.94,151.1 179.95,151.09 UE3.14
  IN4 w0.137: v2(220.87,23.27) 220.85,23.28 220.85,26.57 223.64,29.36 225.79,29.36 230.21,33.78 230.21,34.93 235.37,40.1 241,40.1 249.63,48.72 255.48,48.72 257.89,51.14 257.89,55.1 260.77,57.98 260.77,61.58 259.09,63.26 259.09,66.45 256.43,69.11 252.43,69.11 249.44,72.1 249.44,78.83 245.38,82.89 245.38,87.15 245.48,87.25 245.48,138.35 240.49,143.34 201.56,143.34 199.85,145.06 197.12,145.06 195.98,146.2 195.98,148.47 194.83,149.61 194.83,151.09 194.39,151.54 189.5,151.54 189.07,151.1 v2(179.92,151.1)
  BOTTOM w0.114: Q28.5 221.5,20.47 221.95,20.92 221.95,21.82 R146.2 220.87,22.9 v2(220.87,23.27)
TP_LED_B#_DRV: length 3.1
  BOTTOM w0.114: Q28.3 223.15,19.82 223.03,19.95 223.03,20.34 223.15,20.47 Q28.2 224.22,20.47 R144.2 v1(224.36,21.54)
