# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CTX_PRX_P1: length 64.8
  IN1 w0.104: v2(145.98,87.92) 145.96,87.92 145.84,87.8 145.84,87.25 146.26,86.83 148.73,86.83 149.61,85.95 149.61,76.93 151.45,75.09 151.45,68.02 153.43,66.04 153.43,48.18 154.82,46.79 154.82,45.43 157.24,43.01 157.24,42.43 159.68,39.99 161.14,39.99 162.05,40.9 162.53,40.9 162.93,40.5 v2(163.13,40.5)
  BOTTOM w0.076: CPU1.C6 142.27,88.72 142.27,88.86 142.5,89.09 144.55,89.09 144.61,89.15 144.62,89.15
  BOTTOM w0.089: v2(163.13,40.5) 162.77,40.86 UH1.G24
  BOTTOM w0.127: 144.62,89.15 145.25,89.15 145.78,88.62 145.78,88.12 v2(145.98,87.92)
DMI_CTX_PRX_P2: length 63.3
  IN1 w0.104: v2(147.58,86.22) 147.52,86.22 147.4,86.09 147.4,85.07 149.01,83.46 149.01,76.68 150.85,74.84 150.85,64.96 151.53,64.29 151.53,62.15 152.83,60.84 152.83,47.89 153.43,47.29 153.43,44.76 154.22,43.97 154.22,43.74 158.62,39.33 160.94,39.33 161.33,38.95 162.68,38.95 162.8,39.08 162.8,39.28 162.59,39.5 162.41,39.5 v2(162.37,39.45)
  BOTTOM w0.076: 143.95,88.32 143.48,88.32 143.33,88.17 142.99,87.83 CPU1.B5
  BOTTOM w0.089: v2(162.37,39.45) 162.06,39.76 UH1.E26
  BOTTOM w0.127: 143.95,88.32 144.3,88.32 145.33,87.3 146.59,87.3 147.42,86.47 147.42,86.39 v2(147.58,86.22)
DMI_CTX_PRX_P3: length 66.7
  IN1 w0.104: v2(164.54,38.21) 164.54,38.24 164.68,38.38 164.86,38.38 164.98,38.25 164.98,37.95 164.79,37.75 161.48,37.75 161.28,37.55 160.43,37.55 159.23,38.76 158.19,38.76 153.62,43.34 153.62,43.72 152.83,44.51 152.83,47 152.23,47.6 152.23,60.56 150.25,62.54 150.25,74.59 148.41,76.43 148.41,83.02 145.81,85.63 145.81,85.81 145.95,85.95 v2(146.02,85.95)
  BOTTOM w0.076: CPU1.D4 142.25,87.42 142.8,87.42 142.93,87.55 143.98,87.55 144,87.58 144.02,87.58
  BOTTOM w0.089: UH1.K29 164.54,38.49 v2(164.54,38.21)
  BOTTOM w0.127: v2(146.02,85.95) 145.77,86.2 145.77,86.47 145.46,86.79 145.04,86.79 144.25,87.58 144.02,87.58
DMIC_CLK1_R: length 3.1
  BOTTOM w0.114: LA6.2 29.31,43.6 28.84,43.12 28.38,43.12 28.01,42.75 UA1.53
DMIC_DATA1_R: length 3.7
  BOTTOM w0.114: RA19.2 30.48,43.18 29.49,43.18 v1(29.12,42.81) 29.02,42.71 28.58,42.71 28.41,42.54 UA1.54
DP_AUXN_C: length 4.3
  BOTTOM w0.114: CV25.1 189.75,153.5 190.06,153.2 191.09,153.2 191.29,153.4 v1(191.29,153.5) 191.29,153.83 191.64,154.19 UV3.5
DP_AUXP_C: length 6
  BOTTOM w0.114: UV3.2 193.59,154.1 192.42,152.93 v1(189.75,152.93) 189.5,152.93 CV24.1
DP_CBL_DET: length 17.8
  IN2 w0.097: v2(198.34,161.49) 197.69,160.84 197.69,157.76 198.01,157.44 198.01,154.33 196.42,152.74 v2(193.82,152.74)
  BOTTOM w0.114: v2(193.82,152.74) 194.01,152.93 194.07,152.93 194.39,153.25 RV17.1 194.24,153.45 UV3.1 ; JDP.4 198.92,162.91 198.34,162.32 v1(198.34,162.09) v2(198.34,161.49)
DP_HPD_GPU#: length 136.3
  TOP w0.114: v1(191.1,150.85) RX5.2 192.31,150.58 v2(193.12,150.58) 193.9,150.58 QV97.6
  IN2 w0.097: v2(182.21,79.95) 180.71,78.45 176.1,78.45 175.21,79.34 175.21,82.6 170.51,87.3 170.51,103.85 169.11,105.24 169.11,133.95 164.03,139.03 164.03,153.44 167.08,156.49 168.74,156.49 169.59,157.34 169.59,159.72 170.76,160.89 172,160.89 174.2,163.09 187.34,163.09 189.94,160.49 189.94,159.35 190.9,158.39 190.9,155.28 192.42,153.75 192.42,153.57 191.78,152.93 191.78,151.92 v2(193.12,150.58)
  BOTTOM w0.114: v2(182.21,79.95) 182.62,79.95 182.83,80.16 182.83,80.39 182.89,80.44 182.89,80.5 183.2,80.81 UG9.BE3
DP_HPD_PCH: length 185.5
  TOP w0.089: v2(177.38,30.69) v1(177.97,30.69)
  TOP w0.114: UX1.1 193.18,154.92 RX4.1 193.18,155.92 v2(193.37,156.11)
  IN2 w0.097: v2(193.37,156.11) 193.37,157.89 190.32,160.93 189.94,160.93 187.53,163.35 174.13,163.35 171.87,161.09 170.68,161.09 169.39,159.8 169.39,157.42 168.71,156.74 167.02,156.74 163.78,153.5 163.78,138.92 168.86,133.84 168.86,105.14 170.26,103.74 170.26,87.27 172.61,84.92 172.61,84.1 174.96,81.75 174.96,66.57 177.89,63.64 177.89,61.86 177.59,61.56 v2(176.73,61.56)
  IN4 w0.089: 173.34,55.17 173.75,54.76 173.75,45.11 174.19,44.66 174.19,40.09 176.99,37.3 176.99,32.73 177.38,32.33 v2(177.38,30.69)
  IN4 w0.137: 173.34,55.17 171.06,57.45 171.06,60.84 171.59,61.37 176.54,61.37 v2(176.73,61.56)
  BOTTOM w0.089: UH1.AT44 v2(177.38,30.69)
  BOTTOM w0.114: v2(193.37,156.11) 193.37,157.12 193.7,157.45 195.4,157.45 195.63,157.68 QX2.3
DPSNK_RBIAS: length 2.6
  TOP w0.089: v2(151.45,151.94) UT1.Y18
  BOTTOM w0.114: v1(152.35,150.18) 151.64,150.89 RT19.1 151.45,151.41 v2(151.45,151.94)
DPSRC_RBIAS: length 1.4
  TOP w0.102: UT1.N6 v2(146.9,154.54)
  BOTTOM w0.114: v2(146.9,154.54) 146.34,155.1 RT5.1
EAPD#: length 8.7
  TOP w0.114: v2(28.88,48.29) DA3.2
  BOTTOM w0.114: UA1.52 27.61,43.89 RA22.1 28.96,45.24 RA21.2 28.75,45.78 28.52,45.78 28.14,46.16 28.14,47.55 v1(28.4,47.8) v2(28.88,48.29)
EC_1V8_AON_EN: length 98.2
  TOP w0.114: v2(86.56,58.44) v1(87.4,58.44) 88.55,58.44 91.96,61.85 92.83,61.85 93.58,62.6 93.58,63.09 RG552.1 ; UE10.22 117.64,11.39 v2(117.53,11.51)
  IN3 w0.124: v2(87.2,23.46) 87.58,23.07 87.58,22.44 87.91,22.11 89.69,22.11 89.82,22.24 99.7,22.24 99.7,22.24 102.65,22.24 103.87,23.46 108.48,23.46 109.52,24.51 115.98,24.51 116.59,23.9 v2(117.81,23.9)
  IN4 w0.137: v2(87.2,23.46) 87.26,23.52 87.26,24.35 85.23,26.38 85.23,27.9 85.54,28.21 85.54,30.47 85.03,30.98 85.03,38.92 84.58,39.37 84.58,41.84 85.15,42.41 85.15,54.6 85.61,55.06 85.61,57.45 86.56,58.4 v2(86.56,58.44)
  BOTTOM w0.114: v2(117.53,11.51) 119.48,13.46 121.45,13.46 122.29,14.3 122.29,16.29 117.81,20.78 v2(117.81,23.9)
EC_3V3_SYS_EN: length 3.5
  TOP w0.114: UE10.20 117.78,12.39 117.49,12.1 RG567.1 117.01,11.79 117.04,11.75 117.04,11.33 116.87,11.15 v1(115.99,11.15)
EC_AC_BAT#: length 204.5
  TOP w0.089: 182.56,78.19 182.56,78.76 182.44,78.89 181.81,78.89 181.69,79.02 181.69,81.64 v1(182.3,82.25) v2(182.8,82.75)
  TOP w0.114: 182.56,78.19 182.56,76.69 182.65,76.61 RG16.1 182.4,75.82 182.21,75.63 182.21,74.41 184.48,72.13 185.89,72.13 186.55,71.47 186.55,70.81 187.96,69.4 v2(188.38,69.4) ; UE6.9 65.3,7.18 64.73,7.75 64.73,8.67 65.56,9.5 65.56,9.92 65.12,10.36 v2(65.12,10.75)
  IN3 w0.124: v2(188.38,69.4) 188.94,68.85 188.94,67.09 188.03,66.19 188.03,55.88 187.63,55.48 187.63,54.14 187.8,53.97 187.8,37.79 188.74,36.85 188.74,25.69 187.8,24.75 185.66,24.75 182.72,21.8 179.35,21.8 178.22,20.67 155.51,20.67 154.51,21.68 150,21.68 149.53,21.2 146.41,21.2 145.51,20.3 123.35,20.3 122.51,19.46 116.73,19.46 115.74,20.45 112.68,20.45 111.51,21.63 110.31,21.63 110.08,21.4 110.08,20.11 105.81,15.84 98.82,15.84 98.12,15.14 94.31,15.14 88.85,9.68 87.58,9.68 86.44,8.53 72.15,8.53 69.74,10.95 67.07,10.95 66.44,10.31 65.55,10.31 65.12,10.74 v2(65.12,10.75)
  BOTTOM w0.1: UG9.BE6 v2(182.8,82.75)
EC_ESB_CLK: length 78
  TOP w0.114: UE10.1 119.16,8.61 v2(119.18,8.59) ; RE642.2 95.34,3.59 95.59,3.85 95.59,3.99 95.15,4.43 95.15,4.83 95.07,4.91 UE5.17 95.07,6.56 95.13,6.62 95.13,7 v2(95,7.14) ; v2(69.61,9.8) 69.15,9.34 UE6.1
  IN4 w0.137: v2(95,7.14) 95.16,6.98 95.16,6.26 94.95,6.06 83.45,6.06 78.9,1.5 68.9,1.5 68.09,2.32 68.09,2.82 66.63,4.28 65.04,4.28 63.84,5.48 63.84,7.06 65.11,8.33 68.2,8.33 68.48,8.61 68.48,8.67 v2(69.61,9.8)
  IN5 w0.097: v2(119.18,8.59) 119.64,9.05 119.64,9.21 119.49,9.36 112.66,9.36 110.91,7.61 101,7.61 100.28,6.89 96.74,6.89 96.28,6.44 95.46,6.44 95.2,6.7 95.2,6.93 v2(95,7.14)
EC_ESB_DAT: length 78.8
  TOP w0.114: UE10.4 120.66,8.89 v2(120.75,8.8) ; RE643.2 95.84,3.91 95.84,4.09 95.39,4.53 95.39,4.85 95.47,4.93 UE5.18 95.47,6.61 95.41,6.68 95.41,6.96 v2(95.58,7.14) ; v2(67.39,9.8) 67.65,9.55 UE6.4
  IN4 w0.137: v2(67.39,9.8) 68.21,8.98 68.21,8.72 68.09,8.6 65,8.6 63.58,7.17 63.58,5.37 64.93,4.01 66.52,4.01 67.82,2.71 67.82,2.21 68.79,1.24 79.01,1.24 83.56,5.79 95.06,5.79 95.42,6.15 95.42,6.98 v2(95.58,7.14)
  IN5 w0.097: v2(120.75,8.8) 120.21,8.8 119.86,9.15 119.86,9.3 119.58,9.58 112.57,9.58 110.82,7.83 100.9,7.83 100.19,7.12 96.64,7.12 96.19,6.66 95.55,6.66 95.42,6.79 95.42,6.98 v2(95.58,7.14)
EC_FBVDD/Q_EN: length 1.6
  TOP w0.114: UE10.16 120.16,14.96 RG570.2
EC_MUTE#: length 142.3
  TOP w0.114: v2(121.68,16.03) 121.68,15.14 123.14,13.68 123.14,12.66 122.87,12.39 UE10.11 ; v2(29.83,42.75) 29.88,42.8 v1(29.88,43.29) 29.88,45.11 30.18,45.41 DA3.3
  IN5 w0.097: v2(29.83,42.75) 29.55,42.47 29.55,35.76 28.91,35.12 28.91,33.68 28.22,33 28.22,28.01 30.49,25.74 30.49,25.1 29.07,23.68 29.07,18.02 29.82,17.27 32.81,17.27 33.88,16.19 33.88,13.04 34.93,11.99 38.83,11.99 42.16,8.66 54.3,8.66 55.43,7.54 65.9,7.54 68.48,4.95 69.7,4.95 70.33,4.32 74.71,4.32 75.45,3.58 80.34,3.58 83.64,6.88 93.61,6.88 94.76,8.03 99.96,8.03 100.98,9.04 110.63,9.04 117.17,15.58 121.43,15.58 121.68,15.84 v2(121.68,16.03)
EC_NVVDD1_EN: length 1.5
  TOP w0.114: RG568.2 120.66,15.04 UE10.15
EC_NVVDD2_EN: length 2.5
  TOP w0.114: UE10.19 117.66,12.89 117.47,12.71 RG569.2 117.01,12.94 117.17,13.11 v1(117.17,13.68)
EC_ON: length 61.4
  TOP w0.114: UE5.112 88,13.74 v2(88.4,14.14)
  TOP w0.254: PD100.2 34.92,21.49 v2(34.49,21.06)
  IN2 w0.097: v2(34.49,21.06) 36.03,19.52 36.03,18.7 36.49,18.24 43.1,18.24 44.27,17.07 45.53,17.07 49.12,13.48 65.25,13.48 65.72,13.95 76.03,13.95 76.51,14.44 79.83,14.44 80.09,14.69 84.14,14.69 84.31,14.86 87.45,14.86 88.17,14.14 v2(88.4,14.14)
  BOTTOM w0.114: v2(88.4,14.14) v1(88.4,13.6)
EC_PEX_VDD_EN: length 191.6
  TOP w0.114: v2(121.78,17.68) v1(121.11,17.68) 120.28,17.68 119.53,16.93 119.53,14.36 119.66,14.24 UE10.17
  IN2 w0.254: v2(161.76,156.42) 161.8,156.39 161.8,155.14 159.84,153.19 159.84,149.41 162.35,146.91 162.35,139.12 167.97,133.49 167.97,110.99 164.19,107.2 164.19,103.16 163.55,102.52 163.55,98.54 162.55,97.54 162.55,92.5 163.54,91.52 163.54,73.51 160.73,70.7 v2(160.73,67.21)
  IN5 w0.254: v2(121.78,17.68) 122.55,18.44 123.57,18.44 125.16,20.03 149.49,20.03 151.14,18.38 153.87,18.38 154.89,19.39 154.89,47.4 153.62,48.67 153.62,56.54 157.56,60.48 158,60.48 160.77,63.24 160.77,63.68 161.25,64.17 161.25,65.99 160.73,66.51 v2(160.73,67.21)
  BOTTOM w0.254: PR823.2 161.51,156.68 v2(161.76,156.42)
EC_RSMRST#: length 116.4
  TOP w0.089: v2(179.23,48.26) 179.49,48.51 v1(179.49,48.69) 179.49,48.72 179.35,48.86 179.15,48.86 179.04,48.96 RH88.2
  TOP w0.114: UE5.100 88.41,18.54 89.44,17.5 89.44,16.41 v2(90.25,15.6) ; v2(114,21.19) 114.19,21 114.19,20.53 113.81,20.15 DE2.2
  IN2 w0.097: v2(90.25,15.6) 90.34,15.6 91.17,16.43 91.17,16.91 92.6,18.34 101.45,18.34 101.86,18.74 107.12,18.74 107.69,19.32 110.9,19.32 112.77,21.19 v2(114,21.19) 114.33,21.19 117.61,24.47 118.89,24.47 119.27,24.09 136.73,24.09 137.59,24.96 141.16,24.96 143.28,27.08 144.35,27.08 148.16,30.89 148.16,33.49 148.67,34 152.35,34 154.31,35.95 154.31,39.32 154.83,39.84 155.65,39.84 155.84,39.65 157.41,39.65 159.08,41.32 160.3,41.32 161.29,42.31 165.62,42.31 166.56,43.25 171.96,43.25 173.46,44.76 174.08,44.76 174.24,44.6 175.91,44.6 178.15,46.84 178.6,46.84 178.86,47.1 178.86,47.88 v2(179.23,48.26)
  BOTTOM w0.089: v2(179.23,48.26) 179.25,48.26 179.75,47.76 UH1.BA11
EC_RTCRST: length 61.5
  TOP w0.114: v1(147.59,18.63) 147.22,18.26 RE650.1 147.18,17.51 QE5.2 147.18,16.18 v2(147.78,15.58) ; UE5.34 101.65,7.74 101.49,7.58 101.49,5.24 101.69,5.04 v2(101.69,4.49)
  IN3 w0.124: v2(101.69,4.49) 102.37,4.49 104.09,6.21 129.78,6.21 130.56,7 136.79,7 140.82,11.04 145.63,11.04 146.5,11.9 147.84,11.9 148.67,12.72 v2(148.67,12.85)
  BOTTOM w0.114: v2(148.67,12.85) 148.67,14.69 v2(147.78,15.58)
EC_RX: length 252.2
  TOP w0.114: v2(179.03,12.65) 179.03,12.42 179.61,11.85 180.02,11.85 180.86,11.02 213.88,11.02 214.43,11.57 214.43,13.43 215.91,14.9 220.97,14.9 221.62,14.25 223.58,14.25 223.81,14.48 223.81,15.09 222.89,16.01 222.63,16.01 221.57,17.08 v3(221.57,18.39) 221.92,18.74 221.92,20.31 v2(224.68,23.07) ; v2(100.12,18.77) 100.12,17.65 99.16,16.7 99.16,13.24 99.35,13.05 99.35,10.5 100.53,9.33 100.53,7.09 100.67,6.94 UE5.31
  IN1 w0.097: v2(100.12,18.77) 100.55,18.34 102.91,18.34 103.02,18.45 121.77,18.45 123.28,19.96 154.48,19.96 156.63,17.82 159.17,17.82 160.57,16.42 162.65,16.42 163.17,15.9 163.17,15.9 163.44,15.63 163.97,15.63 165.15,14.45 165.51,14.45 167.08,12.88 175.37,12.88 175.69,13.2 178.48,13.2 v2(179.03,12.65)
  IN4 w0.137: v2(224.68,23.07) 226.04,24.44 229.87,24.44 232.25,26.82 235.83,26.82 251.3,42.29 269.55,42.29 282.18,54.93 287.84,54.93 v2(292.15,59.24)
  BOTTOM w0.114: v2(292.15,59.24) 292.67,59.75 JWLAN.32 ; JEC.7 106.74,22.54 106.83,22.45 106.83,21.22 106.43,20.82 104.13,20.82 103.57,20.27 103.57,19.5 102.06,17.99 100.89,17.99 v2(100.12,18.77)
EC_SCI#: length 118
  TOP w0.089: RH521.2 175.16,29.11 175.65,29.59 175.65,31.32 175.96,31.64 175.96,35.76 v3(176.38,36.18) 177.15,36.94 177.15,37.46 178,38.31 178,39.33 v2(178.08,39.4)
  TOP w0.114: UE5.20 96.27,8.04 96.67,8.43 96.67,12.99 97.16,13.49 97.16,13.8 v2(97.07,13.9)
  IN2 w0.097: v2(178.08,39.4) 176.57,39.4 176.01,38.85 174.84,38.85 174.04,38.05 172.92,38.05 172.73,37.85 172.73,31.68 171.95,30.9 171.95,29.39 171.51,28.96 170.56,28.96 170.19,28.59 169.42,28.59 169.2,28.82 167.28,28.82 166.89,28.43 164.82,28.43 163.83,27.44 155.7,27.44 153.56,25.3 152.66,25.3 151.08,23.72 150.13,23.72 148.03,21.61 144.33,21.61 142.86,20.14 139.07,20.14 138.52,19.6 123.43,19.6 122.66,18.83 118.33,18.83 116.7,17.19 116.36,17.19 113.8,14.62 108.82,14.62 107.5,13.3 103.64,13.3 103,13.94 98.45,13.94 98.08,14.31 97.48,14.31 v2(97.07,13.9)
  BOTTOM w0.089: v2(178.08,39.4) 178.26,39.22 UH1.AV29
EC_SMB_CK1: length 102.9
  TOP w0.114: PR19.2 59.34,6.62 59.34,6.33 PD2.2 59.73,5.87 59.37,5.5 59.37,5.35 59.5,5.22 60.69,5.22 61.18,5.71 61.18,10.73 63.49,13.04 67.22,13.04 v2(67.39,13.21) ; v2(55.38,38.7) 55.53,38.85 55.77,38.85 PR721.2 ; v2(96.48,13.93) 96.31,13.76 96.13,13.76 96,13.89 96,14.24 96.52,14.76 96.52,18.05 96.2,18.37 96.2,20.43 96.27,20.5 UE5.77 96.27,22.4 96.22,22.46 96.22,23.36 95.2,24.37 95.2,25.85 93.48,27.57 92.08,27.57 RE92.2
  IN1 w0.097: v2(55.38,38.7) 55.54,38.85 56.62,38.85 56.83,39.06 61.75,39.06 61.95,38.86 64.96,38.86 67.45,36.37 67.45,14.82 68.24,14.03 68.24,13.2 68.09,13.04 67.56,13.04 v2(67.39,13.21)
  IN2 w0.097: v2(67.39,13.21) 67.59,13.01 68.69,13.01 68.88,13.2 76.48,13.2 76.63,13.35 87.24,13.35 88.2,12.39 92.01,12.39 93.34,13.72 96.18,13.72 96.18,13.73 96.28,13.73 v2(96.48,13.93)
EC_SMB_CK2: length 427.2
  TOP w0.114: v2(184.23,64.42) 183.8,64.85 182.59,64.85 180.89,63.15 177.72,63.15 176.97,63.9 176.45,63.9 175.69,64.67 160.6,64.67 v2(160.42,64.5) ; v2(88.26,25.98) 88.09,26.15 88.09,26.82 87.77,27.14 79.1,27.14 78.85,27.38 78.85,36.23 80.84,38.21 80.84,43.49 82.49,45.14 82.49,51.88 80.71,53.65 80.71,60.26 80.33,60.64 v2(80.33,60.92) ; v2(96.28,10.9) 96.12,10.74 95.81,10.74 95.63,10.92 95.63,13.18 95.26,13.55 95.26,14.55 95.78,15.07 95.78,17.64 95.39,18.04 95.39,20.3 95.47,20.38 UE5.79 95.47,22.43 95.39,22.51 95.39,23.14 94.43,24.1 94.43,25.52 94.02,25.93 92.65,25.93 v2(92.49,26.1) 92.31,25.93 92.07,25.93 RE94.2
  IN1 w0.097: v2(75.64,64.93) 75.38,64.93 75.18,64.73 75.18,64.3 78.18,61.3 79.69,61.3 80.08,60.92 v2(80.33,60.92) ; v2(160.42,64.5) 160.24,64.68 159.46,64.68 158.73,65.4 158.73,69.21 156.01,71.93 156.01,77.79 153.47,80.33 153.47,90.73 160.89,98.16 160.89,99.35 159.74,100.5 159.74,102.98 160.83,104.07 160.83,112.64 163.99,115.81 163.99,118.91 161.91,121 161.91,134.75 157.52,139.13 148.3,139.13 147.71,139.72 138.06,139.72 137.02,140.77 130.27,140.77 129.7,141.34 128.83,141.34 126.57,143.6 125.24,143.6 124.74,144.09 124.74,144.47 v2(124.54,144.68)
  IN2 w0.097: v2(92.49,26.1) 92.49,26.03 92.39,25.93 90.44,25.93 90.06,25.55 88.22,25.55 88.09,25.67 88.09,25.81 v2(88.26,25.98) ; v2(96.28,10.9) 96.44,10.74 99.21,10.74 99.84,10.12 112.56,10.12 117.22,14.78 137.71,14.78 139.5,16.57 143.32,16.57 144.75,18 148.1,18 151.14,21.04 152.38,21.04 v2(152.5,21.16) 152.65,21.01 156.25,21.01 158.35,23.11 166.36,23.11 167.09,23.84 172.04,23.84 173.08,24.88 173.46,24.88 173.93,25.35 174.39,25.35 174.69,25.04 174.91,25.04 175.08,25.22 v2(175.08,25.94)
  IN4 w0.137: v2(135.97,165.82) 135.97,165.63 135.52,165.19 133.68,165.19 133.1,165.77 130.81,165.77 130.17,166.4 127.25,166.4 126.62,167.04 119.54,167.04 117.7,165.2 117.06,165.2 116.46,164.6 116.46,161.74 109.35,154.63 109.35,150.53 109.78,150.1 110.15,150.1 v2(110.32,149.92) 110.47,150.07 111.57,150.07 112.33,150.84 115.71,150.84 121.29,145.25 124.54,145.25 124.67,145.12 124.67,144.81 v2(124.54,144.68)
  IN5 w0.097: v2(152.5,21.16) 152.32,20.98 152.04,20.98 151.84,21.17 151.84,22.06 152.32,22.53 152.95,22.53 154.13,23.71 154.13,40.03 152.99,41.17 152.99,56.73 157.43,61.17 157.81,61.17 159.65,63.02 159.65,64.46 159.87,64.68 160.24,64.68 v2(160.42,64.5)
  BOTTOM w0.114: v2(75.64,64.93) 75.38,64.93 73.81,63.36 73.81,63.17 U2407.10 ; v2(135.97,165.82) 136.16,166.01 136.16,166.19 RM89.1 ; v2(110.32,149.92) 110.04,150.2 RM99.1 ; v2(175.08,25.94) QH5.1 ; RT60.1 124.41,144.8 v2(124.54,144.68) ; QG6.3 184.78,64.67 184.66,64.79 184.36,64.79 184.23,64.67 v2(184.23,64.42)
EC_SMB_DA1: length 104.2
  TOP w0.114: v2(55.38,39.29) 55.58,39.09 55.77,39.09 PR720.2 ; PR21.2 59.1,6.62 59.1,6.3 PD2.3 58.73,5.9 59.13,5.5 59.13,5.25 59.4,4.98 60.79,4.98 61.42,5.61 61.42,10.63 63.59,12.8 67.22,12.8 v2(67.39,12.63) ; v2(96.48,13.35) 96.31,13.52 96.03,13.52 95.76,13.79 95.76,14.34 96.28,14.86 96.28,17.95 95.96,18.27 95.96,20.36 95.87,20.45 UE5.78 95.87,22.36 95.97,22.46 95.97,23.26 94.96,24.27 94.96,25.75 93.38,27.33 92.14,27.33 RE93.2
  IN1 w0.097: v2(55.38,39.29) 55.59,39.08 56.53,39.08 56.74,39.29 61.84,39.29 62.05,39.08 65.05,39.08 67.67,36.46 67.67,14.92 68.47,14.12 68.47,13.11 68.18,12.82 67.58,12.82 v2(67.39,12.63)
  IN2 w0.097: v2(67.39,12.63) 67.38,12.64 67.53,12.79 68.78,12.79 68.97,12.98 76.57,12.98 76.72,13.12 87.15,13.12 88.11,12.16 92.1,12.16 93.43,13.5 96.27,13.5 96.28,13.51 96.32,13.51 v2(96.48,13.35)
EC_SMB_DA2: length 431.2
  TOP w0.114: v2(79.92,60.51) 80.12,60.51 80.47,60.16 80.47,53.55 82.25,51.78 82.25,45.24 80.6,43.59 80.6,38.31 78.61,36.33 78.61,27.28 79,26.9 87.67,26.9 87.85,26.72 87.85,26.15 v2(87.68,25.98) ; RE95.2 92.07,25.68 92.31,25.68 v2(92.49,25.51) 92.66,25.69 93.92,25.69 94.18,25.42 94.18,24 95.15,23.04 95.15,22.51 95.07,22.43 UE5.80 95.07,20.43 95.15,20.35 95.15,17.94 95.54,17.54 95.54,15.17 95.02,14.65 95.02,13.45 95.39,13.08 95.39,10.82 95.71,10.5 96.09,10.5 v2(96.28,10.32) ; v2(160.42,65.08) 160.6,64.91 175.79,64.91 176.55,64.14 177.07,64.14 177.82,63.39 180.79,63.39 182.49,65.09 184.49,65.09 184.78,64.79 186.17,64.79 186.63,65.26 v2(186.63,65.26)
  IN1 w0.097: v2(160.42,65.08) 160.24,64.9 159.55,64.9 158.95,65.49 158.95,69.3 156.24,72.02 156.24,77.88 153.69,80.43 153.69,90.64 161.12,98.07 161.12,99.44 159.96,100.59 159.96,102.89 161.05,103.97 161.05,112.55 164.22,115.71 164.22,119.01 162.13,121.09 162.13,134.84 157.62,139.36 148.39,139.36 147.8,139.95 138.16,139.95 137.11,141 130.37,141 129.8,141.57 128.92,141.57 126.66,143.82 125.33,143.82 124.97,144.18 124.97,144.47 v2(125.17,144.68) ; v2(75.22,65.34) 75.22,65.09 74.96,64.82 74.96,64.21 78.09,61.08 79.6,61.08 79.92,60.76 v2(79.92,60.51)
  IN2 w0.097: v2(96.28,10.32) 96.48,10.52 99.12,10.52 99.74,9.9 112.65,9.9 117.31,14.56 137.8,14.56 139.59,16.35 143.41,16.35 144.84,17.78 148.2,17.78 151.24,20.82 152.25,20.82 v2(152.5,20.57) 152.71,20.78 156.35,20.78 158.45,22.88 166.45,22.88 167.18,23.62 172.13,23.62 173.17,24.66 173.55,24.66 174.02,25.12 174.3,25.12 174.45,24.97 174.45,24.62 174,24.17 v2(173.3,24.17) ; v2(92.49,25.51) 92.29,25.71 90.53,25.71 90.15,25.33 88.12,25.33 87.87,25.58 87.87,25.78 v2(87.68,25.98)
  IN4 w0.137: v2(125.17,144.68) 124.93,144.92 124.93,145.23 124.65,145.51 121.4,145.51 115.82,151.1 112.22,151.1 111.46,150.34 110.49,150.34 v2(110.32,150.51) 110.17,150.36 109.89,150.36 109.62,150.64 109.62,154.52 116.73,161.63 116.73,164.49 117.17,164.93 117.81,164.93 119.65,166.78 126.51,166.78 127.14,166.14 130.06,166.14 130.7,165.51 132.99,165.51 133.57,164.92 135.63,164.92 136.09,165.38 136.16,165.38 v2(136.6,165.82)
  IN5 w0.097: v2(160.42,65.08) 160.24,64.9 159.78,64.9 159.43,64.55 159.43,63.11 157.72,61.4 157.34,61.4 152.76,56.82 152.76,41.08 153.91,39.94 153.91,23.8 152.86,22.76 152.22,22.76 151.62,22.15 151.62,21.08 151.94,20.75 152.32,20.75 v2(152.5,20.57)
  BOTTOM w0.114: U2407.9 73.45,63.53 73.64,63.53 75.22,65.11 v2(75.22,65.34) ; QH5.4 173.64,24.64 173.3,24.3 v2(173.3,24.17) ; RT59.1 125.36,144.87 v2(125.17,144.68) ; v2(186.63,65.26) 186.21,65.26 186.08,65.39 QG6.6 ; v2(110.32,150.51) 109.74,151.09 RM100.1 ; RM90.1 136.67,166.53 136.4,166.27 136.4,166.03 v2(136.6,165.82)
EC_TX: length 253.8
  TOP w0.114: v2(178.45,12.64) 178.45,12.36 179.26,11.54 179.97,11.54 180.72,10.8 213.97,10.8 214.65,11.48 214.65,13.34 215.28,13.96 223.67,13.96 224.02,14.32 224.02,15.27 v3(222.62,16.67) 222.16,17.13 222.16,19.67 v2(225.63,23.14) ; UE5.30 100.28,5.72 100.28,9.26 99.14,10.41 99.14,12.96 98.95,13.15 98.95,16.79 99.52,17.36 v2(99.52,18.95) ; v2(292.87,59.25) 293.64,59.25 RM31.1
  IN1 w0.097: v2(99.52,18.95) 99.52,18.69 100.07,18.14 102.99,18.14 103.11,18.25 129.91,18.25 131.39,19.74 154.39,19.74 156.51,17.62 159.09,17.62 160.49,16.22 162.56,16.22 163.11,15.68 163.36,15.43 163.85,15.43 165.06,14.22 165.36,14.22 166.9,12.68 175.49,12.68 175.81,13.01 178.08,13.01 v2(178.45,12.64)
  IN4 w0.137: v2(225.63,23.14) 226.69,24.2 229.97,24.2 232.35,26.58 235.93,26.58 251.4,42.05 269.94,42.05 282.24,54.35 287.98,54.35 v2(292.87,59.25)
  BOTTOM w0.114: v2(292.87,59.25) JWLAN.30 ; v2(99.52,18.95) 100.22,19.65 100.66,19.65 100.91,19.4 100.91,18.56 101.22,18.25 101.97,18.25 103.35,19.63 103.35,20.39 104.03,21.06 106.33,21.06 106.58,21.32 106.58,22.31 106.24,22.65 JEC.6
ECAGND: length 118.9
  TOP w0.254: CE33.2 100.22,25.04 100.47,25.3 100.47,25.55 v2(100.47,25.55) 100.66,25.74 v3(101.56,25.74) 103.52,25.74 104.48,24.78 LE2.2 104.48,23.09 104.35,22.95 104.35,20.63 CE35.1 ; PH1.2 124.29,101 v2(124.42,101.13)
  IN4 w0.254: v2(124.42,101.13) 124.42,96.91 122.23,94.72 108.72,94.72 107.12,96.32 105.21,96.32 102.82,93.93 102.82,83.48 100.66,81.32 100.66,57 97.78,54.13 97.78,27.56 98.84,26.5 99.84,26.5 100.47,25.87 100.47,25.55 v2(100.47,25.55)
  BOTTOM w0.254: v2(100.47,25.55) 100.47,25.55 100.47,21.13 v2(99.45,20.11)
EDP_AUX#_C: length 1.8
  TOP w0.114: JEDP.14 132.1,159.52 132.24,159.38 132.24,158.42 CV13.1
EDP_AUX_C: length 1.8
  TOP w0.114: CV12.1 132.46,158.46 132.46,159.4 132.6,159.53 JEDP.13
EDP_HPD: length 111.8
  TOP w0.114: v2(132.25,161.56) 132.25,161.48 131.1,160.33 JEDP.16
  IN2 w0.097: v2(132.25,161.56) 133.81,161.56 137.14,164.88 139.92,164.88 142.5,167.47 147.28,167.47 148.65,166.1 155.71,166.1 156.75,165.06 167.82,165.06 169.19,163.69 169.19,157.5 168.75,157.06 166.89,157.06 163.55,153.72 163.55,138.81 168.61,133.76 168.61,110.73 165.05,107.17 v2(165.05,106.64)
  BOTTOM w0.114: v2(165.05,106.64) 164.67,106.26 v1(163.6,106.26) 162.26,106.26 162.04,106.04 UV21.44
EDP_HPD_CPU: length 88.2
  IN2 w0.097: v2(185.05,57.36) 184.79,57.11 178.89,57.11 178.64,56.86 177.62,56.86 176.93,57.56 176.93,58 176,58.93 175.36,58.93 174.42,59.87 171.14,59.87 170.16,60.85 167.28,60.85 164.86,63.27 158.38,63.27 158,63.66 158,70.71 156.2,72.5 156.2,77.85 153.97,80.08 153.97,107.75 v2(154.7,108.48)
  BOTTOM w0.114: v2(185.05,57.36) 185.7,56.72 185.7,55.92 185.04,55.26 v1(185.04,53.89) RH9.1 184.93,52.86 181.94,49.87 181.5,49.87 UH1.BD7 ; UV21.13 154.74,108.44 v2(154.7,108.48)
EDP_HPD_GPU: length 64.2
  TOP w0.114: RG519.1 177.6,74.78 177.07,74.25 176.26,74.25 176.25,74.26 174.74,74.26 174.74,74.25 174.42,74.25 174.41,74.26 172.47,74.26 v2(172.28,74.07) 171.91,73.7 171.91,72.66 165.77,66.52 163.36,66.52 163.06,66.82 160.49,66.82 v3(160.03,67.27) v2(159.4,67.91)
  IN2 w0.097: v2(154.72,104.44) 154.17,103.89 154.17,80.16 156.4,77.94 156.4,72.59 158.59,70.39 158.59,68.71 v2(159.4,67.91)
  BOTTOM w0.114: v2(172.28,74.07) 171.98,73.77 QG500.5 ; UV21.3 v2(154.72,104.44)
EDP_HPD_GPU#: length 7.8
  BOTTOM w0.114: RG555.2 RG556.2 174.91,78.38 174.44,77.91 174.44,77.13 173.78,76.47 173.78,74.93 173.66,74.81 v1(173.66,74.59) 173.75,74.5 RG500.2 173.37,73.68 172.63,74.43 QG500.3
EDP_RCOMP: length 7.8
  BOTTOM w0.089: RC30.1 v1(146.69,112.51)
  BOTTOM w0.152: CPU1.D37 141.48,111.08 141.76,111.35 141.76,111.93 141.9,112.07 142.41,112.07 143.14,112.8
  BOTTOM w0.254: 143.14,112.8 146.07,112.8 RC30.1
EDP_SW: length 238.1
  TOP w0.114: UE5.98 86.07,19.34 v2(85.85,19.13) ; v2(164.88,71.89) 164.26,72.51 164.26,85.4 158.64,91.02 v1(158.64,95.46) v2(158.64,101.94)
  IN2 w0.089: v2(178.82,33.12) 177.8,32.09 177.8,31.82 177.05,31.08 176.61,31.08 175.85,30.31 175.85,28.24
  IN2 w0.097: 175.85,28.24 175.85,28.16 173.1,25.41 172.79,25.41 172.3,24.93 171.7,24.93 171.1,24.32 157.8,24.32 155.01,21.53 150.96,21.53 148.31,18.88 144.96,18.88 143.18,17.11 139.36,17.11 138.5,16.25 122.96,16.25 121.96,15.26 117.02,15.26 112.52,10.76 106.53,10.76 106.37,10.92 99.9,10.92 99.14,11.68 95.55,11.68 93.92,10.05 87.46,10.05 v2(85.78,11.73) ; v2(166,128.37) 164.91,127.27 164.91,110.07 159.91,105.07 159.91,103.21 v2(158.64,101.94)
  IN4 w0.137: v2(85.85,19.13) 85.47,19.13 84.98,18.63 84.98,12.53 v2(85.78,11.73)
  IN5 w0.089: 168.01,55.17 168.95,54.23 168.95,51.63 170.17,50.42 170.17,48.03 170.69,47.51 170.69,45.53 171.25,44.98 173.97,44.98 174.43,44.51 174.43,40.05 178,36.48 178,34.16 178.18,33.99 178.18,33.23 178.3,33.12 v2(178.82,33.12)
  IN5 w0.097: v2(164.88,71.89) 164.22,71.23 164.22,70 164.1,69.87 164.1,59.08 168.01,55.17
  BOTTOM w0.089: UH1.AV44 178.11,31.53 178.11,31.92 178.51,32.32 178.51,32.8 v2(178.82,33.12)
  BOTTOM w0.114: UV21.54 158.67,101.99 158.64,101.96 v2(158.64,101.94) ; UV22.1 v2(166,128.37) 168.09,128.37 170.45,126.01 173.86,126.01 RV659.1
EDP_TX0#_C: length 29.5
  TOP w0.089: JEDP.2 138.1,160.56 138.15,160.62 138.29,160.62 138.36,160.68 138.36,161.03 136.52,162.88 133.14,162.88 132,164.01 125.29,164.01 124.45,163.17 118.91,163.17 118.55,162.81 118.55,162.66 118.37,162.48 118.22,162.48 118.04,162.3 118.04,162.16 117.86,161.98 117.72,161.98 117.54,161.8 117.54,161.66 117.36,161.48 117.22,161.48 117.04,161.3 117.04,161.15 116.86,160.97 116.72,160.97 116.53,160.79 116.53,160.65 116.35,160.47 116.21,160.47 115.99,160.25 115.99,159.59 116.11,159.47 116.11,159.23 115.99,159.12 115.99,158.88 116.11,158.76 116.11,158.52 115.99,158.41 115.99,158.07 CV2.1
EDP_TX0_C: length 29.5
  TOP w0.089: CV1.1 115.75,158.07 115.75,160.35 118.81,163.41 124.35,163.41 125.19,164.25 132.1,164.25 133.24,163.12 136.62,163.12 138.6,161.13 JEDP.1
EDP_TX1#_C: length 27.5
  TOP w0.089: CV4.1 117.01,156.61 v4(117.01,157.35) 117.01,159.93 119.44,162.36 119.98,162.36 120.07,162.27 120.33,162.27 120.42,162.36 120.69,162.36 120.78,162.27 121.04,162.27 121.13,162.36 121.4,162.36 121.49,162.27 121.76,162.27 121.84,162.36 122.11,162.36 122.2,162.27 122.47,162.27 122.56,162.36 122.82,162.36 122.91,162.27 123.18,162.27 123.27,162.36 123.53,162.36 123.62,162.27 123.89,162.27 123.98,162.36 124.79,162.36 125.64,163.2 126.11,163.2 126.21,163.11 126.47,163.11 126.56,163.2 126.82,163.2 126.92,163.11 127.18,163.11 127.27,163.2 130.45,163.2 131.59,162.06 135.76,162.06 136.86,160.97 136.86,160.68 136.81,160.63 136.66,160.63 136.6,160.57 JEDP.5
EDP_TX1_C: length 27.5
  TOP w0.089: JEDP.4 137.1,161.07 135.86,162.3 131.69,162.3 130.55,163.44 125.53,163.44 124.69,162.6 119.34,162.6 116.77,160.03 v4(116.77,158.71) 116.77,156.61 CV3.1
EDP_TX2#_C: length 1.8
  TOP w0.089: JEDP.8 135.1,159.24 135.23,159.11 135.23,158.41 CV6.1
EDP_TX2_C: length 1.8
  TOP w0.089: JEDP.7 135.6,159.24 135.47,159.11 135.47,158.47 CV8.1
EDP_TX3#_C: length 1.8
  TOP w0.089: JEDP.11 133.6,159.4 133.73,159.27 133.73,158.43 CV11.1
EDP_TX3_C: length 1.8
  TOP w0.089: JEDP.10 134.1,159.38 133.97,159.25 133.97,158.46 CV7.1
ELC_8051_C2CK_RST#: length 71.6
  TOP w0.114: v1(223.34,27.28) 222.71,26.64 v2(222.71,26.63) ; RE7.2 271.8,39.38 UE1.9 268.76,39.38 268.42,39.72 268.42,39.9 v2(268.43,39.9)
  IN1 w0.097: v2(222.71,26.63) 223.22,26.63 223.47,26.88 223.47,30.5 223.99,31.02 240.08,31.02 246.33,37.27 253.22,37.27 254.81,38.85 254.81,44.31 256.46,45.97 263.25,45.97 268.3,40.92 268.3,40.03 v2(268.43,39.9)
  BOTTOM w0.114: JELC.2 222.37,29.83 222.58,29.61 222.58,29.42 222.82,29.18 222.82,27.85 222.41,27.43 222.41,26.93 v2(222.71,26.63)
ELC_8051_C2D_P3: length 69.3
  TOP w0.114: v2(222.39,26.06) v1(222.96,26.06) ; v2(267.79,39.9) 268.28,40.38 269.15,40.38 269.36,40.18 UE1.10
  IN1 w0.097: v2(267.79,39.9) 267.79,41.05 263.09,45.74 256.55,45.74 255.03,44.22 255.03,38.76 253.32,37.04 246.42,37.04 240.17,30.8 224.08,30.8 223.79,30.5 223.79,26.76 223.09,26.06 v2(222.39,26.06)
  BOTTOM w0.114: v2(222.39,26.06) 222.19,26.26 222.19,27.52 222.49,27.82 222.49,28.57 222.02,29.03 JELC.3
ELC_EC#: length 289
  TOP w0.114: v2(175.27,156.11) 175.29,156.13 176.72,156.13 177.55,155.29 QE22.5 ; v2(167.34,155.92) 167.33,155.91 166.69,155.91 166.06,155.28 QE13.5 166.06,154.36 167.14,153.27 167.14,148.93 166.06,147.85 166.06,147.02 165.56,146.52 164.67,146.52 163.59,145.44 163.59,142.92 162.7,142.03 156.04,142.03 v1(155.91,142.16) 155.68,142.39 152.53,142.39 v2(152.14,142) ; UE10.6 v2(121.66,8.79) ; QE21.5 172.28,155.16 v2(172.01,155.43)
  IN1 w0.097: v2(79.07,23.71) 80.95,21.83 80.95,15.28 84.28,11.95 84.28,10.63 85.35,9.55 87.57,9.55 88.47,8.66 91.33,8.66 91.77,9.1 92.91,9.1 93.56,8.46 100.72,8.46 101.04,8.79 104.66,8.79 105.06,9.18 121.49,9.18 121.66,9.01 v2(121.66,8.79) ; v2(167.34,155.92) 167.91,155.92 168.1,155.73 168.73,155.73 169.28,155.18 171.76,155.18 v2(172.01,155.43) 173,156.42 173.98,156.42 174.1,156.55 174.66,156.55 175.1,156.11 v2(175.27,156.11)
  IN5 w0.097: v2(79.07,23.71) 79.07,23.96 76.77,26.26 76.77,46.67 79.3,49.21 79.3,54.74 85.08,60.52 85.08,90.12 86.6,91.64 86.6,133.18 87.18,133.75 87.18,134.62 86.65,135.15 86.65,140.64 88.64,142.63 93.53,142.63 94.07,143.17 96.37,143.17 96.52,143.01 97.78,143.01 97.78,143.02 101.53,143.02 102.88,144.36 111.12,144.36 113.17,142.31 131.2,142.31 132.38,143.5 135.36,143.5 136.51,142.34 136.95,142.34 138.04,143.44 143.72,143.44 145.16,142 152.14,142 v2(152.14,142)
EN_0.6VSP: length 4.7
  TOP w0.114: v1(58.12,53.96) PR209.2
  TOP w0.203: PU201.7 59.07,51.13 58.77,51.42 v2(58.72,51.42)
  TOP w0.254: v2(58.72,51.42) PR211.1 PR209.2
  BOTTOM w0.254: PC214.1 59.17,51.45 59.14,51.42 v2(58.72,51.42)
EN_1.2V: length 3.1
  TOP w0.203: PU201.8 v2(58.72,50.73)
  TOP w0.254: PR208.1 58.46,50.73 v2(58.72,50.73)
  BOTTOM w0.114: v1(58.24,50.89) 58.41,50.73 v2(58.72,50.73)
  BOTTOM w0.254: PC213.1 58.73,50.73 v2(58.72,50.73)
EN_+1VALWP: length 6.3
  TOP w0.114: 215.8,20.16 216.17,20.53 217.44,20.53 218.45,21.55 v1(218.45,21.87)
  TOP w0.254: PU300.3 214.81,20.12 215.71,21.02 PC300.1 215.8,21.02 PR300.2
EN_INVPWR: length 195
  TOP w0.114: v2(97.49,25.36) v1(98.62,24.23) 98.87,23.98 98.87,22.74 99.11,22.5 99.65,22.5 99.87,22.28 UE5.68 ; v2(116.69,153.76) 116.69,154.24 116.55,154.38 QV2.2
  IN5 w0.097: v2(116.69,153.76) 116.1,153.76 108.1,145.77 98.41,145.77 96.63,143.99 94.61,143.99 94.4,144.2 92.58,144.2 92.07,143.69 87.56,143.69 86.64,142.78 86.64,141.93 85.71,140.99 85.71,92.01 84.29,90.59 84.29,60.99 78.47,55.18 78.47,49.64 75.98,47.14 75.98,23.19 77.01,22.15 86.99,22.15 88.43,20.72 89.52,20.72 90.01,20.23 90.01,18.93 90.51,18.44 95.03,18.44 96.21,19.62 96.21,21.27 97.6,22.67 97.6,25.25 v2(97.49,25.36)
EN_TPLED: length 8.2
  TOP w0.254: Q2409.3 203.37,6.29 v1(204.17,5.49) 204.17,3.64 203.42,2.89 C2509.1 R180.1 R179.1 200.97,2.42 Q2410.1
EN_WOL#: length 337.7
  TOP w0.114: UE10.14 121.16,15.96 v2(121.1,16.03) ; v2(85.8,19.71) 85.67,19.57 RE79.2
  IN5 w0.097: v2(85.8,19.71) 82.57,19.71 81.8,20.47 77.57,20.47 75.18,22.86 75.18,47.62 77.68,50.12 77.68,55.65 83.42,61.39 83.42,90.99 84.91,92.48 84.91,143.06 86.62,144.76 88.71,144.76 89.42,145.48 92.43,145.48 93.39,146.44 108.18,146.44 116.15,154.4 118.86,154.4 120.04,155.59 120.04,156.4 124.09,160.45 129.5,160.45 129.96,160.91 130.58,160.91 130.97,161.3 130.97,162.16 130.61,162.52 130.61,164.45 131.99,165.83 131.99,166.54 133.63,168.18 133.63,169.28 136.43,172.08 140.99,172.08 141.9,172.99 145.76,172.99 146.43,172.32 146.43,169.83 147.32,168.93 151.38,168.93 153.41,170.97 153.41,173.12 155.38,175.09 162.75,175.09 164.82,173.02 164.82,168.06 165.53,167.35 165.53,166.22 167.52,164.23 167.52,161.41 167.26,161.15 167.26,159.1 172.09,154.26 172.09,151.2 175.85,147.44 175.85,142.26 v2(176.23,141.88)
  BOTTOM w0.114: v2(85.8,19.71) v1(86.95,19.71) 87.9,18.76 96.69,18.76 98.43,17.02 102.87,17.02 104.52,18.67 118.78,18.67 121.05,16.41 121.05,16.08 v2(121.1,16.03) ; v2(176.23,141.88) 176.23,142.07 182.89,148.74 191.71,148.74 CL42.1 191.9,149.35 191.91,149.35 UL2.4
ENBKL: length 221.9
  TOP w0.114: UE5.76 96.67,20.27 v2(97.81,19.14)
  IN2 w0.097: v2(87.64,62.44) 89.99,62.44 90.5,61.94 149.17,61.94 149.43,61.68 152.03,61.68 152.31,61.96 155.98,61.96 156.27,62.25 156.27,63.12 157.8,64.65 157.8,70.62 156,72.42 156,77.77 153.77,80 153.77,110.36 158.83,115.41 158.83,118.26 161.27,120.7 161.27,125.65 164.42,128.8 166.13,128.8 166.7,129.37 166.7,130.99 v2(166.03,131.66)
  IN5 w0.097: v2(97.81,19.14) 97.81,21.68 98.59,22.46 98.59,25.89 97.83,26.64 94.21,26.64 93.34,27.51 90.99,27.51 90.06,28.44 82.47,28.44 81.61,27.58 79.59,27.58 78.98,28.19 78.98,45.51 81.5,48.03 81.5,54 87.06,59.56 87.06,61.86 v2(87.64,62.44)
  BOTTOM w0.114: v2(97.81,19.14) v1(97.81,19.66) ; UV22.9 168.21,132.92 166.96,131.66 v2(166.03,131.66)
ENVDD: length 59.7
  TOP w0.114: v2(166.03,132.27) 165.39,132.27 v1(165.37,132.29)
  IN2 w0.097: v2(136.71,162.04) 136.98,161.77 136.98,158.22 137.52,157.68 137.52,153.02 137.05,152.55 136.61,152.55 135.52,151.47 135.52,146.46 140.1,141.88 151.27,141.88 152.14,141.01 155.03,141.01 157.62,138.42 157.62,134.33 158.38,133.56 164.73,133.56 v2(166.03,132.27)
  BOTTOM w0.114: v2(166.03,132.27) UV22.7 ; UV17.4 137.14,162.96 RV600.2 136.96,162.29 v2(136.71,162.04)
EQA0: length 5.2
  BOTTOM w0.114: RM81.2 RM84.2 96.94,145.07 v1(96.94,145.91) 96.94,146.38 96.24,147.08 96.24,148.26 96.39,148.4 UM8.20
EQA1: length 4.7
  BOTTOM w0.114: RM70.2 98.8,145.05 RM76.2 v1(98.24,145.88) 96.59,147.53 96.59,147.72 96.78,147.9 UM8.19
EQB0: length 5
  BOTTOM w0.114: v1(108.88,156.17) RM85.2 RM82.2 108.35,153.99 108.35,153.38 107.9,152.93 107.9,152.17 107.63,151.9 UM8.46
EQB1: length 4.2
  TOP w0.114: v2(108.28,151.98) v1(108.28,152.68)
  BOTTOM w0.114: UM8.47 107.76,151.4 108.28,151.93 v2(108.28,151.98) 108.28,152.93 108.47,153.12 108.88,153.12 RM26.2 RM23.2
FB_1.0VS_VGAP: length 3.9
  BOTTOM w0.254: PR804.2 PC809.2 165.51,157.42 PR805.1 165.12,155.84 PU800.14
FB_3V: length 4.2
  BOTTOM w0.114: v1(31.88,29.56) 31.82,29.56 31.14,28.89 PR101.2
  BOTTOM w0.203: PU100.4 31.85,27.95 31.57,27.67 PR103.2
  BOTTOM w0.254: PR103.2 PR101.2
FB_5V: length 4.2
  BOTTOM w0.203: PU100.2 32.4,27.15 32.14,26.89 32.14,25.76 31.89,25.51 PR102.1
  BOTTOM w0.254: PR104.1 31.83,25.01 PR102.1
FB_+1.8VGS: length 5.3
  BOTTOM w0.114: v1(244.21,153.31) PC816.2
  BOTTOM w0.254: PR811.1 240.88,154.05 PR810.1 242.29,154.05 PC816.2 242.57,152.85 PU802.6
FB_+1VALWP: length 4.2
  TOP w0.114: v1(215.39,23.79) 215.79,23.39 PR307.1
  TOP w0.254: PR307.1 PR308.1 215.19,21.37 215.19,21.04 214.77,20.62 PU300.4
FB_VDDQ_SENSE: length 118.4
  TOP w0.114: v1(258.29,66.06) 257.85,65.62 v2(257.54,65.62)
  TOP w0.203: 255.46,64.79 255.21,64.54 254.59,64.54 254.22,64.18 PU8200.12
  TOP w0.254: 255.46,64.79 PC8218.1 257.05,65 256.76,65.29 PR8209.1 256.82,65.75 257.41,65.75 v2(257.54,65.62)
  IN1 w0.254: v2(257.54,65.62) 257.54,67.17 257,67.72 257,69.05 255.98,70.06 253,70.06 249.32,73.75 249.32,88.02 247.14,90.2 247.14,90.96 246.58,91.52 246.58,122.58 240.68,128.48 234.2,128.48 v2(233.63,127.91)
  IN4 w0.254: v2(233.63,127.91) 227.79,122.07 v2(210.39,122.07)
  BOTTOM w0.2: UG9.E52 211.36,115.5 211.36,117.16 211.8,117.6 211.8,119.05 210.39,120.46 v2(210.39,122.07)
FBA_CLK0: length 35.2
  TOP w0.119: RG102.1 198.26,133.69 198.52,133.69 v2(198.71,133.88)
  IN5 w0.119: v2(200.61,135.58) 200.61,135.44 200.47,135.3 200.28,135.3 200.2,135.39 200.2,135.88 200.04,136.04 199.59,136.04 198.54,134.98 198.54,134.01 198.66,133.88 v2(198.71,133.88) 199.08,133.5 199.18,133.5 199.43,133.26 199.43,132.36 199.19,132.12 198.78,132.12 198.54,131.88 198.54,127.96 197.73,127.15 197.73,126.98 197.85,126.86 197.85,126.51 197.45,126.11 197.11,126.11 196.94,126.28 196.77,126.28 196.52,126.04 196.52,125.87 196.7,125.69 196.7,125.35 196.28,124.93 195.93,124.93 195.83,125.03 195.66,125.03 195.41,124.78 195.41,124.62 195.54,124.49 195.54,124.22 195.29,123.98 195.29,114.74 195.47,114.57 196.09,114.57 196.42,114.24 196.42,111.36 195.91,110.85 195.91,110.56 v2(195.5,110.15)
  BOTTOM w0.089: UG1.J12 v2(200.61,135.58)
  BOTTOM w0.119: UG9.AG45 v2(195.5,110.15)
FBA_CLK0#: length 35.3
  TOP w0.119: v2(198.71,133.3) 198.52,133.48 198.31,133.48 RG523.1
  IN5 w0.119: v2(195.5,110.85) 195.62,110.85 196.21,111.45 196.21,114.15 196.01,114.36 195.38,114.36 195.08,114.66 195.08,124.06 195.33,124.31 195.33,124.4 195.2,124.53 195.2,124.87 195.57,125.24 195.92,125.24 196.02,125.14 196.19,125.14 196.49,125.44 196.49,125.61 196.31,125.78 196.31,126.12 196.68,126.49 197.02,126.49 197.2,126.31 197.37,126.31 197.65,126.59 197.65,126.77 197.52,126.9 197.52,127.24 198.33,128.05 198.33,131.97 198.69,132.33 199.11,132.33 199.23,132.45 199.23,133.17 199.1,133.3 v2(198.71,133.3) 198.68,133.3 198.33,133.65 198.33,135.07 199.51,136.25 200.13,136.25 200.4,135.98 201.01,135.98 v2(201.41,135.58)
  BOTTOM w0.089: UG1.J11 v2(201.41,135.58)
  BOTTOM w0.119: UG9.AG46 v2(195.5,110.85)
FBA_CLK1: length 37.7
  TOP w0.119: v2(192.36,133.27) 192.57,133.48 193.01,133.48 RG103.1
  IN1 w0.119: v2(193.4,110.85) 193.4,110.66 193.58,110.48 193.74,110.48 193.87,110.61 193.87,113.83 192.61,115.09 192.61,124.99 192.49,125.11 191.5,125.11 191.26,125.35 191.26,125.89 191.5,126.13 192.49,126.13 192.61,126.25 192.61,126.6 192.49,126.72 191.49,126.72 191.25,126.97 191.25,127.5 191.49,127.74 192.49,127.74 192.61,127.86 192.61,131.95 193.07,132.41 193.07,133.51 192.93,133.65 192.74,133.65 v2(192.36,133.27) 191.77,133.86 191.77,134.59 191.95,134.77 191.95,135.05 191,136 189.64,136 189.52,135.87 189.52,135.7 189.64,135.58 v2(189.94,135.58)
  BOTTOM w0.089: UG2.J12 v2(189.94,135.58)
  BOTTOM w0.119: UG9.AK46 v2(193.4,110.85)
FBA_CLK1#: length 37.9
  TOP w0.119: RG524.1 192.93,133.69 192.53,133.69 v2(192.36,133.86)
  IN1 w0.119: v2(193.4,110.15) 193.52,110.27 193.83,110.27 194.08,110.52 194.08,113.91 192.82,115.17 192.82,125.08 192.58,125.32 191.59,125.32 191.47,125.44 191.47,125.8 191.59,125.92 192.58,125.92 192.82,126.16 192.82,126.69 192.58,126.93 191.57,126.93 191.45,127.05 191.45,127.41 191.57,127.53 192.58,127.53 192.82,127.77 192.82,131.87 193.28,132.33 193.28,133.6 193.01,133.86 v2(192.36,133.86) 192.07,133.86 191.98,133.95 191.98,134.51 192.16,134.68 192.16,135.14 191.09,136.21 189.56,136.21 189.31,135.96 189.31,135.74 v2(189.14,135.58)
  BOTTOM w0.089: UG2.J11 v2(189.14,135.58)
  BOTTOM w0.119: UG9.AK45 v2(193.4,110.15)
FBA_CMD0: length 33.8
  BOTTOM w0.089: 208.22,137.58 UG1.G3
  BOTTOM w0.142: 210.51,137.31 210.2,137.31 210.01,137.12 208.68,137.12 208.22,137.58 ; UG9.Y51 200.7,114.8 201.04,115.14 201.04,115.59 200.87,115.75 200.87,118.95
  BOTTOM w0.178: 200.87,118.95 200.7,119.12 200.7,120.18 201.7,121.18 206.53,121.18 208.16,122.81 208.16,124.3 212.18,128.32 212.18,135.69 210.56,137.31 210.51,137.31
FBA_CMD1: length 34.5
  TOP w0.178: RG47.2 211.08,137.31 209.55,137.31 v2(208.61,136.38)
  BOTTOM w0.142: UG1.J3 v2(208.61,136.38) 208.62,136.39 210.59,136.39 ; 200.4,118.84 200.62,118.62 200.62,115.43 UG9.Y52
  BOTTOM w0.178: 210.59,136.39 210.74,136.39 211.66,135.47 211.66,128.54 207.64,124.52 207.64,123.03 206.9,122.29 205.03,122.29 204.54,121.79 202.64,121.79 202.41,121.56 201.63,121.56 200.4,120.34 200.4,118.84
FBA_CMD2: length 33.2
  TOP w0.136: v2(209.41,135.58) 210.8,135.58 RG54.1
  BOTTOM w0.089: 209.45,135.53 v2(209.41,135.58) ; UG1.J2 209.01,135.98
  BOTTOM w0.142: 200.1,118.61 200.35,118.36 200.35,113.6 UG9.Y49 ; 209.45,135.53 210.48,135.53 210.59,135.43 ; 209.01,135.98 v2(209.41,135.58)
  BOTTOM w0.178: 200.1,118.61 200.1,120.42 201.65,121.97 202.26,121.97 202.6,122.31 204.32,122.31 204.82,122.81 206.68,122.81 207.12,123.24 207.12,124.73 211.14,128.75 211.14,134.88 210.59,135.43
FBA_CMD3: length 28.5
  BOTTOM w0.142: UG1.L3 208.58,134.75 210.02,134.75 210.1,134.67 ; UG9.AA52 200,118.17 199.78,118.39
  BOTTOM w0.178: 210.1,134.67 210.62,134.15 210.62,128.97 206.59,124.95 206.59,123.46 206.47,123.33 204.6,123.33 204.1,122.83 202.6,122.83 202.1,122.33 201.58,122.33 199.78,120.53 199.78,118.39
FBA_CMD4: length 25.6
  BOTTOM w0.142: UG1.K5 206.61,135.07 206.25,134.71 206.25,129.36 207.14,128.47 207.14,128.32 ; 199.39,118.26 199.73,117.92 199.73,115.88 199.64,115.8 199.64,115.21 200,114.85 UG9.AA51
  BOTTOM w0.178: 207.14,128.32 207.14,126.61 203.89,123.35 202.21,123.35 199.39,120.53 199.39,118.26
FBA_CMD5: length 28
  BOTTOM w0.142: 199.47,117.64 199.47,115.98 199.41,115.92 199.41,115.09 199.66,114.84 199.66,114.48 200,114.14 UG9.AA50 ; UG1.K4 207.25,135.18 206.9,135.53 206.2,135.53 205.96,135.29 205.96,129.23 206.62,128.57 206.62,128.32
  BOTTOM w0.178: 199.47,117.64 199.07,118.04 199.07,120.66 201.11,122.69 201.11,123.3 201.68,123.87 203.67,123.87 206.62,126.82 206.62,128.32
FBA_CMD6: length 27.6
  BOTTOM w0.142: UG1.J5 206.07,135.98 205.68,135.58 205.68,129.01 206.1,128.59 206.1,128.32 ; 199.18,117.43 199.18,115.04 198.95,114.81 198.95,114.3 UG9.AC50
  BOTTOM w0.178: 206.1,128.32 206.1,127.04 203.46,124.4 201.45,124.4 200.6,123.54 200.6,122.59 198.71,120.7 198.71,117.9 199.18,117.43
FBA_CMD7: length 28.4
  BOTTOM w0.142: UG1.J4 207.41,136.1 207.15,136.36 205.84,136.36 205.37,135.89 205.37,128.74 205.58,128.54 205.58,128.32 ; UG9.AC51 198.6,114.87 198.95,115.22 198.95,117.12 198.41,117.66
  BOTTOM w0.178: 205.58,128.32 205.58,127.25 203.24,124.92 201.09,124.92 200.03,123.85 200.03,122.44 198.41,120.82 198.41,117.66
FBA_CMD8: length 27.1
  BOTTOM w0.142: 198.1,117.47 198.6,116.97 UG9.AC52 ; UG1.H5 205.53,136.78 205.06,136.31 205.06,128.39
  BOTTOM w0.178: 198.1,117.47 198.1,120.92 199.51,122.33 199.51,124.07 200.88,125.44 203.02,125.44 205.06,127.47 205.06,128.39
FBA_CMD9: length 31
  BOTTOM w0.142: UG9.AC49 198.25,113.6 198.25,116.85 197.69,117.41 ; UG1.H4 207.01,137.18 205.37,137.18 204.78,136.59 204.78,128.56 204.54,128.32
  BOTTOM w0.178: 204.54,128.32 204.54,127.68 202.81,125.96 200.66,125.96 198.99,124.28 198.99,122.21 197.69,120.92 197.69,117.41
FBA_CMD10: length 29.3
  BOTTOM w0.142: 197.37,117.2 197.9,116.67 UG9.AD52 ; UG1.G12 201.01,137.48 201.31,137.18 203.34,137.18 204.47,136.05 204.47,128.77 204.01,128.32
  BOTTOM w0.178: 204.01,128.32 204.01,127.9 202.59,126.48 200.45,126.48 198.46,124.5 198.46,122.1 197.37,121 197.37,117.2
FBA_CMD11: length 27.8
  BOTTOM w0.142: 203.49,128.12 203.49,128.22 204.17,128.89 204.17,135.97 203.35,136.78 UG1.H10 ; 197.63,116.53 197.63,115.62 197.53,115.53 197.53,115.22 197.9,114.85 UG9.AD51
  BOTTOM w0.178: 203.49,128.12 202.38,127 200.23,127 197.94,124.71 197.94,122.02 197.09,121.17 197.09,117.07 197.63,116.53
FBA_CMD12: length 29.1
  BOTTOM w0.142: 202.55,127.91 202.74,127.91 203.87,129.04 203.87,135.84 203.35,136.36 202.39,136.36 201.97,136.78 UG1.H11 ; 197.35,116.42 197.35,115.78 197.3,115.74 197.3,115.1 197.55,114.85 197.55,114.45 197.9,114.1 UG9.AD50
  BOTTOM w0.178: 197.35,116.42 196.81,116.95 196.81,121.32 197.42,121.93 197.42,124.93 200.01,127.52 202.16,127.52 202.55,127.91
FBA_CMD13: length 28.1
  BOTTOM w0.142: 197.07,116.28 197.07,115.02 196.85,114.8 196.85,114.3 UG9.AF50 ; 202.16,128.04 202.35,128.23 202.62,128.23 203.58,129.2 203.58,134.94 202.92,135.6 202.23,135.6 UG1.K11
  BOTTOM w0.178: 197.07,116.28 196.51,116.84 196.51,121.46 196.9,121.86 196.9,125.14 199.8,128.04 202.16,128.04
FBA_CMD14: length 26.1
  BOTTOM w0.142: UG9.AF51 196.5,114.8 196.84,115.14 196.84,116.11 196.8,116.14 ; UG1.K10 202.85,135.18 203.3,134.72 203.3,129.3 202.64,128.64 202.23,128.64 201.92,128.33 199.35,128.33
  BOTTOM w0.178: 196.8,116.14 196.19,116.75 196.19,121.53 196.38,121.72 196.38,125.36 199.35,128.33
FBA_CMD15: length 26.7
  BOTTOM w0.142: UG9.AF52 196.5,116.08 195.86,116.72 195.86,125.58 ; 198.6,128.32 198.95,128.66 201.7,128.66 202.01,128.97 202.51,128.97 203.02,129.48 203.02,134.56 202.76,134.82 201.46,134.82 UG1.L12
  BOTTOM w0.178: 195.86,125.58 198.6,128.32
FBA_CMD16: length 35.8
  BOTTOM w0.089: 182.34,137.58 UG2.L3
  BOTTOM w0.142: UG9.AN50 191.6,114.1 191.25,114.45 191.25,114.84 191,115.09 191,115.63 191.07,115.7 191.07,117.96 ; 179.73,137.19 179.86,137.31 180.25,137.31 180.38,137.19 181.95,137.19 182.34,137.58
  BOTTOM w0.178: 191.07,117.96 190.23,118.8 184.71,118.8 177.92,125.6 177.92,135.37 179.73,137.19
FBA_CMD17: length 34.5
  TOP w0.089: v2(181.94,136.38) 182.02,136.45 RG48.2
  BOTTOM w0.142: UG9.AN51 191.6,114.85 191.25,115.19 191.25,115.51 191.35,115.6 191.35,118.06 190.09,119.32 ; UG2.J3 v2(181.94,136.38) 179.83,136.38
  BOTTOM w0.178: 179.83,136.38 179.66,136.38 178.44,135.16 178.44,125.82 184.93,119.32 190.09,119.32
FBA_CMD18: length 31.3
  TOP w0.089: RG53.1 181.17,135.55 v2(181.14,135.58)
  BOTTOM w0.089: UG2.J2 181.54,135.98
  BOTTOM w0.142: UG9.AN52 191.6,118.26 190.01,119.85 ; 179.88,135.53 181.1,135.53 v2(181.14,135.58) 181.54,135.98
  BOTTOM w0.178: 179.88,135.53 179.55,135.53 178.96,134.94 178.96,126.03 185.15,119.85 190.01,119.85
FBA_CMD19: length 32.3
  BOTTOM w0.089: 182.34,134.38 UG2.G3
  BOTTOM w0.142: 191.95,118.57 191.95,113.6 UG9.AM49 ; 182.34,134.38 181.94,134.77 180.62,134.77 180.29,134.44 179.83,134.44
  BOTTOM w0.178: 191.95,118.57 190.15,120.37 185.36,120.37 179.48,126.25 179.48,134.09 179.83,134.44
FBA_CMD20: length 28
  BOTTOM w0.142: UG2.H5 183.95,135.18 184.35,134.77 184.35,129.48 184,129.12 182.94,129.12 182.13,128.32
  BOTTOM w0.178: 182.13,128.32 182.13,124.99 186.24,120.89 190.07,120.89 192.3,118.66 UG9.AM52
FBA_CMD21: length 30
  BOTTOM w0.142: 182.65,128.04 183.33,128.71 183.97,128.71 184.63,129.37 184.63,135.2 184.22,135.62 183.59,135.62 UG2.H4 ; 192.58,118.9 192.58,116.01 192.64,115.96 192.64,115.14 192.3,114.8 UG9.AM51
  BOTTOM w0.178: 182.65,128.04 182.65,125.21 186.45,121.41 190.07,121.41 192.58,118.9
FBA_CMD22: length 29.9
  BOTTOM w0.142: UG2.J5 184.33,135.98 184.91,135.39 184.91,129.27 184.08,128.43 183.64,128.43 183.17,127.96 ; UG9.AM50 192.3,114.17 192.65,114.52 192.65,114.8 192.88,115.03 192.88,119.15
  BOTTOM w0.178: 183.17,127.96 183.17,125.42 186.67,121.93 190.1,121.93 192.88,119.15
FBA_CMD23: length 31
  BOTTOM w0.142: 183.69,127.95 183.82,128.08 184.13,128.08 185.19,129.15 185.19,135.55 184.33,136.41 183.57,136.41 UG2.J4 ; 192.92,119.59 193.16,119.35 193.16,117.73 193.11,117.68 193.11,115.09 193.35,114.85 193.35,114.3 UG9.AK50
  BOTTOM w0.178: 183.69,127.95 183.69,125.64 186.89,122.45 190.06,122.45 192.92,119.59
FBA_CMD24: length 29.4
  BOTTOM w0.142: UG9.AK51 193.7,114.85 193.35,115.2 193.35,117.57 193.4,117.61 193.4,119.85 ; UG2.K5 184.44,136.78 185.47,135.75 185.47,129.04 184.22,127.79
  BOTTOM w0.178: 184.22,127.79 184.22,125.86 187.1,122.97 190.28,122.97 193.4,119.85
FBA_CMD25: length 30
  BOTTOM w0.142: UG2.K4 183.56,137.2 184.61,137.2 185.75,136.05 185.75,128.92 184.74,127.9
  BOTTOM w0.178: UG9.AK52 193.7,120.04 191.91,121.83 191.91,122.07 190.49,123.49 187.32,123.49 184.74,126.07 184.74,127.9
FBA_CMD26: length 33.2
  BOTTOM w0.142: UG2.L12 189.14,137.17 186.69,137.17 186.07,136.55 186.07,128.82 185.26,128 ; 193.98,120.19 193.98,115.77 194.05,115.71 194.04,115.71 194.05,115.7 194.05,113.6 UG9.AJ49
  BOTTOM w0.178: 185.26,128 185.26,126.29 187.53,124.01 190.71,124.01 192.48,122.24 192.48,121.69 193.98,120.19
FBA_CMD27: length 28.2
  BOTTOM w0.142: 185.78,128.12 186.41,128.75 186.41,136 187.19,136.78 UG2.K10 ; 194.3,120.31 194.3,115.45 UG9.AJ52
  BOTTOM w0.178: 185.78,128.12 185.78,126.5 187.75,124.53 190.92,124.53 193.05,122.4 193.05,121.55 194.3,120.31
FBA_CMD28: length 29.4
  BOTTOM w0.142: 186.32,128.23 186.7,128.61 186.7,135.81 187.25,136.36 188.36,136.36 188.74,136.75 UG2.K11 ; 194.53,120.47 194.63,120.37 194.63,118.39 194.53,118.29 194.53,115.76 194.76,115.53 194.76,115.15 194.4,114.8 UG9.AJ51
  BOTTOM w0.178: 186.32,128.23 186.32,126.73 187.98,125.08 191.19,125.08 193.63,122.64 193.63,121.37 194.53,120.47
FBA_CMD29: length 28.9
  BOTTOM w0.142: UG9.AJ50 194.75,114.3 194.75,114.8 195,115.05 195,115.64 194.78,115.86 194.78,118.16 ; 186.84,128.32 186.98,128.46 186.98,134.95 187.63,135.6 188.32,135.6 UG2.H11
  BOTTOM w0.178: 194.78,118.16 194.88,118.27 194.88,120.69 194.2,121.37 194.2,122.83 191.43,125.6 188.19,125.6 186.84,126.95 186.84,128.32
FBA_CMD30: length 27.5
  BOTTOM w0.142: UG9.AG50 195.45,114.3 195.45,114.85 195.23,115.07 195.23,115.81 195.04,116 ; UG2.H10 187.61,135.18 187.28,134.85 187.28,128.87 187.36,128.78 187.36,128.32
  BOTTOM w0.178: 195.04,116 195.04,117.94 195.21,118.12 195.21,121.12 194.77,121.56 194.77,123.34 191.99,126.12 188.41,126.12 187.36,127.16 187.36,128.32
FBA_CMD31: length 28.2
  BOTTOM w0.142: 187.89,128.32 187.89,128.95 187.58,129.26 187.58,134.62 187.72,134.76 189.16,134.76 UG2.G12 ; 195.54,118 195.3,117.75 195.3,116.14 195.46,115.98 195.46,115.19 195.8,114.85 UG9.AG51
  BOTTOM w0.178: 187.89,128.32 187.89,127.38 188.62,126.64 192.84,126.64 195.34,124.14 195.34,121.97 195.54,121.77 195.54,118
FBA_D0: length 19.6
  IN5 w0.145: v2(207.81,129.18) 207.81,124.64 206.26,123.09 204.42,123.09 202.77,121.44 202.77,118.32 v2(202.1,117.65)
  BOTTOM w0.089: v2(207.81,129.18) 207.41,129.58 UG1.U4
  BOTTOM w0.142: UG9.U51 202.8,114.8 203.14,115.14 203.14,115.49 203.07,115.56 203.07,117.38 202.76,117.69
  BOTTOM w0.178: v2(202.1,117.65) 202.14,117.69 202.76,117.69
FBA_D1: length 21.4
  IN5 w0.145: v2(203.2,113.65) 203.2,115.3 203.72,115.82 203.72,120.67 204.1,121.06 206.2,121.06 209.75,124.61 209.75,128.83 v2(209.41,129.18)
  BOTTOM w0.089: v2(209.41,129.18) 209.01,129.58 UG1.U2
  BOTTOM w0.102: v2(203.2,113.65) 203.15,113.6 203.15,113.13 202.8,112.78 UG9.U48
FBA_D2: length 20.8
  IN5 w0.145: v2(207.81,129.98) 207.02,129.19 207.02,126.7 201.18,120.86 201.18,119.17 v2(202.1,118.25)
  BOTTOM w0.089: UG1.T4 207.41,130.38 v2(207.81,129.98)
  BOTTOM w0.142: UG9.U50 202.8,114.16 203.15,114.51 203.15,114.8 203.37,115.02 203.37,115.61 203.3,115.67 203.3,117.55
  BOTTOM w0.178: v2(202.1,118.25) 202.6,118.25 203.3,117.55
