# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_N3_C: length 2.4
  TOP w0.089: UT1.AC13 149.63,150.48 149.51,150.61 149.44,150.61 149.4,150.57 149.4,150.22 149.47,150.15 149.47,149.82 149.44,149.79 149.44,149.13 149.06,148.75 CT24.2
CPU_DP1_P0: length 72.2
  TOP w0.089: v2(145.64,147.35) 145.88,147.59 145.88,147.9 CT6.1
  IN5 w0.104: v2(137.29,113.3) 137.54,113.05 137.72,113.05 138,112.77 138.73,112.77 139.96,114 145.4,114 147.05,112.34 150.54,112.34 150.54,112.34 154.24,112.34 155.53,113.63 157.05,113.63 158.7,115.28 159.73,115.28 160.48,116.03 160.48,137.25 153.46,144.26 146.94,144.26 145.97,145.23 145.97,147.01 v2(145.64,147.35)
  BOTTOM w0.076: CPU1.K36 137.8,110.5 138,110.5 138.21,110.71 138.21,112.61 137.86,112.96 137.86,113.03 137.59,113.3 v2(137.29,113.3)
CPU_DP1_P0_C: length 2.7
  TOP w0.089: UT1.AB7 146.64,150.69 146.64,150.15 145.76,149.27 145.76,148.89 CT6.2
CPU_DP1_P1: length 74
  TOP w0.114: v2(155.34,145.5) 155.45,145.5 155.62,145.34 155.62,145.09 155.43,144.9 148.89,144.9 147.14,146.64 147.14,147.98 CT8.1
  IN5 w0.104: v2(138.12,109.45) 138.13,109.43 138.37,109.43 138.56,109.62 138.56,109.99 138.94,110.37 140.63,110.37 141.69,111.43 144.41,111.43 146.15,109.69 150.88,109.69 151.73,110.54 155.61,110.54 156.41,111.34 158.36,111.34 162.7,115.68 162.7,116.79 162.28,117.21 162.28,138 155.65,144.63 155.65,145.25 155.4,145.5 v2(155.34,145.5)
  BOTTOM w0.089: CPU1.J35 138.5,109.49 138.39,109.38 138.19,109.38 v2(138.12,109.45)
CPU_DP1_P1_C: length 2.6
  TOP w0.089: CT8.2 147.33,149.03 147.34,149.03 147.34,149.69 147.73,150.09 147.76,150.12 147.85,150.12 148.02,150.29 148.02,150.69 UT1.AB9
CPU_DP1_P2: length 74.5
  TOP w0.089: CT10.1 148.35,148.04 148.35,147.5 v2(148.45,147.39)
  IN4 w0.147: v2(144.14,146.32) 144.22,146.4 144.22,147.66 144.81,148.25 145.55,148.25 145.66,148.14 148.06,148.14 148.35,147.85 148.35,147.5 v2(148.45,147.39)
  IN5 w0.104: v2(144.14,146.32) 144.14,145.16 145.64,143.66 153.22,143.66 159.87,137 159.87,117.67 158.63,116.43 158.63,116.12 156.84,114.33 146.08,114.33 145.17,115.24 139.68,115.24 138.99,114.55 138.99,114.32 v2(138.81,114.15)
  BOTTOM w0.076: CPU1.H37 139.14,110.92 139.01,110.92 138.93,111 138.93,111.18 139.21,111.45 139.21,113.94 139,114.15 v2(138.81,114.15)
CPU_DP1_P2_C: length 2.4
  TOP w0.089: UT1.AB11 148.94,150.62 148.94,150.26 148.54,149.86 148.54,149.38 148.47,149.32 CT10.2
CPU_DP1_P3: length 82.2
  TOP w0.089: CT11.1 149.56,148.1 149.56,147.6 149.42,147.46 v2(149.42,147.23)
  IN4 w0.147: v2(149.42,147.23) 149.42,147.29 149.78,147.65 149.78,148.4 149.3,148.87 146.25,148.87 146,149.12 144.54,149.12 142.93,147.51 142.03,147.51 141.5,146.98 141.32,146.98 v2(141.17,147.12)
  IN5 w0.104: v2(141.17,147.12) 141.17,147.06 145.55,142.67 153.63,142.67 159.46,136.84 159.46,118.05 159.27,117.86 158.07,116.65 158.07,116.15 156.69,114.77 146.45,114.77 145.41,115.8 139.18,115.8 138.32,114.94 138.32,114.09 138.04,113.82 137.74,113.82 v2(137.66,113.73)
  BOTTOM w0.076: v2(137.66,113.73) 138.12,113.73 138.6,113.24 138.6,113 138.47,112.87 138.47,112.16 138.47,112.16 138.47,111.09 CPU1.J37
CPU_DP1_P3_C: length 2.4
  TOP w0.089: CT11.2 149.62,149.72 149.65,149.75 149.65,150.08 149.86,150.29 149.86,150.69 UT1.AB13
CPU_DP2_AUXN: length 82.1
  IN5 w0.104: v2(140.6,103.19) 140.38,103.19 140.27,103.08 140.27,102.91 140.4,102.78 140.77,102.78 141.14,103.15 142.15,103.15 143.39,104.39 143.39,105.45 143.76,105.82 145.54,105.82 146.78,107.06 159.43,107.06 160.6,108.23 160.6,108.37 161.41,109.18 161.81,109.18 164.09,111.45 164.09,113.42 165.11,114.45 165.11,117.79 164.69,118.2 164.69,139 161.38,142.31 161.38,145.34 161.2,145.52 161.2,146.15 161,146.35 161,146.62 160.88,146.74 160.7,146.74 160.57,146.62 v2(160.57,146.49)
  BOTTOM w0.089: CPU1.E26 140.6,103.32 v2(140.6,103.19)
  BOTTOM w0.114: CT36.1 149.94,143.98 149.94,143.5 150.06,143.38 158.73,143.38 159.21,143.86 159.21,145.38 159.62,145.79 160.96,145.79 161.16,146 161.16,146.18 160.86,146.49 v2(160.57,146.49)
CPU_DP2_AUXN_C: length 8.9
  TOP w0.089: UT1.W12 v2(148.86,152.58)
  BOTTOM w0.114: CT36.2 150.14,145.12 150.19,145.17 RT77.1 150.19,146.74 150.1,146.83 150.1,147.56 149.63,148.03 149.63,148.81 149.62,148.83 v4(149.62,150.08) 149.62,151.92 149.22,152.32 149.12,152.32 v2(148.86,152.58)
CPU_DP2_AUXP: length 82.1
  IN5 w0.104: v2(139.82,103.18) 140.08,102.92 140.08,102.83 140.15,102.76 140.32,102.59 140.85,102.59 141.22,102.96 142.23,102.96 143.59,104.31 143.59,105.37 143.84,105.62 145.62,105.62 146.86,106.86 159.51,106.86 160.8,108.15 160.8,108.29 161.49,108.99 161.89,108.99 164.28,111.37 164.28,113.34 165.3,114.37 165.3,117.87 164.88,118.29 164.88,139.08 161.58,142.39 161.58,145.42 161.4,145.6 v2(161.4,146.5)
  BOTTOM w0.089: CPU1.F26 140.21,103.58 v2(139.82,103.18)
  BOTTOM w0.114: v2(161.4,146.5) 161.4,145.91 161.05,145.57 159.71,145.57 159.43,145.29 159.43,143.77 158.82,143.15 149.97,143.15 149.71,143.41 149.71,144.02 CT35.1
CPU_DP2_AUXP_C: length 8.9
  TOP w0.089: UT1.Y12 149.17,151.73 148.96,151.94 v2(148.85,151.94)
  BOTTOM w0.114: v2(148.85,151.94) 149,152.09 149.12,152.09 149.39,151.83 149.39,150.37 149.37,150.35 149.37,149.81 149.39,149.79 v4(149.39,148.54) 149.39,147.95 149.88,147.47 149.88,146.74 149.97,146.65 149.97,145.91 RT79.1 149.7,145.24 149.7,144.92 CT35.2
CPU_DP2_N0: length 74.8
  TOP w0.114: CT28.1 150.26,148.1 150.26,147.34 150.7,146.9 151.97,146.9 152.83,146.04 v4(153.82,146.04) 156.13,146.04 156.99,145.19 158.89,145.19 159.21,145.5 159.21,146.01 v2(159.27,146.07)
  IN5 w0.104: v2(138.89,108.76) 139.08,108.57 139.08,108.53 139.51,108.1 141.43,108.1 141.6,108.27 143.29,108.27 143.91,107.66 145.19,107.66 145.64,108.1 151.27,108.1 152.09,108.93 159.29,108.93 160.73,110.37 160.73,111.5 164.1,114.86 164.1,117.37 163.68,117.79 163.68,138.58 159.12,143.14 159.12,145.92 v2(159.27,146.07)
  BOTTOM w0.089: v2(138.89,108.76) 139.18,108.46 CPU1.H33
CPU_DP2_N0_C: length 2.3
  TOP w0.089: CT28.2 150.47,149.03 150.47,150.02 150.32,150.17 150.32,150.54 150.39,150.61 150.48,150.61 150.55,150.54 UT1.AC15
CPU_DP2_N1: length 68.5
  TOP w0.089: CT30.1 151.6,147.9 151.6,147.74 v2(151.42,147.55)
  IN5 w0.104: v2(140.49,113.39) 140.76,113.12 141.05,113.12 141.29,112.88 141.29,112.29 141.55,112.04 142.83,112.04 143.27,112.48 144.5,112.48 146.27,110.71 151.05,110.71 151.48,111.14 155.24,111.14 156.08,111.97 158.13,111.97 161.68,115.53 161.68,137.75 154.72,144.71 154.72,147.94 154.17,148.49 153.28,148.49 152.7,147.91 152.7,147.26 152.3,146.86 151.82,146.86 151.58,147.1 151.58,147.38 v2(151.42,147.55)
  BOTTOM w0.076: CPU1.G38 139.63,111.71 139.56,111.79 139.56,112.05 139.63,112.13 139.79,112.13 139.92,112.26 139.92,112.81 140.49,113.37 v2(140.49,113.39)
CPU_DP2_N1_C: length 2.4
  TOP w0.089: UT1.AC17 151.47,150.52 151.38,150.61 151.31,150.61 151.24,150.54 151.24,150.16 151.3,150.1 151.39,150.1 151.47,150.02 151.47,148.89 CT30.2
CPU_DP2_N2: length 68.7
  TOP w0.114: v2(157.35,146.05) 157.48,146.05 157.63,146.2 157.63,146.51 157.37,146.77 153.05,146.77 152.72,147.1 152.72,147.92 CT32.1
  IN5 w0.104: v2(157.35,146.05) 157.48,146.05 157.66,145.87 157.66,143.47 162.88,138.25 162.88,117.46 163.3,117.04 163.3,115.26 159.78,111.74 159.78,110.58 158.95,109.75 151.79,109.75 150.97,108.93 145.83,108.93 144.87,109.88 142.77,109.88 141.92,109.04 140.35,109.04 140.16,109.22 140.16,109.31 140.32,109.46 v2(140.5,109.46)
  BOTTOM w0.076: v2(140.5,109.46) 140.2,109.46 140.07,109.59 CPU1.F35
CPU_DP2_N2_C: length 2.4
  TOP w0.089: CT32.2 152.67,148.94 152.67,149.67 152.44,149.89 152.44,150.02 152.37,150.1 152.31,150.1 152.16,150.24 152.16,150.53 152.23,150.6 152.3,150.6 152.39,150.5 UT1.AC19
CPU_DP2_N3: length 62.9
  TOP w0.089: CT34.1 153.62,148.16 153.9,147.87 153.9,147.55 v2(153.73,147.38)
  IN5 w0.104: v2(141.69,112.75) 141.94,112.99 145.11,112.99 146.99,111.12 150.88,111.12 151.31,111.55 154.85,111.55 155.69,112.39 157.4,112.39 157.75,112.74 157.75,113.16 158.97,114.39 159.96,114.39 161.27,115.7 161.27,137.58 153.3,145.55 153.3,147.66 153.49,147.85 153.76,147.85 153.92,147.7 153.92,147.57 v2(153.73,147.38)
  BOTTOM w0.076: v2(141.69,112.75) 141.45,112.75 141.05,112.35 141.05,111.54 141.15,111.44 141.15,110.71 CPU1.E36
CPU_DP2_N3_C: length 2.5
  TOP w0.089: UT1.AC21 153.31,150.46 153.22,150.55 153.15,150.55 153.08,150.48 153.08,150.16 153.15,150.09 153.37,150.09 153.47,149.99 153.47,149.93 153.79,149.61 153.79,148.88 153.66,148.75 CT34.2
CPU_DP2_P0: length 74.8
  TOP w0.114: v2(158.64,146.07) 158.7,146.07 158.98,145.79 158.98,145.59 158.8,145.41 157.08,145.41 156.22,146.26 154.11,146.26 154.09,146.28 153.55,146.28 153.54,146.26 152.92,146.26 152.06,147.12 150.79,147.12 150.46,147.46 150.46,147.86 150.51,147.91 150.51,147.92 CT27.1
  IN5 w0.104: v2(158.64,146.07) 158.76,146.07 158.93,145.91 158.93,143.06 163.49,138.5 163.49,117.71 163.9,117.29 163.9,114.94 160.54,111.58 160.54,110.45 159.21,109.12 152.01,109.12 151.19,108.29 145.56,108.29 145.11,107.85 143.99,107.85 143.37,108.46 141.52,108.46 141.35,108.29 139.59,108.29 139.27,108.61 139.27,108.96 139.36,109.05 139.56,109.05 139.72,108.89 v2(139.72,108.75)
  BOTTOM w0.089: v2(139.72,108.75) 139.71,108.73 139.53,108.73 139.28,108.98 CPU1.H34
CPU_DP2_P0_C: length 2.4
  TOP w0.089: CT27.2 150.65,148.86 150.65,150.1 150.78,150.23 150.78,150.6 150.56,150.92 UT1.AB15
CPU_DP2_P1: length 68.5
  TOP w0.089: CT29.1 151.78,148.04 151.78,147.78 v2(152,147.55)
  IN5 w0.104: v2(140.49,112.81) 140.6,112.93 140.97,112.93 141.1,112.8 141.1,112.21 141.47,111.85 142.91,111.85 143.35,112.29 144.42,112.29 146.19,110.51 151.13,110.51 151.56,110.95 155.32,110.95 156.16,111.78 158.21,111.78 161.87,115.45 161.87,137.83 154.92,144.79 154.92,148.02 154.25,148.68 153.2,148.68 152.51,147.99 152.51,147.34 152.22,147.05 151.93,147.05 151.8,147.18 151.8,147.36 v2(152,147.55)
  BOTTOM w0.076: v2(140.49,112.81) 140.43,112.86 140.21,112.86 140.08,112.74 140.08,111.52 140.07,111.51 CPU1.F37
CPU_DP2_P1_C: length 2.4
  TOP w0.089: UT1.AB17 151.48,150.92 151.7,150.61 151.7,150.29 151.65,150.24 151.65,149 CT29.2
CPU_DP2_P2: length 68.7
  TOP w0.114: CT31.1 152.93,148.05 152.93,147.21 153.14,147 157.46,147 157.86,146.6 157.86,146.24 v2(158.05,146.05)
  IN5 w0.104: v2(139.71,109.41) 139.97,109.18 139.97,109.13 140.28,108.85 142,108.85 142.85,109.69 144.79,109.69 145.75,108.74 151.05,108.74 151.87,109.56 159.03,109.56 159.97,110.5 159.97,111.66 163.5,115.18 163.5,117.12 163.08,117.54 163.08,138.33 157.86,143.55 157.86,145.86 v2(158.05,146.05)
  BOTTOM w0.076: CPU1.F34 139.78,109.41 v2(139.71,109.41)
CPU_DP2_P2_C: length 2.4
  TOP w0.089: CT31.2 152.84,148.95 152.84,149.74 152.62,149.97 152.62,150.69 UT1.AB19
CPU_DP2_P3: length 62.9
  TOP w0.089: CT33.1 154.09,148.06 154.09,147.61 v2(154.32,147.38)
  IN5 w0.104: v2(154.32,147.38) 154.11,147.59 154.11,147.78 153.84,148.04 153.41,148.04 153.11,147.74 153.11,145.47 161.08,137.5 161.08,115.78 159.88,114.58 158.89,114.58 157.56,113.24 157.56,112.82 157.32,112.58 155.61,112.58 154.77,111.74 151.23,111.74 150.8,111.31 147.07,111.31 145.19,113.19 141.84,113.19 v2(141.69,113.33)
  BOTTOM w0.076: CPU1.E37 140.96,111.16 140.96,111.36 140.87,111.44 140.87,112.45 141.39,112.96 141.39,112.97 141.69,113.27 v2(141.69,113.33)
CPU_DP2_P3_C: length 2.5
  TOP w0.089: CT33.2 153.97,148.97 153.97,149.69 153.68,149.97 153.68,150.08 153.54,150.22 153.54,150.69 UT1.AB21
CPU_EDP_AUX: length 27.6
  IN1 w0.104: v2(160.03,116.12) 159.84,115.94 159.84,115.58 159.6,115.34 157.21,115.34 152.03,110.17 152.03,108.29 149.3,105.56 146.95,105.56 146,104.6 145.61,104.6 145.16,104.15 145.16,103.9 145.03,103.77 145.03,103.59 145.18,103.45 v2(145.28,103.45)
  BOTTOM w0.076: CPU1.C26 142.32,103.42 142.32,103.24 142.47,103.08 143.58,103.08 143.92,102.75 144.81,102.75 145.04,102.97 145.04,103.2 v2(145.28,103.45)
  BOTTOM w0.114: v2(160.03,116.12) 159.93,116.02 159.93,114.91 CV434.2
CPU_EDP_AUX#: length 27.6
  IN1 w0.104: v2(159.45,116.12) 159.65,115.92 159.65,115.66 159.52,115.53 157.13,115.53 151.84,110.25 151.84,108.37 149.22,105.75 146.87,105.75 145.92,104.8 145.53,104.8 144.97,104.23 144.97,104.2 144.97,103.98 144.84,103.85 144.84,103.79 v2(144.5,103.45)
  BOTTOM w0.076: CPU1.B26 142.75,103.64 142.57,103.64 142.51,103.58 142.51,103.32 142.56,103.26 143.66,103.26 144.01,102.91 144.74,102.91 144.87,103.04 144.87,103.36 144.78,103.45 v2(144.5,103.45)
  BOTTOM w0.114: CV435.2 159.7,114.86 159.7,115.86 v2(159.45,116.12)
CPU_EDP_AUX#_C: length 2.4
  BOTTOM w0.114: UV21.29 159.47,112.36 159.55,112.45 159.55,112.73 159.73,112.9 159.73,113.48 159.75,113.49 159.75,113.87 CV435.1
CPU_EDP_AUX_C: length 2.4
  BOTTOM w0.114: UV21.30 159.87,112.4 159.78,112.48 159.78,112.63 159.97,112.83 v4(159.97,113.21) 159.97,113.91 CV434.1
CPU_EDP_N0_C: length 4
  BOTTOM w0.114: CV427.1 152.07,108.23 v4(152.67,108.23) 153.64,108.23 153.66,108.25 154.3,108.25 154.54,108.01 154.92,108.01 154.96,108.04 UV21.12
CPU_EDP_N1_C: length 2.5
  BOTTOM w0.114: CV429.1 153.63,109.53 154.4,109.53 154.78,109.15 154.96,109.15 155.05,109.24 UV21.15
CPU_EDP_N2_C: length 4.3
  BOTTOM w0.114: UV21.17 155.1,110.04 155.05,109.98 154.87,109.98 v4(154.42,110.43) 153.98,110.87 153.1,110.87 153.08,110.89 152.54,110.89 152.52,110.87 152.04,110.87 CV431.1
CPU_EDP_N3_C: length 3.1
  BOTTOM w0.114: UV21.20 155.06,111.24 154.97,111.15 154.79,111.15 154.66,111.28 154.66,111.89 154.4,112.16 v4(154.26,112.16) 153.61,112.16 CV433.1
CPU_EDP_P0_C: length 4
  BOTTOM w0.114: CV426.1 151.98,108 152.38,108 152.4,107.99 152.94,107.99 152.96,108 v4(153.93,108) 154.23,108 154.45,107.78 154.91,107.78 154.97,107.73 155.06,107.64 UV21.11
CPU_EDP_P1_C: length 2.4
  BOTTOM w0.114: UV21.14 155.07,108.84 154.99,108.93 154.69,108.93 154.31,109.31 153.6,109.31 CV428.1
CPU_EDP_P2_C: length 4.3
  BOTTOM w0.114: CV430.1 152.01,110.64 v4(152.81,110.64) 153.89,110.64 154.06,110.47 154.06,110.45 154.44,110.07 154.47,110.07 154.82,109.72 155.05,109.72 155.12,109.64 UV21.16
CPU_EDP_P3_C: length 3.1
  BOTTOM w0.114: CV432.1 153.62,111.93 153.87,111.93 153.9,111.91 154.31,111.91 154.44,111.78 154.44,111.19 154.7,110.93 155.04,110.93 155.13,110.84 UV21.19
CPU_EDP_TX0N: length 16.7
  IN1 w0.104: v2(147.58,110.06) 147.46,110.18 147.46,110.47 147.16,110.77 145.67,110.77 145.1,110.2 143.51,110.2 142.63,109.32 142.63,106.85 142.36,106.58 141.81,106.58 141.37,106.14 141.37,105.75 v2(141.19,105.58)
  BOTTOM w0.076: CPU1.E29 141.19,105.61 v2(141.19,105.58)
  BOTTOM w0.114: CV427.2 151.03,108.28 v4(149.87,108.28) 148.84,108.28 148.82,108.29 148.28,108.29 148.27,108.28 147.92,108.28 147.64,108.56 147.63,108.56 147.41,108.78 147.41,109.89 v2(147.58,110.06)
CPU_EDP_TX0P: length 16.7
  IN1 w0.104: v2(147.03,110.06) 147.27,110.3 147.27,110.39 147.08,110.58 145.75,110.58 145.18,110.01 143.59,110.01 142.83,109.24 142.83,106.77 142.44,106.39 141.89,106.39 141.56,106.06 141.56,105.69 141.69,105.56 v2(141.88,105.56)
  BOTTOM w0.076: CPU1.D29 141.53,105.94 141.88,105.58 v2(141.88,105.56)
  BOTTOM w0.114: v2(147.03,110.06) 147.2,109.89 147.2,108.69 147.48,108.41 147.48,108.4 147.83,108.05 v4(148.55,108.05) 149.59,108.05 149.6,108.04 150.14,108.04 150.16,108.05 151.03,108.05 CV426.2
CPU_EDP_TX1N: length 16.7
  IN1 w0.104: v2(149.43,110.07) 149.17,109.81 149.17,109.5 148.73,109.05 146.53,109.05 145.11,107.64 145.11,107.39 144.35,106.63 144.35,106.26 142.95,104.86 141.79,104.86 141.62,104.69 141.62,104.51 141.41,104.3 141.31,104.3 141.2,104.41 v2(141.2,104.74)
  BOTTOM w0.076: v2(141.2,104.74) 140.86,105.07 CPU1.E28
  BOTTOM w0.114: v2(149.43,110.07) 149.15,109.79 149.15,109.66 149.46,109.34 152.41,109.34 CV429.2
CPU_EDP_TX1P: length 16.6
  IN1 w0.104: v2(148.79,110.07) 148.98,109.88 148.98,109.58 148.65,109.25 146.45,109.25 144.92,107.72 144.92,107.47 144.16,106.71 144.16,106.34 142.87,105.05 141.56,105.05 141.51,105.11 141.05,105.11 140.68,104.74 v2(140.55,104.74)
  BOTTOM w0.076: CPU1.F28 140.21,105.08 v2(140.55,104.74)
  BOTTOM w0.114: CV428.2 149.37,109.12 148.92,109.56 148.92,109.94 v2(148.79,110.07)
CPU_EDP_TX2N: length 14.4
  IN1 w0.104: v2(145.47,106.33) 145.37,106.43 145.37,106.77 146.25,107.65 148.75,107.65 150.19,109.1 150.19,111.66 v2(150.25,111.72)
  BOTTOM w0.089: CPU1.B29 143.04,105.72 143.04,105.6 143.2,105.44 143.7,105.44 143.92,105.66 145.01,105.66 145.24,105.89 145.24,106.1 v2(145.47,106.33)
  BOTTOM w0.114: CV431.2 151.03,110.88 150.22,110.88 150.03,111.07 150.03,111.5 v2(150.25,111.72)
CPU_EDP_TX2P: length 14.4
  IN1 w0.104: v2(144.92,106.33) 145.17,106.58 145.17,106.85 146.17,107.85 148.67,107.85 150,109.18 150,111.34 v2(149.63,111.71)
  BOTTOM w0.089: v2(144.92,106.33) 145.06,106.19 145.06,105.96 144.93,105.83 143.84,105.83 143.62,105.62 143.28,105.62 143.21,105.68 143.21,105.84 143.31,105.94 CPU1.A29
  BOTTOM w0.114: v2(149.63,111.71) 149.81,111.53 149.81,110.98 150.13,110.66 151.03,110.66 CV430.2
CPU_EDP_TX3N: length 18.2
  IN1 w0.104: v2(144.6,104.25) 144.48,104.37 144.48,104.4 144.48,104.4 144.48,104.67 144.79,104.99 145.56,104.99 147.14,106.57 149.05,106.57 151.19,108.72 151.19,112.53 v2(151.39,112.73)
  BOTTOM w0.076: v2(144.6,104.25) 144.35,104.5 144.35,104.64 144.15,104.84 142.71,104.84 142.49,105.06 142.49,105.13 142.6,105.23 142.74,105.23 CPU1.B28
  BOTTOM w0.114: CV433.2 152.62,112.15 151.35,112.15 151.18,112.32 151.18,112.52 v2(151.39,112.73)
CPU_EDP_TX3P: length 18.3
  IN1 w0.104: v2(150.8,112.73) 151,112.53 151,108.8 148.97,106.77 147.06,106.77 145.48,105.18 144.71,105.18 144.29,104.75 144.29,104.48 v2(144.06,104.25)
  BOTTOM w0.076: v2(144.06,104.25) 144.18,104.37 144.18,104.58 144.08,104.67 142.64,104.67 CPU1.C28
  BOTTOM w0.114: CV432.2 152.62,111.93 151.26,111.93 150.95,112.23 150.95,112.58 v2(150.8,112.73)
CPU_FAN_FB: length 90.1
  TOP w0.114: v2(98.15,12.52) 98.15,11.43 98.31,11.26 98.31,10.31 98.89,9.73 98.89,8.39 99.29,7.99 99.29,7.39 99.47,7.2 UE5.28
  TOP w0.254: v2(66.56,58.06) 66.56,57.86 67.43,56.99 v1(67.43,56.45) 67.43,56.08 66.78,55.43 64.69,55.43 64.01,56.11 DF1.2 63.7,56.09 63.36,55.75 RF1.1
  IN5 w0.097: v2(66.56,58.06) 67.65,56.97 74.13,56.97 76.53,54.57 76.53,51.65 74.1,49.22 74.1,22.22 76.84,19.48 80.48,19.48 82.24,17.73 83,17.73 83.19,17.92 85.75,17.92 87.01,16.66 87.01,15 88.99,13.02 88.99,12.62 89.13,12.47 91.14,12.47 91.64,12.97 97.77,12.97 98.15,12.59 v2(98.15,12.52)
CPU_FAN_PWM: length 96.2
  TOP w0.114: RF2.1 66.57,54.82 67.79,56.04 67.79,57.38 v3(67.12,58.05) 66.72,58.45 66.31,58.45 v2(65.8,57.94) ; UE5.26 98.67,7.69 97.99,8.37 97.99,11.14 97.56,11.57 97.56,12.44 v2(97.53,12.48)
  IN5 w0.097: v2(97.53,12.48) 97.42,12.59 97.09,12.59 96.91,12.77 91.75,12.77 91.13,12.14 89.18,12.14 88.79,12.53 88.79,12.94 86.79,14.94 86.79,15.38 86.31,15.85 85.01,15.85 83.8,17.06 82.29,17.06 80.09,19.26 76.75,19.26 73.23,22.78 73.23,40.55 73.81,41.13 73.81,49.25 76.28,51.71 76.28,54.51 74.31,56.48 67.2,56.48 65.8,57.87 v2(65.8,57.94)
  BOTTOM w0.114: v2(65.8,57.94) 65.67,58.06 65.67,58.13 65.36,58.44 64.28,58.44 64.09,58.63 64.09,61.37 64.78,62.06 65.29,62.06 66.18,62.95 66.18,63.74 JFAN1.3
CPU_ID: length 4.1
  TOP w0.089: RH24.1 RH23.1 174.35,38.4 174.07,38.12 v1(174.07,37.68) 174.07,36.79 v2(174.64,36.22)
  BOTTOM w0.089: UH1.AL35 175.03,35.82 v2(174.64,36.22)
CPU_TRIGGER: length 73.1
  TOP w0.114: RH192.1 144.66,100.74 147.97,100.74 v1(149.03,99.68) 149.03,96.08 148.6,95.66 v2(147.16,95.66)
  BOTTOM w0.089: 173.86,54.8 174.27,54.39 UH1.AK1
  BOTTOM w0.114: 173.86,54.8 173.86,56.76 173.4,57.21 173.4,57.46 172.67,58.19 171.65,58.19 171.35,58.5 170.04,58.5 169.15,59.38 167.28,59.38 160.99,65.67 158.43,65.67 157.46,66.64 153.33,66.64 150.86,69.12 150.86,81.35 149.75,82.46 149.75,94.51 149.24,95.02 147.79,95.02 v2(147.16,95.66)
CPU_XDP_TRST#: length 249.3
  TOP w0.114: v2(70.25,67.33) 70.75,67.84 71.01,67.84 JPCMC.28 ; v3(72.21,14.63) 71.52,15.33 v2(71.51,15.33)
  IN2 w0.097: v2(71.51,15.33) 71.51,15.67 75.25,19.41 84.87,19.41 86.69,21.23 93.17,21.23 93.62,21.68 102.53,21.68 103.38,22.53 107.52,22.53 107.74,22.31 107.74,22.03 107.94,21.83 109.28,21.83 109.91,22.45 111.27,22.45 115.26,26.44 136.07,26.44 136.62,26.99 139.5,26.99 143.21,30.69 143.59,30.69 144.1,31.2 144.1,34.38 147.4,37.68 148.03,37.68 152.67,42.32 154.26,42.32 156.73,44.79 160.06,44.79 160.82,45.55 165.7,45.55 166.05,45.91 166.99,45.91 167.12,45.78 169.48,45.78 169.59,45.89 171.02,45.89 171.53,45.38 172.31,45.38 172.8,45.87 173.29,45.87 173.92,46.5 173.92,47.85 174.74,48.67 177.1,48.67 178.18,49.76 v2(179.13,49.76) ; v2(101.06,107.3) 101.06,106.44 99.74,105.12 98.6,105.12 96.37,102.88 96.37,95.15 92.78,91.56 87.96,91.56 82.52,86.13 82.52,84.54 69.69,71.7 69.69,68.85 69.8,68.73 69.8,68.1 70.25,67.65 v2(70.25,67.33)
  IN4 w0.137: v2(70.25,67.33) 70.25,66.53 77.79,58.98 77.79,48.91 75.83,46.95 75.83,36.79 74.18,35.14 74.18,19.62 71.51,16.95 v2(71.51,15.33)
  BOTTOM w0.076: v2(101.06,107.3) 101.41,106.95 103.32,106.95 103.48,106.79 103.84,106.79 CPU1.BP30
  BOTTOM w0.089: UH1.AY5 179.53,50.16 v2(179.13,49.76)
  BOTTOM w0.114: v2(101.06,107.3) 101.06,107.77 RH497.2
CRX_N8: length 33.4
  IN5 w0.104: v2(125.97,168.99) 125.81,168.83 125.81,168.62 125.55,168.36 119.39,168.36 118.28,167.26 117.45,167.26 115.01,164.83 115.01,162.96 106.57,154.52 106.2,154.52 106.2,154.52 106.04,154.52 105.75,154.81 105.75,155.05 v2(105.41,155.39)
  BOTTOM w0.114: v2(105.41,155.39) 105.92,154.88 105.92,154.24 105.81,154.13 105.79,154.13 105.41,153.75 105.41,153.73 105.17,153.49 105.17,153.19 105.09,153.11 UM8.42 ; v2(125.97,168.99) 125.78,169.18 125.78,169.79 125.85,169.87 JCDRA.16
CRX_N9: length 38.4
  IN5 w0.104: v2(102.61,155.91) 102.82,155.71 102.82,155.19 103.12,154.88 104.3,154.88 104.65,154.53 104.65,154.13 104.96,153.82 106.89,153.82 115.85,162.78 115.85,162.99 116.6,163.74 116.6,164.52 119.74,167.66 126.15,167.66 127.01,168.53 127.01,168.79 v2(127.15,168.92)
  BOTTOM w0.114: UM8.37 102.59,153.3 102.72,153.43 102.72,154.8 102.98,155.06 102.98,155.55 v2(102.61,155.91) ; v2(127.15,168.92) 126.97,169.1 126.97,169.8 127.05,169.88 JCDRA.19
CRX_N10: length 38.8
  IN5 w0.104: v2(103.4,154.5) 103.4,153.48 103.82,153.06 107.09,153.06 110.71,156.68 111.04,156.68 121.24,166.88 126.86,166.88 127.94,167.96 129.66,167.96 129.9,168.2 129.9,168.51 v2(129.99,168.6)
  BOTTOM w0.114: JCDRA.25 129.45,169.3 129.76,169 129.76,168.84 v2(129.99,168.6) ; UM8.39 103.59,153.19 103.74,153.34 103.74,153.67 103.47,153.94 103.47,154.42 v2(103.4,154.5)
CRX_N11: length 38.2
  IN5 w0.104: v2(106.32,156.24) 106.56,156.49 106.56,157.69 117.01,168.13 117.87,168.13 120.14,170.41 131.54,170.41 131.78,170.17 131.78,169.66 v2(131.95,169.49)
  BOTTOM w0.114: UM8.44 106.09,153.15 106.22,153.28 106.22,153.52 106.77,154.07 106.77,155.79 v2(106.32,156.24) ; JCDRA.31 131.85,169.87 131.8,169.82 131.8,169.64 v2(131.95,169.49)
CRX_P8: length 33.4
  IN5 w0.104: v2(125.38,168.99) 125.43,168.99 125.62,168.8 125.62,168.7 125.47,168.56 119.31,168.56 118.2,167.45 117.37,167.45 114.82,164.91 114.82,163.04 106.49,154.71 106.12,154.71 105.94,154.89 105.94,155.47 106.07,155.6 106.28,155.6 106.38,155.5 v2(106.38,155.39)
  BOTTOM w0.114: v2(106.38,155.39) 106.27,155.39 106.14,155.26 106.14,154.14 v4(105.77,153.77) 105.42,153.42 105.42,153.25 105.59,153.08 UM8.43 ; v2(125.38,168.99) 125.55,169.16 125.55,169.78 125.45,169.88 JCDRA.15
CRX_P9: length 38.4
  IN5 w0.104: v2(126.56,168.92) 126.69,168.92 126.76,168.85 126.76,168.76 126.82,168.7 126.82,168.61 126.07,167.85 119.66,167.85 116.41,164.6 116.41,163.82 115.66,163.07 115.66,162.86 106.81,154.01 105.04,154.01 104.84,154.21 104.84,154.61 104.38,155.08 103.2,155.08 103.01,155.27 103.01,155.92 103.14,156.04 103.4,156.04 v2(103.53,155.91)
  BOTTOM w0.114: JCDRA.18 126.65,169.88 126.74,169.8 126.74,169.1 v2(126.56,168.92) ; UM8.38 103.09,153.23 102.95,153.38 102.95,154.71 103.2,154.97 103.2,155.59 v2(103.53,155.91)
CRX_P10: length 38.8
  IN5 w0.104: v2(129.41,168.6) 129.41,168.52 129.53,168.4 129.65,168.4 129.7,168.35 129.7,168.28 129.58,168.15 127.86,168.15 126.78,167.07 121.16,167.07 110.96,156.87 110.63,156.87 107.01,153.25 103.9,153.25 103.59,153.56 103.59,153.97 103.69,154.08 103.96,154.08 104.03,154.14 104.03,154.32 103.98,154.38 v2(103.98,154.5)
  BOTTOM w0.114: v2(103.98,154.5) 103.7,154.22 103.7,154.03 103.96,153.76 103.96,153.31 104.09,153.19 UM8.40 ; v2(129.41,168.6) 129.53,168.73 129.53,168.91 129.05,169.39 JCDRA.24
CRX_P11: length 38.2
  IN5 w0.104: v2(131.36,169.49) 131.59,169.72 131.59,170.09 131.46,170.21 120.22,170.21 117.95,167.94 117.09,167.94 106.76,157.61 106.76,156.2 106.88,156.07 107.06,156.07 v2(107.23,156.24)
  BOTTOM w0.114: UM8.45 106.59,153.14 106.44,153.29 106.44,153.43 106.99,153.98 106.99,155.88 106.94,155.93 106.94,156.11 107.07,156.24 v2(107.23,156.24) ; v2(131.36,169.49) 131.51,169.64 131.51,169.82 131.45,169.87 JCDRA.30
CS1: length 2.6
  BOTTOM w0.203: PR106.2 32.71,24.9 32.49,25.12 32.49,25.97 32.96,26.44 PU100.1
CS2: length 2.6
  BOTTOM w0.203: PR105.2 32.4,30.32 32.4,28.49 32.54,28.35 PU100.5
CS_1.2V: length 1.7
  TOP w0.203: PU201.13 61.31,48.57 61.36,48.51 61.36,47.86 PR201.2
CSON_1: length 28.8
  TOP w0.254: PR723.2 52.87,34.24 PC717.2 52.39,34.72 v2(51.96,34.72) 52.02,34.78 PC721.1
  IN1 w0.254: v2(51.96,34.72) 52.05,34.63 52.66,34.63 52.78,34.5 53.66,34.5 54.15,35 54.15,36.26 54.76,36.87 61.05,36.87 61.25,37.06 62.37,37.06 62.89,36.54 62.89,34.58 64.2,33.27 64.2,32.28 v2(64.3,32.17)
  BOTTOM w0.254: PR712.3 67.38,25.86 67.1,26.14 67.1,26.98 66.79,27.29 66.79,28.07 64.1,30.76 64.1,31.49 64.3,31.69 v2(64.3,32.17)
CSOP_1: length 27.9
  TOP w0.254: v2(51.96,34.12) PC716.2 52.05,33.35 PC717.1 52.85,33.35 PR722.2
  IN1 w0.254: v2(63.72,32.17) 63.82,32.28 63.82,33.11 62.51,34.42 62.51,36.35 62.18,36.68 61.38,36.68 61.18,36.48 54.95,36.48 54.53,36.06 54.53,34.84 53.82,34.12 52.59,34.12 52.47,34.25 52.08,34.25 v2(51.96,34.12)
  BOTTOM w0.254: PR712.2 66.43,25.86 66.72,26.15 66.72,26.86 66.44,27.14 66.44,27.75 v1(65.05,29.13) 63.72,30.47 v2(63.72,32.17)
CSSN_1: length 3.1
  BOTTOM w0.114: v1(59.53,40.82) 59.22,40.82 58.98,41.06 PR704.1
  BOTTOM w0.254: PR702.3 59.07,42.56 58.62,42.56 58.43,42.37 58.43,41.19 PR704.1
CSSN_2: length 12.3
  TOP w0.203: PU700.1 60.84,33.73 61.22,33.35 v2(61.28,33.35)
  IN5 w0.254: v2(61.28,33.35) 61.41,33.48 61.96,33.48 62.31,33.83 62.31,34.68 61.96,35.03 61.32,35.03 60.59,35.76 60.59,37.68 v2(60.72,37.81)
  BOTTOM w0.254: v2(60.72,37.81) 60.59,37.93 60.59,38.25 v1(60.54,38.31) 60.15,38.7 58.75,38.7 58.57,38.87 PC708.2 ; PC708.2 58.56,39.28 PR704.2 ; PC708.2 PC709.1
CSSN_B+: length 63.3
  TOP w0.254: PR6100.3 246.97,48.86 v2(247.03,48.92)
  IN1 w0.203: v2(247.03,48.92) 246.97,48.86 244.68,48.86 242.33,51.21 242.33,54.44 240.43,56.35 233,56.35 231.92,57.43 231.92,64.48 232.36,64.92 232.36,72.53 231.21,73.68 225.38,73.68 223.17,75.89 218.78,75.89 v2(218.73,75.93)
  BOTTOM w0.254: RG59.1 v1(208.51,76.29) 209,75.8 218.6,75.8 v2(218.73,75.93)
CSSN_NVVDD: length 55.5
  TOP w0.254: PR6101.3 v2(236.87,53.49)
  IN1 w0.203: v2(221.1,73.44) 221.24,73.3 224.5,73.3 225.19,72.62 231.04,72.62 231.64,72.02 231.64,65.51 228.3,62.17 228.3,53.97 229.57,52.7 236.72,52.7 237.06,53.04 237.06,53.29 v2(236.87,53.49)
  BOTTOM w0.254: RG64.1 208.11,73.18 208.4,72.88 208.68,72.88 v1(209.34,73.53) 221.01,73.53 v2(221.1,73.44)
CSSN_NVVDDS: length 86
  TOP w0.114: v2(202.52,67.84) v1(202.92,68.25)
  TOP w0.254: PR6200.3 238.28,48.52 239.03,47.78 v2(239.03,46.76)
  IN1 w0.203: v2(202.52,67.84) 202.36,67.99 202.36,68.68 201.46,69.58 199.06,69.58 198.05,70.6 194.93,70.6 190.91,66.57 190.01,66.57 188.8,65.37 188.8,63.4 189.79,62.41 189.79,55.96 192.85,52.89 224.64,52.89 228.3,49.24 238.1,49.24 239.03,48.31 v2(239.03,46.76)
  BOTTOM w0.254: RG138.1 202.64,67.97 v2(202.52,67.84)
CSSP_1: length 4.7
  BOTTOM w0.114: v1(55.4,41.03) 55.54,41.17 57.56,41.17 PR703.1
  BOTTOM w0.254: PR702.2 57.88,42.56 58.05,42.38 58.05,41.44 PR703.1
CSSP_2: length 12.2
  TOP w0.203: PU700.2 61.07,34.13 61.22,33.99 v2(61.28,33.99)
  IN5 w0.254: v2(60.09,37.81) 60.21,37.68 60.21,35.6 61.17,34.65 61.8,34.65 61.92,34.52 61.92,33.99 61.8,33.86 61.41,33.86 v2(61.28,33.99)
  BOTTOM w0.254: PR703.2 57.66,40.13 PC708.1 ; PC707.2 PC708.1 ; PC708.1 57.66,38.71 v1(58.05,38.31) 59.96,38.31 60.19,38.09 60.19,37.91 v2(60.09,37.81)
CSSP_B+: length 63.3
  TOP w0.254: PR6100.2 243.64,45.96 v2(243.09,46.51)
  IN1 w0.203: v2(243.09,46.51) 243.09,49.94 241.95,51.08 241.95,54.32 240.3,55.97 232.87,55.97 231.54,57.3 231.54,64.67 232.04,65.18 232.04,72.27 231.01,73.3 225.25,73.3 222.99,75.56 219.44,75.56 219.32,75.44 v2(219.07,75.44)
  BOTTOM w0.254: v2(219.07,75.44) 209.02,75.44 v1(208.54,74.95) RG62.1
CSSP_NVVDD: length 61.7
  TOP w0.254: v2(237.5,53.49) 238.75,53.49 239.16,53.08 239.16,50.57 239.73,49.99 PR6101.2
  IN1 w0.203: v2(237.5,53.49) 237.44,53.43 237.44,52.92 236.87,52.35 229.38,52.35 227.94,53.78 227.94,62.32 231.33,65.71 231.33,71.84 230.91,72.26 225.07,72.26 224.36,72.97 221.22,72.97 v2(221.07,72.82)
  BOTTOM w0.254: RG66.1 208.11,72.22 208.4,72.52 208.92,72.52 209.58,73.18 220.72,73.18 v2(221.07,72.82)
CSSP_NVVDDS: length 84.4
  TOP w0.114: v1(201.55,68.24) 201.93,67.86 v2(201.93,67.84)
  TOP w0.254: PR6200.2 v2(239.03,46.12)
  IN1 w0.203: v2(239.03,46.12) 239.46,46.55 239.46,48.37 238.24,49.59 228.44,49.59 226.73,51.3 226.73,51.3 224.82,53.21 193.05,53.21 190.12,56.15 190.12,62.52 189.12,63.52 189.12,65.24 190.13,66.25 191.1,66.25 195.09,70.24 197.92,70.24 198.9,69.26 201.33,69.26 202.04,68.56 202.04,67.95 v2(201.93,67.84)
  BOTTOM w0.254: RG137.1 201.75,68.03 201.94,67.84 v2(201.93,67.84)
CTL1: length 82.5
  TOP w0.114: v2(22.53,48.64) 22.44,48.72 UU1.6 ; v2(65.93,10.76) 66.26,10.43 66.26,9.5 65.25,8.49 65.25,8.31 65.38,8.18 UE6.7
  IN5 w0.097: v2(22.53,48.64) 22.68,48.79 27.49,48.79 27.67,48.97 29.71,48.97 30.16,48.52 30.16,47.92 31.1,46.98 31.1,42.59 32.27,41.42 32.27,20.3 35.15,17.43 35.15,13.48 35.41,13.22 39.44,13.22 41.67,10.99 50.53,10.99 50.79,11.26 65.43,11.26 v2(65.93,10.76)
  BOTTOM w0.114: v2(22.53,48.64) 22.71,48.64 v1(23.05,48.98)
CTL2: length 83.2
  TOP w0.114: v2(22.49,49.22) UU1.7 ; UE6.8 65.3,7.68 64.95,8.04 64.95,8.57 65.93,9.55 65.93,10.06 v1(65.8,10.18) 65.53,10.45 65.53,11.07 v2(65.92,11.45)
  IN5 w0.097: v2(22.49,49.22) 22.7,49.01 27.31,49.01 27.49,49.19 29.8,49.19 30.38,48.62 30.38,48.01 31.9,46.49 31.9,42.1 32.54,41.47 32.54,20.35 35.37,17.52 35.37,13.57 35.5,13.44 39.53,13.44 41.79,11.19 50.41,11.19 50.67,11.45 v2(65.92,11.45)
DAT_SMB: length 6.5
  TOP w0.114: PR21.1 59.08,8.23 59.08,8.56 v2(58.74,8.9)
  BOTTOM w0.114: v2(58.74,8.9) 58.35,9.3 PBATT1.5
DDR_A_ACT#: length 50.8
  IN5 w0.145: v2(115,82.89) 115.55,82.34 115.55,75.84 115.06,75.35 115.06,68.65 108.12,61.71 108.12,52.75 108.75,52.12 108.75,49.07 109.21,48.62 109.21,44.96 109.42,44.75 109.91,44.75 v2(110.18,45.02)
  BOTTOM w0.076: CPU1.AU3 115.86,86.11 115.86,83.75 v2(115,82.89)
  BOTTOM w0.178: JDIMM1.114 110.27,42.68 109.48,43.48 109.48,44.32 v2(110.18,45.02)
DDR_A_ALERT#: length 55.3
  IN5 w0.089: v2(114.87,84.71) 114.87,84.52 114.57,84.21 114.57,82.07 112.59,80.09 112.59,75.35
  IN5 w0.145: 112.59,75.35 112.59,72.48 111.86,71.75 111.86,68.96 105.64,62.73 105.64,44.96 107.76,42.83 109.44,42.83 v2(110.16,43.55)
  BOTTOM w0.076: v2(114.87,84.71) 115.27,84.71 115.53,84.97 115.53,87.08 CPU1.AU5
  BOTTOM w0.178: v2(110.16,43.55) 110.42,43.55 110.77,43.2 JDIMM1.116
DDR_A_BG0: length 52.5
  IN5 w0.145: v2(107.95,45.33) 107.66,45.04 106.57,45.04 106.19,45.42 106.19,62.5 112.42,68.73 112.42,71.53 113.14,72.25 113.14,78.86 v2(113.55,79.26)
  BOTTOM w0.076: CPU1.AU1 116.14,84.52 116.13,84.52 116.13,83.46 114.84,82.17 114.49,82.17 113.16,80.84 113.16,79.65 v2(113.55,79.26)
  BOTTOM w0.178: v2(107.95,45.33) 108.85,45.33 109.51,45.99 109.51,47.66 110.53,48.67 JDIMM1.115
DDR_A_BG1: length 50.8
  IN5 w0.145: v2(113.55,80.53) 113.94,80.14 113.94,78.49 113.6,78.15 113.6,72.06 112.87,71.34 112.87,68.54 106.65,62.32 106.65,52.75 106.65,52.74 106.65,45.83 106.77,45.7 107.36,45.7 107.51,45.85 107.51,46.27 v2(107.95,46.7)
  BOTTOM w0.076: CPU1.AU2 116.14,85.48 116.41,85.2 116.41,83.51 113.55,80.64 v2(113.55,80.53)
  BOTTOM w0.178: JDIMM1.113 110.02,48.85 109.03,47.86 109.03,47.23 108.5,46.7 v2(107.95,46.7)
DDR_A_BS0: length 56.1
  IN5 w0.089: v2(122.77,83.92) 123.65,83.92 123.78,83.79 123.78,76.88 124.25,76.41 124.75,76.41 125.69,75.47 125.69,75.35
  IN5 w0.145: 125.69,75.35 125.69,70.35 124.44,69.09 124.44,65.2 123.17,63.93 123.17,59.36 120.1,56.29 120.1,44.6 120.25,44.45 120.58,44.45 120.73,44.3 120.73,44 120.58,43.85 120.25,43.85 120.01,43.62 120.01,42.67 120.28,42.4 121.61,42.4 121.89,42.67 121.89,43.44 121.76,43.57 v2(121.24,43.57)
  BOTTOM w0.076: CPU1.AH5 123.22,87.23 123.22,84.37 v2(122.77,83.92)
  BOTTOM w0.178: v2(121.24,43.57) 121.28,43.54 JDIMM1.150
DDR_A_BS1: length 53.6
  IN5 w0.089: 124.78,75.35 124.78,75.37 123.42,76.73 123.42,82.15 123.29,82.28 123,82.28 122.79,82.07 v2(122.79,82)
  IN5 w0.145: 124.78,75.35 124.78,70.72 123.53,69.47 123.53,65.58 120.79,62.85 120.79,62.63 121.14,62.29 121.14,62.11 120.88,61.86 120.71,61.86 120.36,62.21 120.16,62.21 119.92,61.97 119.92,61.38 120.1,61.2 121.91,61.2 122.06,61.05 122.06,60.75 121.91,60.6 120.1,60.6 119.95,60.45 119.95,60.18 120.18,59.95 121.92,59.95 122.07,59.8 122.07,59.56 121.95,59.43 120.1,59.43 119.95,59.28 119.95,58.98 120.1,58.83 120.75,58.83 120.9,58.68 120.9,58.38 120.75,58.23 120.1,58.23 119.95,58.08 119.95,57.48 119.19,56.71 v2(119.19,48.4)
  BOTTOM w0.076: CPU1.AH1 123.68,82.89 v2(122.79,82)
  BOTTOM w0.178: JDIMM1.145 120.02,48.69 119.73,48.4 v2(119.19,48.4)
DDR_A_CAS#: length 56.3
  IN5 w0.145: v2(123.94,44.59) 123.94,44.44 124.26,44.11 124.92,44.11 125.05,44.24 125.05,45.11 124.9,45.26 124.33,45.26 124.18,45.41 124.18,45.71 124.33,45.86 124.9,45.86 125.05,46.01 125.05,46.31 124.9,46.46 124.34,46.46 124.19,46.6 124.19,46.9 124.34,47.05 124.9,47.05 125.05,47.2 125.05,51.73 124.82,51.96 124.35,51.96 124.2,52.11 124.2,52.36 124.33,52.48 124.9,52.48 125.05,52.63 125.05,52.93 124.9,53.08 124.35,53.08 124.2,53.23 124.2,53.53 124.35,53.68 124.9,53.68 125.05,53.83 125.05,54.13 124.81,54.38 124.35,54.38 124.2,54.53 124.2,55.61 129.07,60.48 129.07,75.35
  IN5 w0.15: v2(125.3,78.82) 125.6,78.82 129.07,75.35
  BOTTOM w0.076: CPU1.AD1 127.08,84.93 127.08,80.6 v2(125.3,78.82)
  BOTTOM w0.178: v2(123.94,44.59) 123.83,44.59 122.77,43.53 JDIMM1.156
DDR_A_D0: length 58.7
  IN5 w0.097: v2(83.01,45.17) 83.25,44.92 83.54,44.92 83.66,45.05 83.66,45.27 83.57,45.37 83.51,45.37 83.41,45.46 83.41,45.66 83.51,45.75 83.57,45.75 83.66,45.85 83.66,46.04 83.57,46.14 83.51,46.14 83.41,46.24 83.41,46.43 83.51,46.53 83.57,46.53 83.66,46.62 83.66,46.82 83.57,46.91 83.51,46.91 83.41,47.01 83.41,47.2 83.51,47.3 83.57,47.3 83.66,47.4 83.66,52.87 90.12,59.32 90.12,67.62 96.92,74.42 96.92,75.75 97.19,76.03 97.19,84.12 100.21,87.14 100.32,87.25 100.91,87.25 v2(100.94,87.22)
  BOTTOM w0.076: CPU1.BR6 103.4,88.38 102.57,88.38 102.52,88.32 102.17,88.32 102.09,88.4 101.44,88.4 100.94,87.91 v2(100.94,87.22)
  BOTTOM w0.114: v2(83.01,45.17) 82.55,44.71 82.55,43.29 82.78,43.07 JDIMM1.4
DDR_A_D1: length 58.6
  IN5 w0.097: v2(102.32,88.68) 101.43,88.68 100.43,87.69 99.91,87.69 99.21,86.99 96.59,84.37 96.59,78.06 95.65,77.11 95.65,73.99 89.52,67.87 89.52,59.57 83.01,53.06 83.01,52.94 82.56,52.49 82.43,52.49 82.3,52.37 82.3,52.05 82.4,51.96 82.91,51.96 83.01,51.85 83.01,51.67 82.91,51.57 82.4,51.57 82.3,51.47 82.3,51.28 82.4,51.19 82.91,51.19 83.01,51.08 83.01,50.9 82.91,50.8 82.4,50.8 82.3,50.7 82.3,46.56 82.43,46.44 v2(83.01,46.44)
  BOTTOM w0.076: v2(102.32,88.68) CPU1.BT6
  BOTTOM w0.114: JDIMM1.3 82.53,46.92 v2(83.01,46.44)
DDR_A_D2: length 59.1
  IN5 w0.097: v2(101.81,85.8) 101.94,85.67 101.94,85.07 99.29,82.41 99.29,75.17 99.01,74.89 99.01,73.54 92.21,66.75 92.21,58.45 89.21,55.44 89.21,55.02 89.11,54.92 88.69,54.92 88.59,54.83 88.59,54.64 88.69,54.54 89.11,54.54 89.21,54.44 89.21,51.47 89.15,51.41 89.15,51.33 87.99,50.17 87.91,50.17 86.44,48.7 86.44,47.52 86.68,47.28 86.68,46.41 86.58,46.31 86.21,46.31 86.12,46.21 86.12,46.02 86.21,45.92 86.58,45.92 86.68,45.83 86.68,45.63 86.58,45.54 86.21,45.54 86.12,45.44 86.12,45.25 86.21,45.15 86.58,45.15 86.68,45.06 86.68,44.62 86.55,44.49 86.2,44.49 86.07,44.62 86.07,44.7 85.67,45.1 v2(85.67,45.17)
  BOTTOM w0.076: v2(101.81,85.8) 101.81,86.32 102.03,86.54 102.53,86.54 102.75,86.77 103.33,86.77 103.35,86.79 103.91,86.79 CPU1.BP3
  BOTTOM w0.114: JDIMM1.20 86.78,44.07 v2(85.67,45.17)
DDR_A_D3: length 58.4
  IN5 w0.097: v2(101.48,85.28) 101.43,85.33 100.94,85.33 98.69,83.08 98.69,75.42 98.41,75.13 98.41,73.79 91.61,67 91.61,58.7 87.87,54.96 87.87,54 87.75,53.87 86.78,53.87 86.68,53.77 86.68,53.58 86.78,53.48 87.78,53.48 87.87,53.39 87.87,53.16 87.78,53.07 86.79,53.07 86.68,52.96 86.68,52.78 86.79,52.68 87.78,52.68 87.87,52.59 87.87,52.39 87.78,52.3 86.8,52.3 86.71,52.2 86.71,52.01 86.8,51.91 87.78,51.91 87.87,51.81 87.87,51.62 87.78,51.52 86.75,51.52 86.63,51.4 86.63,51.17 86.72,51.08 87.29,51.08 87.39,50.98 87.39,50.79 87.29,50.69 86.44,50.69 86.34,50.59 86.34,50.35 86.44,50.25 86.71,50.25 86.84,50.13 86.84,49.95 85.84,48.95 85.84,47.87 v2(85.67,47.71)
  BOTTOM w0.076: v2(101.48,85.28) 101.53,85.33 101.88,85.33 102.54,86 102.97,86 103.44,86.47 CPU1.BR3
  BOTTOM w0.114: JDIMM1.17 86.02,48.06 v2(85.67,47.71)
DDR_A_D4: length 59.1
  IN5 w0.097: v2(100.47,86.88) 97.5,83.91 97.5,75.91 97.22,75.63 97.22,74.29 90.42,67.49 90.42,59.19 83.96,52.74 83.96,44.85 v2(83.01,43.9)
  BOTTOM w0.076: v2(100.47,86.88) 100.47,87.68 101.37,88.57 101.7,88.57 102.17,89.03 103.16,89.03 103.32,88.88 104.09,88.88 104.47,88.5 104.47,88.04 CPU1.BN5
  BOTTOM w0.114: JDIMM1.8 83.78,43.13 v2(83.01,43.9)
DDR_A_D5: length 58.3
  IN5 w0.097: v2(83.01,47.71) 82.92,47.62 82.73,47.62 82.6,47.75 82.6,48.76 82.7,48.86 83.27,48.86 83.36,48.95 83.36,49.15 83.27,49.24 82.7,49.24 82.6,49.34 82.6,49.53 82.7,49.63 83.27,49.63 83.36,49.73 83.36,49.92 83.27,50.02 82.7,50.02 82.6,50.11 82.6,50.31 82.7,50.4 83.22,50.4 83.31,50.5 83.31,52.94 89.82,59.44 89.82,67.74 96.62,74.54 96.62,75.88 96.89,76.16 96.89,84.24 100.08,87.43 100.44,87.43 101.03,88.02 101.23,88.02 101.36,87.88 101.36,87.7 v2(101.31,87.65)
  BOTTOM w0.076: CPU1.BP6 104.18,88.38 103.79,87.99 103.38,87.99 103.3,88.07 103.26,88.07 103.11,88.21 102.7,88.21 102.64,88.16 102.1,88.16 102.02,88.24 101.5,88.24 101.31,88.05 v2(101.31,87.65)
  BOTTOM w0.114: JDIMM1.7 83.53,48.86 83.58,48.8 83.58,48.16 83.13,47.71 v2(83.01,47.71)
DDR_A_D6: length 58.5
  IN5 w0.097: v2(85.67,43.9) 85.67,42.72 85.8,42.59 86.85,42.59 86.97,42.72 86.97,42.94 86.88,43.04 86.47,43.04 86.37,43.13 86.37,43.33 86.47,43.42 86.88,43.42 86.97,43.52 86.97,43.71 86.88,43.81 86.47,43.81 86.37,43.9 86.37,44.1 86.47,44.19 86.88,44.19 86.97,44.29 86.97,47.4 86.73,47.64 86.73,48.57 88.03,49.87 88.12,49.87 89.45,51.21 89.45,51.29 89.51,51.35 89.51,55.32 92.51,58.32 92.51,66.62 99.31,73.42 99.31,74.71 99.59,74.99 99.59,81.72 v2(100.8,82.93)
  BOTTOM w0.076: CPU1.BP2 104.46,85.64 104.46,84.95 104.26,84.76 104.17,84.76 103.52,84.1 103.25,84.1 102.08,82.93 v2(100.8,82.93)
  BOTTOM w0.114: v2(85.67,43.9) 85.78,43.8 JDIMM1.16
DDR_A_D7: length 58.8
  IN5 w0.097: v2(85.67,46.44) 85.92,46.44 86.14,46.65 86.14,48.82 87.79,50.47 87.87,50.47 88.4,51.01 88.4,51.17 88.86,51.63 88.86,51.83 88.77,51.92 88.27,51.92 88.17,52.02 88.17,52.21 88.27,52.31 88.81,52.31 88.91,52.41 88.91,52.6 88.81,52.69 88.27,52.69 88.17,52.79 88.17,52.98 88.27,53.08 88.81,53.08 88.91,53.18 88.91,53.37 88.81,53.47 88.27,53.47 88.17,53.56 88.17,53.76 88.27,53.85 88.81,53.85 88.91,53.95 88.91,54.14 88.81,54.24 88.27,54.24 88.17,54.34 88.17,54.83 91.91,58.57 91.91,66.87 98.71,73.67 98.71,75.01 98.99,75.29 98.99,82.68 v2(100.65,84.34)
  BOTTOM w0.076: v2(100.65,84.34) 101.05,84.34 101.73,85.02 101.89,85.02 102.04,84.87 102.59,84.87 103.18,85.46 103.18,85.56 103.18,85.91 103.2,85.94 103.39,86.13 103.61,86.13 103.72,86.24 104.62,86.24 CPU1.BN3
  BOTTOM w0.114: v2(85.67,46.44) 86.56,46.44 87.02,46.9 JDIMM1.21
DDR_A_D8: length 55.6
  IN5 w0.097: v2(106.47,86.71) 104.62,84.86 103.8,84.86 100.62,81.68 100.62,73.27 93.54,66.2 93.54,57.9 91.51,55.86 91.51,53.06 90.77,52.33 90.77,50.62 89.22,49.07 89.22,48.04 89.13,47.95 88.95,47.95 88.85,47.85 88.85,47.66 88.95,47.56 89.13,47.56 89.22,47.46 89.22,47.24 88.99,47.01 88.85,47.01 88.35,47.51 88.21,47.51 88.08,47.37 88.08,47.24 88.58,46.73 88.58,46.6 88.42,46.44 v2(87.71,46.44)
  BOTTOM w0.076: v2(106.47,86.71) 106.15,87.04 CPU1.BL4
  BOTTOM w0.114: JDIMM1.29 89.02,47.76 v2(87.71,46.44)
DDR_A_D9: length 55.3
  IN5 w0.097: v2(87.71,47.71) 87.47,47.95 87.47,48.27 87.68,48.48 87.82,48.48 88.36,47.95 88.49,47.95 88.63,48.08 88.63,48.22 88.09,48.76 88.09,48.89 88.34,49.14 88.87,49.14 90.26,50.53 90.26,52.67 90.36,52.77 90.79,52.77 90.89,52.87 90.89,53.06 90.79,53.16 90.55,53.16 90.45,53.25 90.45,53.44 90.55,53.54 91.11,53.54 91.21,53.64 91.21,53.83 91.11,53.93 90.55,53.93 90.45,54.02 90.45,54.22 90.55,54.31 91.11,54.31 91.21,54.41 91.21,54.6 91.01,54.8 91.01,55.79 93.24,58.02 93.24,66.32 100.32,73.4 100.32,81.64 103.72,85.05 104.29,85.05 106.47,87.23 v2(106.47,87.36)
  BOTTOM w0.076: CPU1.BL5 106.15,87.69 v2(106.47,87.36)
  BOTTOM w0.114: JDIMM1.25 88.02,48.03 v2(87.71,47.71)
DDR_A_D10: length 55.8
  IN5 w0.097: v2(103.95,83.37) 104.05,83.27 104.05,82.81 103.05,81.81 103.05,72.6 95.64,65.19 95.64,55.76 94.11,54.23 94.11,53.36 94.02,53.26 93.7,53.26 93.6,53.16 93.6,52.97 93.7,52.87 94.02,52.87 94.11,52.78 94.11,50.95 92.17,49.01 92.17,47.37 92.07,47.27 91.68,47.27 91.58,47.17 91.58,46.98 91.68,46.88 92.07,46.88 92.17,46.79 92.17,45.86 92.04,45.73 91.62,45.73 v2(90.92,46.44)
  BOTTOM w0.076: CPU1.BL2 105.79,85.74 105.2,85.14 105.2,84.92 105,84.72 104.57,84.72 103.95,84.1 v2(103.95,83.37)
  BOTTOM w0.114: v2(90.92,46.44) 90.92,46.46 91.45,46.99 91.91,46.99 92.02,47.1 92.02,47.34 91.9,47.47 91.46,47.47 91.34,47.58 91.34,47.81 91.46,47.93 91.91,47.93 92.02,48.04 92.02,48.27 91.91,48.38 91.46,48.38 91.34,48.5 91.34,48.73 91.46,48.84 91.91,48.84 92.02,48.95 JDIMM1.41
DDR_A_D11: length 55.8
  IN5 w0.097: v2(90.92,45.17) 91.2,45.17 91.32,45.04 91.32,43.93 91.45,43.8 92.19,43.8 92.31,43.93 92.31,44.11 92.22,44.21 91.87,44.21 91.77,44.3 91.77,44.5 91.87,44.59 92.37,44.59 92.47,44.69 92.47,44.88 92.37,44.98 92.25,44.98 92.15,45.08 92.15,45.27 92.25,45.36 92.34,45.36 92.47,45.49 92.47,48.88 94.41,50.82 94.41,54.11 95.94,55.63 95.94,65.07 103.35,72.48 103.35,80.42 104.23,81.31 104.23,82.26 105.1,83.13 105.1,83.41 104.74,83.78 v2(104.39,83.78)
  BOTTOM w0.076: CPU1.BM1 105.6,85.09 105.06,84.55 104.67,84.55 104.39,84.27 v2(104.39,83.78)
  BOTTOM w0.114: v2(90.92,45.17) 90.94,45.17 92.27,43.84 JDIMM1.42
DDR_A_D12: length 55.5
  IN5 w0.097: v2(87.71,43.9) 87.71,43.73 87.83,43.6 88.89,43.6 89.02,43.73 89.02,46.19 89.82,46.99 89.82,48.77 92.11,51.06 92.11,55.61 94.14,57.65 94.14,65.82 101.42,73.1 101.42,81.96 103.95,84.49 105.03,84.49 107.25,86.71 v2(107.26,86.71)
  BOTTOM w0.076: v2(107.26,86.71) CPU1.BK4
  BOTTOM w0.114: JDIMM1.24 87.78,43.83 v2(87.71,43.9)
DDR_A_D13: length 55.9
  IN5 w0.097: v2(87.71,45.17) 88.59,45.17 88.72,45.29 88.72,46.31 89.52,47.12 89.52,48.9 91.07,50.45 91.07,52.2 91.81,52.94 91.81,55.74 93.84,57.77 93.84,66.07 100.92,73.15 100.92,81.72 103.88,84.68 104.95,84.68 106.88,86.61 106.88,86.93 v2(107.27,87.31)
  BOTTOM w0.089: v2(107.27,87.31) 106.89,87.69 CPU1.BK5
  BOTTOM w0.114: JDIMM1.28 88.78,42.54 88.12,43.19 88.12,44.76 v2(87.71,45.17)
DDR_A_D14: length 55.4
  IN5 w0.097: v2(105.39,84.32) 105.73,84.32 105.93,84.12 105.93,83.69 104.42,82.18 104.42,81.23 103.65,80.46 103.65,72.35 96.24,64.95 96.24,55.51 95.01,54.28 94.73,53.99 94.73,53.18 94.71,53.16 94.71,50.7 92.77,48.76 92.77,44.35 92.61,44.19 92.61,43.6 92.52,43.5 91.8,43.5 91.71,43.41 91.71,43.21 91.8,43.12 92.52,43.12 92.61,43.02 92.61,42.78 92.49,42.65 91.58,42.65 90.92,43.31 v2(90.92,43.9)
  BOTTOM w0.076: v2(105.39,84.32) 105.61,84.54 105.74,84.54 106.28,85.09
  BOTTOM w0.089: CPU1.BK1 106.28,85.09
  BOTTOM w0.114: JDIMM1.38 91.27,43.54 v2(90.92,43.9)
DDR_A_D15: length 56
  IN5 w0.089: 102.75,75.35 102.86,75.47 102.86,81.15 102.74,81.28 102.34,81.28 v2(102.17,81.11)
  IN5 w0.097: 102.75,75.35 102.75,72.73 95.34,65.32 95.34,57.15 94.98,56.79 94.98,56.65 95.34,56.29 95.34,56.16 95.2,56.02 95.07,56.02 94.7,56.38 94.57,56.38 94.43,56.24 94.43,56.11 94.93,55.61 94.93,55.47 94.79,55.34 94.66,55.34 94.16,55.83 94.02,55.83 93.89,55.7 93.89,55.56 94.38,55.06 94.38,54.93 94.25,54.79 94.11,54.79 93.61,55.29 93.48,55.29 93.3,55.12 93.3,54.84 93.4,54.74 93.71,54.74 93.8,54.65 93.8,54.45 93.71,54.36 93.4,54.36 93.3,54.26 93.3,54.04 93.4,53.94 93.64,53.94 93.74,53.84 93.74,53.65 93.64,53.55 93.4,53.55 93.3,53.46 93.3,50.56 91.87,49.13 91.87,48.54 91.77,48.44 91.62,48.44 91.52,48.34 91.52,48.16 91.62,48.06 91.77,48.06 91.87,47.96 91.87,47.74 91.7,47.57 91.06,47.57 v2(90.92,47.71)
  BOTTOM w0.089: CPU1.BK2 107.15,85.45 107.15,84.49 103.76,81.11 v2(102.17,81.11)
  BOTTOM w0.114: v2(90.92,47.71) 91.02,47.81 JDIMM1.37
DDR_A_D16: length 52.1
  IN5 w0.097: v2(93.28,47.71) 93.72,48.14 93.72,48.67 95.44,50.4 95.44,51.28 95.54,51.37 95.62,51.37 95.72,51.47 95.72,51.66 95.62,51.76 95.54,51.76 95.44,51.86 95.44,52.05 95.54,52.15 95.62,52.15 95.72,52.24 95.72,52.44 95.62,52.53 95.55,52.53 95.44,52.64 95.44,52.86 95.55,52.97 96.14,52.97 96.24,53.07 96.24,53.26 96.14,53.36 95.55,53.36 95.46,53.45 95.46,53.69 95.62,53.85 95.75,53.85 95.8,53.8 95.94,53.8 96.07,53.94 96.07,54.08 96.03,54.12 96.03,54.26 96.97,55.2 96.97,64.64 104.38,72.05 104.38,78.98 104.09,79.27 104.09,80.64 104.6,81.16 104.6,82.1 106.87,84.37 107.14,84.37 107.32,84.18 107.32,83.96 v2(107.27,83.9)
  BOTTOM w0.076: CPU1.BG4 108.36,87.04 107.99,86.67 107.99,85.48 107.89,85.37 107.89,84.65 108.02,84.52 108.02,84.17 107.75,83.9 v2(107.27,83.9)
  BOTTOM w0.114: v2(93.28,47.71) 93.02,47.96 JDIMM1.45
DDR_A_D17: length 52.8
  IN5 w0.097: v2(106.88,83.46) 106.22,83.46 104.79,82.03 104.79,81.08 104.28,80.56 104.28,79.34 104.68,78.94 104.68,71.93 97.27,64.52 97.27,55.08 96.54,54.35 96.54,52.75 96.01,52.23 96.01,50.54 94.02,48.55 94.02,48.02 93.66,47.66 93.66,46.82 v2(93.28,46.44)
  BOTTOM w0.076: v2(106.88,83.46) 107.54,83.46 108.19,84.1 108.19,84.66 108.15,84.7 108.15,85.34 108.24,85.43 108.24,86.43 108.57,86.76 108.71,86.76 108.87,86.92 108.87,87.41 CPU1.BG5
  BOTTOM w0.114: v2(93.28,46.44) 94.02,47.18 JDIMM1.49
DDR_A_D18: length 52.2
  IN5 w0.097: v2(96.84,46.44) 96.91,46.36 97.49,46.36 97.62,46.49 97.62,46.67 97.52,46.77 97.34,46.77 97.24,46.86 97.24,47.06 97.34,47.15 97.52,47.15 97.62,47.25 97.62,47.44 97.52,47.54 97.34,47.54 97.24,47.64 97.24,47.83 97.34,47.93 97.52,47.93 97.62,48.02 97.62,48.21 97.52,48.31 97.45,48.31 97.36,48.41 97.36,48.6 97.45,48.7 97.52,48.7 97.62,48.79 97.62,49.18 99.36,50.93 99.36,63.65 106.77,71.06 106.77,78.21 106.77,82.16 108.94,84.33 108.94,86.55 109.24,86.85 109.67,86.85 v2(109.76,86.76)
  BOTTOM w0.076: v2(109.76,86.76) 109.49,87.04 CPU1.BF4
  BOTTOM w0.114: v2(96.84,46.44) 97.53,47.13 JDIMM1.63
DDR_A_D19: length 51.5
  IN5 w0.097: v2(96.84,47.71) 96.48,47.71 96.34,47.85 96.34,48.33 96.5,48.48 96.63,48.48 96.72,48.4 96.85,48.4 97.06,48.6 97.06,48.74 96.97,48.83 96.97,48.96 99.06,51.05 99.06,52.13 98.91,52.28 98.43,52.28 98.33,52.38 98.33,52.57 98.43,52.67 98.97,52.67 99.06,52.77 99.06,52.93 98.94,53.06 98.43,53.06 98.33,53.15 98.33,53.35 98.43,53.44 98.97,53.44 99.06,53.54 99.06,63.77 106.47,71.18 106.47,82.13 108.75,84.41 108.75,86.62 109.49,87.36 v2(109.77,87.36)
  BOTTOM w0.076: CPU1.BF5 109.45,87.69 v2(109.77,87.36)
  BOTTOM w0.114: JDIMM1.59 96.53,48.02 v2(96.84,47.71)
DDR_A_D20: length 52.8
  IN5 w0.097: v2(106.1,82.56) 105.58,82.56 104.97,81.95 104.97,81 104.46,80.49 104.46,79.42 104.98,78.9 104.98,71.8 97.57,64.39 97.57,54.7 96.84,53.97 96.84,52.63 96.31,52.1 96.31,50.42 94.32,48.42 94.32,45.29 94.19,45.17 v2(93.28,45.17)
  BOTTOM w0.076: CPU1.BG2 108.4,85.55 108.4,85.31 108.31,85.22 108.31,84.84 108.48,84.68 108.48,83.91 107.69,83.12 107.22,83.12 106.65,82.56 v2(106.1,82.56)
  BOTTOM w0.114: v2(93.28,45.17) 93.29,45.17 94.27,44.19 JDIMM1.50
DDR_A_D21: length 51.8
  IN5 w0.097: v2(93.28,43.9) 94.49,43.9 94.62,44.02 94.62,48.3 96.61,50.3 96.61,51.98 97.14,52.5 97.14,53.84 97.87,54.57 97.87,64.27 105.28,71.68 105.28,78.87 104.65,79.49 104.65,80.41 105.22,80.98 105.22,81.67 v2(105.65,82.11)
  BOTTOM w0.076: CPU1.BG1 108.59,84.96 108.68,84.87 108.68,83.82 106.97,82.11 v2(105.65,82.11)
  BOTTOM w0.114: JDIMM1.46 93.27,43.89 v2(93.28,43.9)
DDR_A_D22: length 51.8
  IN5 w0.097: v2(96.84,43.9) 96.84,43.6 96.96,43.48 97.83,43.48 97.96,43.6 97.96,44.22 97.86,44.31 97.39,44.31 97.29,44.41 97.29,44.6 97.39,44.7 97.86,44.7 97.96,44.8 97.96,45.02 98.22,45.28 98.22,48.93 99.96,50.68 99.96,63.4 107.37,70.81 107.37,80.99 107.2,81.16 107.2,82.07 109.77,84.64 v2(109.77,84.76)
  BOTTOM w0.076: CPU1.BF1 109.45,85.09 v2(109.77,84.76)
  BOTTOM w0.114: JDIMM1.62 97.27,43.46 v2(96.84,43.9)
DDR_A_D23: length 51.7
  IN5 w0.097: v2(96.84,45.17) 97,45 97.52,45 97.92,45.4 97.92,45.58 97.82,45.68 97.34,45.68 97.24,45.77 97.24,45.97 97.34,46.06 97.82,46.06 97.92,46.16 97.92,49.06 99.66,50.8 99.66,63.53 107.07,70.93 107.07,81.02 106.96,81.14 106.96,82.09 109.41,84.54 109.41,84.91 109.77,85.28 v2(109.77,85.41)
  BOTTOM w0.076: v2(109.77,85.41) 109.45,85.74 CPU1.BF2
  BOTTOM w0.114: v2(96.84,45.17) 96.27,44.6 JDIMM1.58
DDR_A_D24: length 50.9
  IN5 w0.097: v2(99.35,47.71) 99.35,47.64 99.71,47.28 99.93,47.28 100.06,47.41 100.06,47.68 100.15,47.78 100.59,47.78 100.69,47.88 100.69,48.16 100.59,48.26 99.78,48.26 99.68,48.35 99.68,48.94 99.81,49.07 100.49,49.07 100.6,49.18 100.6,49.31 100.4,49.52 100.4,49.66 100.53,49.79 100.67,49.79 101,49.46 101.14,49.46 101.28,49.6 101.28,49.73 100.94,50.06 100.94,50.2 101.1,50.36 101.1,63.08 108.4,70.38 108.4,75.35 108.97,75.92 108.97,82.01 108.84,82.14 v2(108.43,82.14)
  BOTTOM w0.076: CPU1.BD2 111.11,85.5 110.83,85.22 110.83,84.84 110.89,84.78 110.89,83.79 109.88,82.78 109.62,82.78 108.98,82.14 v2(108.43,82.14)
  BOTTOM w0.114: JDIMM1.67 98.53,48.54 v2(99.35,47.71)
DDR_A_D25: length 51.3
  IN5 w0.097: v2(99.35,43.9) 99.35,43.29 99.23,43.16 98.82,43.16 98.69,43.29 98.69,44.72 98.95,44.97 98.95,48.63 100.8,50.48 100.8,63.21 108.1,70.51 108.1,81.56 v2(107.98,81.69)
  BOTTOM w0.076: v2(107.98,81.69) 109.11,81.69 109.86,82.44 111.11,83.68 CPU1.BD1
  BOTTOM w0.114: v2(99.35,43.9) 99.27,43.82 JDIMM1.70
