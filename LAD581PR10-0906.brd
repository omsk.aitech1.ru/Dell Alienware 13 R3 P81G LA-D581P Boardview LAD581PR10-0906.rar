# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35VS_VGA_PGOOD: length 281.5
  TOP w0.203: PU8200.13 253.82,64.22 254.03,64.43 v1(254.03,64.77) 253.86,64.93 253.86,65.54 PR8204.1
  TOP w0.254: v2(89.04,65.94) 89.04,65.82 89.41,65.45 91.57,65.45 92.5,64.53 92.77,64.53 92.96,64.72 UG25.1 ; PR8204.1 254,65.63 v2(254.59,65.05)
  IN2 w0.254: v2(89.04,65.94) 89.46,65.52 140.23,65.52 v2(146,71.28)
  IN3 w0.254: v2(146,71.28) 146,71.14 145.49,70.64 145.49,65.05 146.13,64.41 149.34,64.41 151.69,66.76 157.88,66.76 159.59,65.05 159.59,64.53 160.08,64.03 163.81,64.03 168.03,59.81 171.97,59.81 172.58,59.21 172.58,58.25 173.6,57.23 176.47,57.23 176.87,57.63 176.87,58.81 176.29,59.4 175.89,59.4 174.91,60.38 174.91,61.5 175.95,62.54 177.56,62.54 183.85,68.83 v2(183.85,73.61)
  IN5 w0.254: v2(254.59,65.05) 255.28,65.05 255.91,64.43 255.91,57.32 254.57,55.98 254.57,46.62 253.7,45.74 242.33,45.74 239.82,48.25 227.25,48.25 223.45,44.45 223.45,35.06 222.85,34.46 219.61,34.46 216.87,31.71 216.87,30.44 215.84,29.41 214.36,29.41 214.26,29.52 209.54,29.52 206.77,32.28 205.44,32.28 202.83,29.68 202.71,29.68 202.45,29.42 199.09,29.42 198.77,29.11 196.48,29.11 193.31,32.28 193.31,36.44 191.45,38.3 191.45,42.27 190.73,42.99 190.73,48.04 190.53,48.25 190.53,50.68 186.53,54.69 186.53,56.35 186.26,56.61 186.26,60.93 186.49,61.15 186.49,63.49 184.85,65.12 184.85,65.68 186.03,66.86 v2(186.03,69.07) 185.71,69.07 185.24,69.54 185.24,72.22 v2(183.85,73.61)
  BOTTOM w0.254: UG29.1 186.22,68.88 v2(186.03,69.07)
+1.35VS_VGAP: length 41.2
  TOP w0.254: PR8209.2 255.58,65.95 255.58,67.42 255.41,67.59 v2(255.41,67.58)
  IN5 w0.254: v2(227.28,65.18) 228.42,65.18 232.36,69.11 232.36,72.41 233.12,73.18 241.57,73.18 242.71,74.32 246.97,74.32 248.9,72.39 248.9,71.54 251.53,68.91 254.08,68.91 v2(255.41,67.58)
  BOTTOM w0.114: 233.02,70.34 233.02,71.25 v1(232.27,72)
+1V8_AON: length 523.2
  TOP w0.089: RG79.2 176.8,78.46
  TOP w0.254: RG19.2 183.4,84.92 183.52,85.04
  TOP w0.35: v2(184.9,88.45) 185.02,88.57 185.58,88.57 v2(185.65,88.5)
  TOP w0.356: UG26.5 95.5,67.74 95.73,67.97 CG439.1 95.73,68.63 94.83,69.53 93.53,69.53 93.51,69.51 92.83,69.51 92.81,69.53 90.27,69.53 90.09,69.35 v2(90.06,69.39) ; RG16.2 182.65,75.02 182.93,74.74 v2(183.2,74.74) ; RG503.2 184.47,79.79 184.66,79.6 RG9.2 ; UG22.5 181.26,60.97 181.59,60.64 RG516.1 ; v2(186.46,80.8) 186.37,80.89 RG522.2 ; UG28.5 89.92,66.71 89.42,67.21 ; CG444.1 90.37,67.52 90.25,67.4 89.61,67.4 89.42,67.21 ; v2(192.86,70.38) 192.67,70.57 191.43,70.57 190.79,71.21 190.79,74.17 189.66,75.3 CG440.1 189.66,76.25 189.13,76.78 UG27.5 ; 89.42,67.21 v2(89.1,67.21) ; CG246.1 181.19,59 v2(181.08,59) ; v2(186.88,73.96) 186.76,73.96 RG504.2
  TOP w0.381: RG9.2 RG522.2 ; CG246.1 RG516.1 ; v2(183.99,54.5) 184.02,54.54 QG511.2
  TOP w0.508: RG82.2 176.93,79.59 v2(176.73,79.4) 176.93,79.21 RG79.2 ; 180.1,76.92 180.16,76.86 180.61,76.86 181.12,77.37 RG83.2 ; 180.1,76.92 v2(180.04,76.86) ; 180.1,76.92 180.1,77.42 RG78.2 ; RG510.1 177.8,58.33 178.07,58.06 v2(178.07,57.94) ; v2(258.59,69.3) 255.41,69.3 254.46,68.35 254.46,67.5 254.92,67.04 PR8204.2 ; v2(194.71,147.85) 193.37,147.85 192.91,148.31 RX7.1 192.05,149.95 RX5.1 ; 176.8,78.46 175.03,78.46 v2(174,77.43)
  IN1 w0.508: v2(186.46,80.8) 186.13,80.47 186.13,76.05 186.88,75.3 v2(186.88,73.96)
  IN2 w0.356: v2(89.1,67.21) 88.91,67.21 88.28,67.84 88.28,69.11 88.91,69.75 89.7,69.75 v2(90.06,69.39) 93.12,66.32 139.9,66.32 144.29,70.7 144.29,73.43 v2(145.3,74.45)
  IN2 w0.457: 186.12,89.01 185.65,88.54 v2(185.65,88.5)
  IN2 w0.508: 186.12,89.01 186.39,89.28 186.39,95.15 186.13,95.4 179.27,95.4 178.77,95.91 178.77,97.12 175.46,100.42 175.46,111.53 174.7,112.29 174.7,134.71 173.56,135.85 173.56,138.14 177.21,141.79 177.21,143.76 179.21,145.76 180.86,145.76 v2(181.88,146.77) ; v2(170.96,85.94) 170.45,85.43 170.45,84.82 168.83,83.21 v2(168.67,83.21) 168.67,82.96 166.07,80.35 166.07,79.72 v2(166.19,79.59)
  IN3 w0.356: v2(145.3,74.45) 145.37,74.51 145.89,74.51 145.96,74.45 154.64,74.45 158.45,78.26 164.86,78.26 v2(166.19,79.59) ; v2(187.21,59.14) 186.5,58.43 186.5,54.91 186.09,54.5 v2(183.99,54.5)
  IN3 w0.508: v2(194.71,147.85) 194.87,147.85 198.68,144.05 231.45,144.05 232.47,145.07 232.47,145.87 233.12,146.52 233.92,146.52 236.37,148.96 236.37,153.82 236.01,154.17 236.01,155.14 237.18,156.31 237.65,156.79 243.97,156.79 246.72,154.03 246.72,103.59 247.08,103.23 247.08,94.17 246.64,93.73 246.64,91.25 247.01,90.87 247.45,90.87 247.6,91.02 247.92,91.02 248.36,90.58 248.36,89.08 250.06,87.39 250.06,72.6 253.33,69.32 258.56,69.32 v2(258.59,69.3) ; v2(170.96,85.94) 171.02,85.94 174.7,89.62 174.7,94.07 174.13,94.64 v2(174.13,95.34) ; v2(167.72,160.45) 167.99,160.72 171.52,160.72 172.92,159.32 v2(173.13,159.32) 173.26,159.32 173.59,159 173.59,156.89 172.63,155.94 172.63,151.42 177.28,146.77 v2(181.88,146.77)
  IN4 w0.508: v2(194.71,147.85) 194.71,148.3 193.72,149.28 190.29,149.28 188.99,147.98 186.77,147.98 185.94,148.8 183.91,148.8 v2(181.88,146.77)
  IN5 w0.508: 177.97,78.16 179.18,78.16 180.04,77.3 v2(180.04,76.86) ; 177.97,78.16 v2(176.73,79.4) 175.72,79.4 174.53,80.59 174.53,83.64 172.23,85.94 v2(170.96,85.94) ; 177.97,78.16 177.97,74.99 v2(178.45,74.51)
  BOTTOM w0.25: UG9.BC14 v2(184.9,88.45)
  BOTTOM w0.254: UG9.BB14 185.4,88.75 v2(185.65,88.5) ; UG9.BA10 v2(185.7,85.65)
  BOTTOM w0.356: RV648.1 v2(173.13,159.32) ; CG1.1 187.14,61.77 UG10.5 186.1,60.93 186.67,60.36 186.67,58.84 RG13.2 186.89,58.83 v2(187.21,59.14) ; RV652.1 167.97,160.2 v2(167.72,160.45) ; v2(186.88,73.96) 187.34,73.51 RG12.1 ; RG8.2 183.36,75.91 RG15.2 183.36,74.9 v2(183.2,74.74) ; RG21.2 187.94,65.95 RG18.2 187.34,66.61 v2(187.31,66.64) 186.97,66.98 UG29.5 186.36,66.98 186.23,66.85 CG483.1
  BOTTOM w0.381: RG14.2 178.58,62.84
  BOTTOM w0.508: RG17.2 183.39,65.49 v2(182.96,65.49) 182.01,64.54 182.01,64.22 181.05,63.27 180.48,63.27 180.35,63.14 178.88,63.14 178.58,62.84 ; 169.62,69.87 169.62,66.87 168.23,65.47 ; 169.62,69.87 UG15.3 169.62,72 169.2,72.41 166.19,72.41 ; 169.62,69.87 171.72,69.87 171.79,69.95 CG241.1 173.13,69.95 173.88,70.7 173.88,72.97 RG500.1 v1(174.89,73.1) RG81.2 RG80.2 177.65,73.1 178.45,73.9 v2(178.45,74.51) 178.39,74.57 178.39,75.07 RG502.1 ; 168.23,65.47 168.35,65.34 UG15.7 ; 168.23,65.47 167.44,65.47 167.08,65.11 UG15.8 ; v2(166.19,79.59) 166.13,79.53 UG13.3 ; RG2.2 173.98,95.49 v2(174.13,95.34) ; RG74.1 165.83,72.78 166.19,72.41 ; v2(189.24,71.91) 189.05,71.72 RG11.1 ; 166.19,72.41 165.81,72.03 165.81,70.31 RG147.1 ; RG86.2 173.5,77.94 v2(174,77.43) 173.5,76.92 RG84.2
  vias: v2(185.49,85.13) v2(185.71,86.37) v2(186.41,84.96) v2(192.13,68.95) v2(192.9,71.14) v2(192.86,69.75) v2(196.29,72.86) v2(196.29,72.22) v2(196.88,72.86) v2(196.88,72.22)
+1V8_MAIN: length 31.3
  TOP w0.356: RG515.1 189.81,80.55 189.81,79.77 189.99,79.59 190.32,79.59 190.58,79.34 RG546.1
  TOP w0.508: LG3.1 177.42,83.64 v2(177.05,83.27) ; CG312.1 180.23,75.4 v2(179.27,74.45) ; RG512.1 175.55,58.55 v2(175.55,57.94)
  IN3 w0.508: v2(172.35,70.83) 172.35,62.95 174.26,61.05 174.26,60.22 175.59,58.89 175.59,58.04 175.55,58 v2(175.55,57.94)
  BOTTOM w0.254: UG9.BC30 v2(184.9,100.25) ; UG9.AT11 189.5,86.75 v2(189.25,87) ; v2(185.65,96.9) 185.4,97.15 UG9.BB26 ; UG9.AR11 190.2,86.75 v2(190.45,87) ; v2(185.66,99) 185.41,99.25 UG9.BB29 ; UG9.AR10 v2(190.5,86.25) ; v2(185.65,101.1) 185.4,101.35 UG9.BB32 ; UG9.AT10 v2(189.2,86.25) ; UG9.AV10 v2(188.4,86.25) ; v2(191.35,87) 191.6,86.75 UG9.AN11 ; UG9.BC27 184.6,97.86 v2(184.89,98.15) ; UG9.AW11 v2(187.05,87) ; UG9.BC26 v2(184.9,96.85) ; UG9.BC29 v2(184.9,98.95) ; v2(191.3,86.25) UG9.AN10 ; UG9.AM11 192.3,86.75 v2(192.55,87) ; UG9.AM10 v2(192.6,86.25) ; v2(184.23,94) 183.9,93.68 UG9.BD21 ; UG9.BB27 185.38,97.85 v2(185.65,98.12) ; UG9.BD30 v2(184.2,100.25) ; v2(187.05,86.31) 187.4,85.96 UG9.AW10 ; UG9.AV11 188.1,86.75 v2(188.35,87)
  BOTTOM w0.3: UG9.BD27 v2(184.2,98.15) ; UG9.BC32 v2(184.9,101.05)
  vias: v1(193.37,81.95) v2(177.75,92.42) v2(191.75,74.12) v2(191.75,73.53) v2(191.75,72.95) v2(192.32,73.28) v2(192.32,72.69)
+1V_MPHY: length 2.7
  BOTTOM w0.152: v2(168.24,39.75) UH1.U26 ; UH1.U25 v2(168.24,40.53) ; v2(169.01,39.75) UH1.V26 ; v2(168.24,42.08) UH1.U21 ; v2(168.24,41.3) UH1.U23
  vias: v2(158.95,30.59) v2(158.95,29.95) v3(156.83,30.58)
+1V_PCH: length 14
  TOP w0.508: CH185.1 171.41,44.33 v2(171.34,44.4)
  BOTTOM w0.152: v2(166.38,45.54) UH1.N17 ; UH1.AN19 176.05,43.46 v2(175.7,43.92) ; UH1.AD15 171.62,45.51 v2(172.11,45.75) ; v2(167.42,42.86) 167.12,43.38 UH1.R19 ; v2(167.39,43.94) 167.14,44.18 UH1.R17 ; UH1.K3 164.61,51.75 164.52,51.84 UH1.K2 164.73,52.33 v2(164.73,53.14) ; v2(168.24,42.85) UH1.U20 ; UH1.AC17 v2(171.34,44.4) ; v2(169.01,44.4) UH1.V17
  BOTTOM w0.203: v2(174.96,41.66) 174.76,41.87 UH1.AL22
  BOTTOM w0.457: RH71.1 161.94,55.55 161.49,55.1 v2(161.43,55.1)
  BOTTOM w0.508: v2(169.32,54.19) 168.77,54.74 CH177.1 ; CH178.1 165.86,55.48 165.39,55.01 164.93,55.01 CH179.1 164.73,54.83 v2(164.73,53.14)
  vias: v2(167.33,51.54) v2(175.59,50.17) v3(162.93,54.24)
+1V_PCH_PRIM: length 8.8
  BOTTOM w0.152: UH1.AC23 v2(171.34,41.3) UH1.AE23 ; UH1.AA26 v2(169.79,40.53) UH1.Y25 ; v2(171.34,40.53) UH1.AE26 ; v2(170.56,40.53) UH1.AC26 ; v2(170.56,39.75) UH1.AA28 ; UH1.Y23 v2(169.79,41.3) UH1.AA23 ; UH1.AJ25 v2(173.66,41.3) UH1.AJ23 v2(173.66,42.08) UH1.AJ21 v2(173.66,42.85) UH1.AJ20 ; v2(171.34,39.75) UH1.AC28
  vias: v3(172.8,40.21)
+1V_VCCDSW: length 3.1
  TOP w0.089: v2(179.43,38.04) 178.95,37.55 178.32,37.55 v1(178.16,37.71)
  TOP w0.508: CH176.1 179.31,38.42 179.43,38.3 v2(179.43,38.04)
  BOTTOM w0.254: v2(179.43,38.04) UH1.BA29
+1VALW: length 88.8
  TOP w0.254: JPCMC.22 75.99,66.18 v2(76.21,65.96)
  TOP w0.457: RC353.1 66.38,67.01 66.24,67.14 v2(65.93,67.14)
  IN2 w0.508: v2(146.57,70.91) 146.95,70.53 146.95,69.43 141.52,64 82.82,64 80.86,65.96 v2(76.21,65.96)
  IN5 w0.508: v2(76.21,65.96) 70.4,65.96 69.22,67.14 v2(65.93,67.14)
  vias: v2(151.83,73.23) v2(151.83,72.53) v2(151.83,71.9) v2(151.83,71.29) v2(151.83,70.63) v2(151.83,69.99) v2(152.33,72.92) v2(152.34,72.24) v2(152.34,71.61) v2(152.34,70.97) v2(153.81,45.81) v2(153.81,44.92) v2(154.19,46.25) v2(154.19,45.36) v2(168.82,57.26) v2(169.2,56.81) v2(169.58,57.27) v2(169.96,56.83) v2(181.28,20.38) v2(181.28,19.8) v2(181.28,19.21) v2(181.88,20.4) v2(181.88,19.81) v2(181.88,19.23) v2(181.88,18.64) v2(181.88,18.06) v2(182.46,20.4) v2(182.46,19.81) v2(182.46,19.23) v2(182.46,18.64) v2(182.46,18.06) v2(183.05,20.4) v2(183.05,19.81) v2(183.05,19.23) v2(183.05,18.64) v2(183.05,18.06) v3(147.98,70.37)
+1VALWP: length 24.8
  TOP w0.254: PR307.2 216.71,24.25 216.18,24.78 214.23,24.78 213.67,24.22 v3(202.88,24.22) 202.07,24.22 198.73,20.87 v2(195.15,20.87)
+1VALWP_B+:
  vias: v1(207.42,16.99) v2(206.45,16.49) v2(206.58,15.54) v2(207.09,16.49) v2(207.09,15.86)
+1VALWP_PGOOD: length 143.8
  TOP w0.254: v2(179.62,12.65) 183.52,12.65 184.39,13.52 210.79,13.52 v3(212.8,15.52) PR301.2 214.83,17.56 214.83,18.9 214.62,19.12 PU300.1
  IN1 w0.508: v2(179.62,12.65) 179.62,12.89 178.9,13.61 175.46,13.61 175.14,13.28 167.37,13.28 165.72,14.93 165.38,14.93 164.29,16.03 163.61,16.03 162.81,16.83 160.74,16.83 159.34,18.22 156.79,18.22 154.69,20.33 154.69,21.43 153.9,22.21 151.68,22.21 150.64,21.16 123.91,21.16 121.6,18.86 104.18,18.86 101.9,21.13 99.56,21.13 98.76,20.33 98.76,18.31 97.96,17.51 94.45,17.51 93.78,16.85 93.78,14.6 89.96,10.78 v2(89.1,10.78)
+2.5V_MEM: length 28.8
  BOTTOM w1.016: 150.95,36.37 151.97,35.35 151.97,31.03 157.62,25.38 157.62,23.77 ; 149.72,49.78 151.37,48.13 151.37,45.27 150.61,44.51 150.61,42.92 151.44,42.09 151.44,40.47 150.23,39.26 150.23,38.22
  vias: v2(149.29,48.79) v2(149.3,48.21) v2(149.63,37.52) v2(149.63,36.89) v3(149.73,36.31)
+2.5V_MEMP:
  vias: v1(164.29,29.42)
+2.5VOUT: length 11.8
  BOTTOM w0.254: UM8.51 v2(108.28,149.4) ; CM36.1 102.09,154.01 UM8.36 ; CM32.1 v1(102.41,146) 102.41,146.22 102.59,146.4 UM8.9 ; UM8.41 104.59,154.11 CM9.1 ; UM8.14 100.09,145.2 CM35.1
  BOTTOM w0.508: CM32.1 v2(100.83,145.19) CM35.1 ; v2(105.22,154.57) 104.77,154.12 CM9.1 ; CM36.1 101.51,154.12 v2(101.3,154.33) ; CM34.1 108.77,149.4 v2(108.28,149.4)
+2.5VSP_ON: length 4.8
  BOTTOM w0.127: v1(167.2,20.61) 166.74,20.15 PR1301.1
  BOTTOM w0.508: 164.54,21.13 164.54,19.91 PC1301.1 PR1302.1 PR1301.1
+2.5VSP_VIN:
  vias: v1(163.86,19.73)
+3.3V_1.8V_DVDD: length 50.1
  TOP w0.203: UA4.16 28.11,25.19 28.46,25.54 v2(28.46,25.7)
  IN1 w0.508: v2(28.46,25.7) 28.46,26.48 28.21,26.73 28.21,31.15 29.09,32.03 30.9,32.03 32.42,33.55 32.42,34.42 33.01,35 33.95,35 34.87,35.91 34.87,36.82 34.57,37.11 34.31,37.11 34.31,37.11 v2(34.31,37.11)
  IN4 w0.508: v2(33.41,38.4) 32.63,38.4 32.08,38.95 32.08,42.14 28.64,45.59 v2(28.64,46.67) ; v2(28.46,25.7) 28.46,25.36 27.26,24.15 27.26,23.01 27.64,22.63 28.34,22.63 29.35,21.61 29.35,20.55 29.68,20.22 30.59,20.22 32.39,18.41 v2(32.39,18.4)
  BOTTOM w0.203: UA1.7 30.58,38.38 30.83,38.12 31.78,38.12 CA12.1
  BOTTOM w0.356: RA21.1 28.96,46.35 v2(28.64,46.67)
  BOTTOM w0.457: RA32.1 33.43,36.46 34.08,37.11 34.31,37.11 34.31,37.11 v2(34.31,37.11) ; RA70.1 28.52,25.63 v2(28.46,25.7) 28.46,26.35 CA64.1 CA65.1 27.51,27.32 RA66.1 ; CA12.1 CA13.1 32.94,38.4 v2(33.41,38.4)
  BOTTOM w0.508: RA53.1 RA50.1 32.04,19.12 32.4,18.76 32.4,18.4 v2(32.39,18.4)
  vias: v1(34.01,38.91)
+3.3V_1.8V_DVDD_IO:
  vias: v1(27.79,33.51)
+3.3V_ANA_PCIE: length 1.1
  TOP w0.254: UT1.L16 v2(151.45,156.49)
  BOTTOM w0.381: CT85.1 151.54,156.41 v2(151.45,156.49)
+3.3V_ANA_USB2: length 1.1
  TOP w0.254: v2(150.8,156.49) UT1.J16
  BOTTOM w0.356: v2(150.8,156.49) 150.76,156.53 CT86.1
+3.3V_F383: length 378
  TOP w0.254: UE3.27 186.53,151.09 186.59,151.15 CE24.1
  TOP w0.508: RE7.1 273.38,39.2 273.89,38.7 273.89,34.63 272.56,33.3 269.83,33.3 269.38,33.74 269.38,35.2 268.86,35.72 CE59.1 ; RE2.1 RE1.1 254.21,39.45 v2(254.2,39.46) ; RE15.1 v2(256.36,43.39) ; RE16.1 v2(267.16,51.21) ; v2(260.38,49.73) RE17.1 RE8.1 ; RE40.1 RE43.1 188.49,153.43 188.74,153.19 188.74,150.65 188.48,150.39 v2(187.91,150.39) 187.64,150.39 187.14,150.9 CE24.1 ; RE21.1 263.29,51.14 v2(263.49,51.35) ; RE23.1 v2(260.55,47.4) ; v2(185.73,146.88) RE25.1
  TOP w1.016: 139.14,22.21 118.97,22.21 116.54,19.77 116.54,18.6 ; 173.37,136.93 173.35,136.95 172.88,136.95 172.16,136.23 172.16,121.37 167.34,116.55 167.34,106.64 164.57,103.87 164.57,102.98 163.3,101.71 163.3,94.22 162.19,93.12 162.19,91.4 162.19,91.4 ; 141.55,22.21 141.64,22.12 158.28,22.12 158.29,22.14 158.98,22.14 159,22.12 168.98,22.12 169.06,22.21
  IN1 w1.016: 196.67,24.34 208.8,24.34 209.56,25.11 217.82,25.11 219.31,26.59 219.31,28.78 219.6,29.07 v2(219.6,30.63) 219.6,33.3 221.07,34.77 225.14,34.77 227.42,32.5 240.17,32.5 245.67,38 252.74,38 253.32,38.57
  IN2 w1.016: 185.5,145.63 184.74,144.87 179.66,144.87 178.2,143.41 178.2,141.31 174.96,138.07
  IN3 w0.508: v2(187.91,150.39) 187.91,149.88 187.28,149.25 185.75,149.25 185.05,148.55 185.05,147.09 185.27,146.88 v2(185.73,146.88)
  IN4 w1.016: 194.51,23.46 190.99,19.93 184.87,19.93 183.25,21.55 178.61,21.55 178.14,21.08 ; 161.88,89.75 160.29,88.16 157.69,88.16 152.48,82.96 152.48,75.23 150.86,73.61 150.86,68.37 150.19,67.71 150.19,66.19 145.39,61.38 141.43,61.38 138.95,58.91 138.95,50.34 138.49,49.88 138.49,41.72 138.89,41.32 138.89,36.97 140.27,35.59 140.27,29.33 140.43,29.17 140.43,23.16
  IN5 w1.016: 115.51,18.49 112.69,18.49 107.04,12.84 103.7,12.84 99.61,8.75 94.42,8.75 93.47,7.8 82.67,7.8 81.68,8.79 79.28,8.79 78.56,9.51 76.15,9.51
  BOTTOM w0.254: UE4.27 172.1,22.22 CE25.1
  BOTTOM w0.508: RE26.1 178.5,20.71 v2(178.86,20.36) ; RE14.1 69.47,1.73 68.91,1.17 v2(67.96,1.17) ; RE32.1 169.14,21.17 v2(169.86,21.89) 169.86,22.1 170.37,22.6 CE25.1 ; v2(219.6,30.63) JELC.1 ; CE19.1 71.79,13.27 70.94,14.12 RE13.1
  vias: v2(73.8,9.76) v2(73.93,3.33) v2(73.93,2.69) v2(74.43,9.76) v2(115.93,17.64) v2(116.51,17.64) v2(140.03,22.27) v2(140.66,22.27) v2(162.57,90.38) v2(163.08,90.77) v2(174.26,137.31) v2(174.26,136.68) v2(195.09,24.15) v2(195.72,24.15) v2(253.57,39.46) v2(266.84,36.43) v2(267.47,36.43) v3(173.88,21.28)
+3.3V_FLASH: length 49.9
  IN1 w0.457: v2(122.7,148.36) 122.39,148.67 v2(121.49,148.67)
  IN3 w0.508: v2(122.7,148.36) 122.7,148.6 122.98,148.88 125.9,148.88 128.42,146.35 129.99,146.35 130.76,147.13 130.76,148.17 132.02,149.43 v2(132.02,151.04) ; v2(138.69,153.06) 138.26,153.06 137.3,152.11 136.76,152.11 136.18,151.53 136.18,145 v2(135.57,144.39)
  IN5 w0.508: v2(121.49,148.67) 121.43,148.73 121.43,150.67 120.78,151.32 v2(120.78,151.34)
  BOTTOM w0.229: 121.19,150.77 122.04,151.62 122.88,151.62 122.92,151.58 UT4.G1
  BOTTOM w0.254: v2(122.7,148.36) 123.42,149.08 UT4.B1
  BOTTOM w0.457: v2(121.49,148.67) RT66.1 RT67.1
  BOTTOM w0.508: 132.07,151.09 RT74.1 ; 132.07,151.09 v2(132.02,151.04) ; 132.07,151.09 v1(133.82,151.09) 134.65,151.09 136.63,153.07 RT50.1 137.98,153.07 RT49.2 v2(138.69,153.06) 138.69,153.06 RT48.1 ; RT51.1 133.71,145.75 CT45.1 135.07,144.39 v2(135.57,144.39) 137.21,144.39 137.8,143.8 UT2.8 ; CT103.1 121.19,150.93 v2(120.78,151.34)
+3.3V_LC: length 73.5
  TOP w0.203: UT1.R6 v2(146.91,153.88)
  TOP w0.381: RT6.1 RT7.1 RT8.1 RT9.1 138.98,148.71 v2(138.63,148.36)
  TOP w0.508: v2(99.52,154.27) 99.52,153.92 v3(99.26,153.67) 99.19,153.59 JTAG.1
  IN3 w0.508: v2(138.63,148.36) 138.03,148.36 136.92,147.26 136.92,144.8 135.59,143.47 132.75,143.47 131.98,144.25 130.75,144.25 129.41,142.91 127.89,142.91 127.23,142.25 117.92,142.25 116.78,143.39 112.5,143.39 110.99,144.9 108.76,144.9 106.3,147.36 99,147.36 98.06,148.3 98.06,152.49 99.52,153.95 v2(99.52,154.27)
  IN4 w0.508: v2(146.91,153.88) 146.91,153.36 147.52,152.75 147.52,151.03 147.12,150.63 142.24,150.63 139.97,148.36 v2(138.63,148.36)
  BOTTOM w0.381: v2(146.91,153.88) 146.88,153.86 CT46.1
+3.3V_TBT_SX: length 74.3
  TOP w0.254: RT27.1 RT26.1 141.37,153.42 141.12,153.67 v2(141.03,153.67) 141,153.67 140.76,153.43 RT31.1 ; UT1.F8 147.22,158.12 146.91,158.43 v2(146.9,158.43) ; RT28.1 RT29.1 142.17,152.24 142.22,152.29 v2(142.23,152.29)
  TOP w0.356: RT33.1 139.06,155.75 v2(138.17,155.75)
  IN1 w0.508: v2(142.23,152.29) 142.13,152.29 141.06,153.36 141.06,153.64 v2(141.03,153.67) 141.03,153.86 139.27,155.61 138.3,155.61 v2(138.17,155.75)
  IN3 w0.508: v2(118.06,154.86) 118.06,154.55 119,153.61 119,144.46 119.67,143.79 129.39,143.79 130.96,145.36 134.28,145.36 135,146.09 135,151.62 136.3,152.92 137.15,152.92 138.03,153.8 138.03,155.04 138.17,155.18 v2(138.17,155.75)
  BOTTOM w0.356: 143.83,157.67 143.83,157.73 143.42,158.14 RT30.1 143.25,158.49 143.96,159.21 ; RT70.1 118.56,156.49 118.06,155.99 v2(118.06,154.86) 118.53,154.39 119.95,154.39 RT61.2
  BOTTOM w0.381: v2(146.9,158.43) 146.9,158.42 146.33,158.42 CT47.1
  BOTTOM w0.457: v2(138.17,155.75) 137.49,155.08 RT94.1
  BOTTOM w0.508: 143.96,159.21 144.95,160.2 RT86.1 146.45,159.65 146.27,159.47 CT47.1 ; RT32.1 140.12,154.3 140.68,153.73 140.96,153.73 v2(141.03,153.67) 141.37,153.67 142.25,154.56 142.25,155.41 v1(142.76,155.92) 143.83,156.98 143.83,157.67 ; RT97.2 139.36,155.98 139.08,155.7 138.22,155.7 v2(138.17,155.75)
+3.3V_TBT_SX_R: length 4.8
  BOTTOM w0.076: UT4.H2 123.8,152.33 123.36,152.33
  BOTTOM w0.152: 123.36,152.33 123.16,152.33 122.95,152.54 122.69,152.54 121.98,153.24 121.94,153.24 v1(121.92,153.26)
  BOTTOM w0.508: RT61.1 CT102.1 121.36,153.82 v1(121.92,153.26)
+3V3_SYS: length 274.2
  TOP w0.508: v2(180.93,59.82) 180.06,58.95 180.06,58.41 178.75,57.1 177.85,57.1 177.7,56.95 173.67,56.95 173.01,57.61 RG514.1 ; UG14.6 192.98,75.19 193.16,75.02 193.82,75.02 CG323.1 194.39,74.76 194.97,75.35 CG385.1 195.65,75.51 v2(196.17,76.03) 196.42,76.03 v1(196.74,75.72)
  IN1 w0.508: v2(199.59,70.26) 198.58,71.27 196.38,71.27 195.34,72.31 193.21,72.31 190.79,69.9 190.79,69.32 190.02,68.54 189.36,68.54 188.34,67.53 v2(188.34,67.52) 188.34,67.52 188.34,55.16 188.67,54.82 188.67,53.93 190.65,51.95 190.65,43.04 191.64,42.05 191.64,39.03 192.1,38.57 v2(192.1,38.57)
  IN2 w0.508: v2(197.46,73.51) 198.02,72.95 198.02,71.83 v2(199.59,70.26)
  IN3 w0.508: 185.13,68.35 185.05,68.35 183.59,66.89 183.59,65.05 v2(182.91,64.36) 182.29,63.75 182.29,62.86 180.93,61.49 v2(180.93,59.82) ; 185.13,68.35 v2(185.13,73.34) ; 185.13,68.35 187.82,68.35 188.34,67.83 v2(188.34,67.52) ; v2(172.8,158.58) 171.27,160.11 168.25,160.11 167.98,159.84 164.1,159.84 163.18,158.93 163.18,156.21 161.01,154.03 160.27,154.03 v2(159.78,154.52) ; v2(192.1,38.57) 192.1,34.25 198.74,27.62 202.29,27.62 203.79,29.11 203.79,30.89 204.67,31.77 205.56,31.77 v2(205.7,31.63) ; v2(175.02,86.94) 174.27,86.19 174.27,85.06 174.07,84.86 174.07,84.03 174.96,83.15 174.96,79.46 176.23,78.19 182.39,78.19 182.8,78.6 183.94,78.6 184.38,78.17 185.14,78.17 186.54,76.77 188.75,76.77 189.49,77.5 189.49,79.07 190.58,80.16 191.85,80.16 193.63,78.38 196.1,78.38 196.86,77.62 196.86,76.73 v2(196.17,76.03) 196.04,75.91 196.04,74.93 v2(197.46,73.51)
  IN4 w0.508: v2(205.7,31.63) 206.57,31.63 207.29,32.36 208.56,32.36 v2(209.06,32.85)
  IN5 w0.508: v2(175.02,86.94) 175.02,95.46 173.88,96.61 173.88,105.12 175.73,106.97 175.73,133.54 176.2,134.01 176.2,138.74 177.81,140.36 177.81,144.55 177.43,144.93 177.43,147.9 176.48,148.85 176.48,153.25 175.76,153.97 175.08,153.97 173.64,155.41 173.64,156.98 172.8,157.82 v2(172.8,158.58) 173.37,158.58 173.99,159.21 175.77,159.21 176.99,160.43 176.99,162.9 176.16,163.73 173.93,163.73 171.9,165.76 v2(171.73,165.76)
  BOTTOM w0.254: PR6103.1 v2(205.7,31.63)
  BOTTOM w0.381: RG6.1 v2(182.91,64.36) ; CG61.1 199.58,70.97 199.58,71.38 199.85,71.65 200.17,71.65 200.59,72.07 UG11.4
  BOTTOM w0.508: v2(172.8,158.58) 172.8,157.44 173.19,157.05 RX1.1 175.44,157.05 QX1.2 ; RV655.1 171.58,165.61 v2(171.73,165.76) ; CG61.1 v2(199.59,70.26) ; v2(197.46,73.51) 197.05,73.91 RG60.1 RG61.1 197.04,75.09 RG63.1 ; PR6205.2 208.65,32.45 v2(209.06,32.85) ; PR821.2 160.29,154.01 v2(159.78,154.52) ; QG5.2 v2(185.13,73.34)
+3V_PCH: length 177.5
  TOP w0.356: 175.44,37.86 174.93,38.37 RH23.2
  TOP w0.381: CH187.1 182.3,52.42 182.31,52.41 182.31,51.73 v2(182.32,51.71)
  TOP w0.457: v2(65.8,66.45) 65.99,66.45 66.38,66.05 RC9.1
  TOP w0.508: RH506.2 186.33,41.56 v2(186.94,41.56) ; 175.44,37.86 175.39,37.86 174.59,37.06 v2(174.59,36.91) ; v2(172.15,33.48) 171.84,33.48 171.39,33.04 CH190.1 171.08,32.68 170.51,32.11 170.51,31.48 170.15,31.12 166.79,31.12 166.43,31.48 165.83,31.48 165.24,30.89 163.44,30.89 161.24,28.68 155.27,28.68 154.83,29.12 154.83,41.68 152.6,43.9 v3(152.6,48.3) 152.6,51.54 151.65,52.49 v2(151.65,56.04) ; RH25.2 173.62,32.19 174.55,33.12 v2(174.72,33.12) 174.95,32.89 CH191.1 ; RH75.1 RH78.1 186.94,35.33 v2(187.03,35.42) ; v2(180.75,30.33) 180.84,30.25 CH192.1 ; CH200.1 178.38,36.84 v2(178.69,37.16) ; v2(176.61,50.16) 175.9,50.87 CH189.1
  IN2 w0.508: v2(151.65,56.04) 151.43,56.26 79.68,56.26 73.56,62.38 72.82,62.38 70.68,64.52 69.5,64.52 67.96,66.05 66.38,66.05 65.99,66.45 v2(65.8,66.45)
  BOTTOM w0.203: UH1.BE3 UH1.BD3 UH1.BE4 ; v2(178.69,37.16) 179.33,37.16 UH1.BA31 ; v2(179.85,44.02) 179.86,44.02 179.86,43.84 179.84,43.82 UH1.BA20
  BOTTOM w0.254: UH1.AN5 176.11,50.44 v2(176.61,50.16) ; RPH6.8 169.57,25.09 v2(169.81,24.84) 170.06,25.1 RPH6.7 ; v2(172.15,33.48) 172.08,33.43 172.07,33.36 171.68,33.09 UH1.AD41 ; RPH6.6 170.56,25.09 v2(170.81,24.84) 171.06,25.1 RPH6.5
  BOTTOM w0.381: v2(169.81,24.84) 169.81,24.57 168.56,23.32 RG559.1 167.76,25.13 RG558.1
  BOTTOM w0.508: UH4.8 185.36,23.34 186.04,24.02 186.04,24.74 CH49.1 v2(186.74,26.44) ; 182.5,52.4 182.5,54.43 183,54.93 183,55.41 183.27,55.68 RH493.1 183.07,56.26 182.1,57.24 RH571.2 ; v2(175.39,21.95) RH461.1 RH460.1
  vias: v2(160.86,62.51) v2(161.49,62.51) v2(175.52,33.17) v2(182.32,51.12)
+3VALW: length 1106.1
  TOP w0.127: UH5.2 315.95,83.92 v2(315.38,83.35) 315.11,83.35 314.73,83.73 CH2.1 ; v2(185.81,44.24) 185.81,45.08 v3(185.82,45.08)
  TOP w0.356: RU26.1 300.9,50.02 299.86,48.98 299.86,47.66 v2(299.16,46.95)
  TOP w0.381: v2(120.88,5.45) 121.39,5.45 121.78,5.84 RE506.1 121.78,6.69 121.75,6.73 121.75,7.21 122.02,7.49 123.28,7.49 123.45,7.33 124.98,7.33 ; RE475.1 126.37,13.6 v2(126.37,13.08) ; RE477.1 123.65,17.61 v2(123.64,17.63)
  TOP w0.508: v2(292.68,46.46) 293.18,46.95 RU15.2 RU16.2 RU20.2 RU19.2 RU18.2 RU17.2 v2(299.16,46.95) ; v2(84.22,20.41) 84.19,20.39 RE79.1 ; PR301.1 213.04,17.47 v2(212.55,16.98) ; v2(169.74,45.52) 169.45,45.8 169.24,45.8 CH82.1 ; v2(173.24,48.91) 173.59,48.91 173.67,48.82 RH2.1 174,50.95 173.75,51.21 173.75,53.36 173.88,53.49 173.88,54.62 171.75,56.75 171.75,57.9 170.26,59.4 168.04,59.4 167.34,58.7 167.34,57.49 165.81,55.97 163.84,55.97 163.27,56.54 157.11,56.54 156.7,56.96 148.31,56.96 C269.1 ; RE91.1 70.04,11.28 70.56,10.76 70.56,8.85 70.82,8.6 ; CE29.1 97.25,3.59 96.33,2.68 RE643.1 RE642.1 ; v2(262.99,60.54) 263.22,60.77 PR8221.1 ; PR16.2 v2(56.78,8.6) ; PR3.2 285.8,39.81 v2(286.21,40.22) ; PR24.2 v2(286.59,38.65) ; v2(102.13,22.67) 102.21,22.59 103.39,22.59 103.78,22.98 RE64.2 ; PR210.1 58.82,46.51 58.82,44.69 58.24,44.11 55.07,44.11 53.92,42.97 53.92,38.78 52.76,37.62 52.27,37.62 51.96,37.3 v2(51.96,37.04) ; RE644.2 123.59,17.63 v2(123.64,17.63) ; 147.59,2.88 v2(147.59,4.6) ; RE530.1 R307.1 118.29,6.77 R325.1 117.87,5.41 117.8,5.49 v2(117.62,5.49) ; RA13.1 37.28,38.87 v2(37.53,38.62) ; RE70.1 v2(82.63,12.71)
  IN1 w0.508: 173.68,45.7 173.68,45.47 174.61,44.55 175.98,44.55 176.54,43.99 176.54,42.46 177.3,41.7 178.38,41.7 179.08,41 179.28,41 179.7,40.57 v2(179.7,40.48) ; 173.68,45.7 174.07,46.08 174.07,48.49 173.65,48.91 v2(173.24,48.91) ; 173.68,45.7 172.92,45.7 172.29,45.07 170.19,45.07 v2(169.74,45.52) ; v2(38.68,39.58) 51.1,39.58 51.96,38.72 v2(51.96,37.04)
  IN1 w1.016: 190.51,150.71 190.51,151.98 189.75,152.74 185.94,152.74 185.62,152.42 184.35,152.42 183.97,152.81 183.02,152.81 180.21,150 179.01,150 177.75,151.26 177.75,154.84 175.46,157.12 175.15,157.12 175.06,157.21 173.86,157.21 173.78,157.12 168.86,157.12 168.54,156.81 167.15,156.81 166.64,157.31 v2(166.64,157.44) 165.05,157.44 163.36,159.13 163.36,161.86 162.85,162.37 160.63,162.37 158.49,164.51 157.75,164.51 156.29,165.97 151.06,165.97 150.45,166.58
  IN1 w2.032: 92.72,7.14 92.72,7.14 88.34,7.14 87.09,8.39 84.03,8.39 79.64,12.78 79.64,17.68 75.2,22.12 75.2,47.24 77.89,49.92 77.89,50.48 77.95,50.55 77.95,54.42 75.84,56.53 63.83,56.53 62.35,55.06 54.37,55.06 53.54,55.89 53.54,59.74 ; 57.85,63.83 65.09,63.83 67.96,66.7 67.96,68.03 68.53,68.6 68.53,70.79 82.11,84.36 82.11,89.17 84.85,91.91 84.85,148.13 87.24,150.52 91.12,150.52 92.56,151.96 95.88,151.96 96.73,152.81 105.74,152.81 111.04,158.1 ; 114.76,7.2 114.7,7.26 107.01,7.26 ; 230.72,12.09 226.08,12.09 225.67,11.68 219.12,11.68 215.97,8.53 213.95,8.53 212.02,6.6 205.31,6.6 ; 186.18,6.82 180.51,6.82 179.78,7.55 170.92,7.55 170.38,8.09 167.57,8.09 167.12,8.53 165.41,8.53 158.74,15.2 153.11,15.2 147.78,9.87 ; 281.61,38.12 277.82,38.12 272.37,32.66 251.01,32.66 247.9,29.55 247.9,14.81
  IN2 w0.508: v2(51.96,37.04) 51.2,36.28 51.2,33.69 52.59,32.3 52.59,30.89 v2(52.47,30.76) ; v2(185.81,44.24) 184.93,45.12 182.2,45.12 180.22,43.15 180.22,42.49 180.53,42.19 180.53,41.53 179.7,40.71 v2(179.7,40.48) ; v2(88.4,22.52) 86.54,22.52 84.43,20.41 v2(84.22,20.41) ; v2(117.92,143.41) 117.49,143.41 115.52,141.44 93.16,141.44 92.48,142.11 89.1,142.11 86.05,139.07 86.05,125.59 90.95,120.69 95.19,120.69 96.01,119.87 96.01,112.02 95.07,111.08 v2(95.07,104.18)
  IN3 w0.508: v2(111.97,160.84) 111.97,154.63 117.92,148.68 v2(117.92,143.41) ; v2(118.06,166.86) 118.8,166.13 118.8,163.93 119.55,163.18 126.28,163.18 127.34,164.25 131.33,164.25 131.99,163.59 134.04,163.59 137.31,160.31 137.31,158.9 139.32,156.9 v2(140.7,156.9) ; v2(235.87,23.46) 235.45,23.87 231.42,23.87 230.43,22.88 230.43,19.2 229.95,18.72 228.47,18.72 227.15,17.4 223.28,17.4 222.23,16.34 213.18,16.34 v2(212.55,16.98)
  IN4 w0.508: v2(89.87,27.14) 89.86,27.14 89.86,26.37 88.4,24.91 v2(88.4,22.52) ; v2(14.37,27.14) 14.37,29.62 15.44,30.69 15.44,38.31 18.68,41.55 18.68,42.7 21.1,45.11 21.1,46.89 21.03,46.95 21.03,53.75 23.76,56.48 25.35,56.48 26.75,57.87 44.34,57.87 44.4,57.81 ; v2(144.17,24.92) 144.16,24.91 142.63,24.91 ; 126.04,13.96 126.37,13.63 v2(126.37,13.08) ; 126.04,13.96 125.17,14.82 125.17,16.09 v2(123.64,17.63) ; 126.04,13.96 142.6,13.96 142.63,13.99 ; v2(84.22,20.41) 84.22,13.36 83.57,12.71 82.63,12.71 v2(82.63,12.71)
  IN4 w1.016: 146.13,9.55 142.63,13.04 142.63,29.76 142.25,30.14 142.25,36.37 140.92,37.7 140.92,42.27 140.22,42.97 140.22,49.64 140.7,50.12 140.7,57.49 143.46,60.24 145.11,60.24
  IN4 w1.524: 147.14,168.17 143.89,168.17 141.79,170.27 141.79,170.96 140.15,172.6 138.29,172.6 136.27,170.59 119.63,170.59 118.75,169.71 118.75,168.07
  IN5 w0.508: v2(81.76,6.84) 73.59,6.84 71.87,8.56 61.58,8.56 60.53,9.61 57.8,9.61 v2(56.78,8.6) ; v2(236.08,15.3) 236.08,23.24 v2(235.87,23.46) ; v2(91.71,4.49) 91.89,4.67 95.97,4.67 96.15,4.49 v2(97.17,4.49) 97.62,4.95 100.95,4.95 v2(101.93,5.93)
  BOTTOM w0.127: v2(315.38,83.35) 315.67,83.35 315.99,83.03 315.99,80.42 313.51,77.94 310.85,77.94 310.02,78.76 307.08,78.76 304.56,76.25 304.56,71.64 304.05,71.13 304.05,66.25 304.56,65.75 304.56,62.89 304.05,62.38 304.05,55.14 304.94,54.25 304.94,49.87 302.02,46.95 v2(299.16,46.95) ; UH1.BA24 179.7,40.84 v2(179.7,40.48)
  BOTTOM w0.203: v2(169.74,45.52) 169.71,45.5 UH1.W15
  BOTTOM w0.254: v2(14.37,27.14) 14.37,25.36 15.04,24.69 RA84.2
  BOTTOM w0.508: v2(262.99,60.54) 263.69,59.84 263.69,57.54 266.75,54.48 284.56,54.48 286.76,52.28 286.76,44 v2(287.76,43) ; v2(117.92,143.41) 118.12,143.21 RT53.1 ; RH545.2 RH515.2 RH453.2 185.88,44.31 v2(185.81,44.24) 185.88,44.17 RH533.2 ; v2(102.13,22.67) 102.11,22.69 102.11,23.68 101.87,23.92 101.87,25.82 101.38,26.31 95.45,26.31 94.76,27.01 89.99,27.01 v2(89.87,27.14) ; v2(51.96,37.04) 52.74,37.04 PR718.2 ; PC5003.1 95,104.96 PR5033.2 ; v2(166.64,157.44) 166.83,157.63 166.83,159.09 165.69,160.23 164.23,160.23 163.59,159.6 PR812.2 ; RT97.1 141.38,156.36 140.84,156.9 v2(140.7,156.9) ; v2(144.17,24.92) 144.17,25.28 144.63,25.74 151.15,25.74 161.18,15.71 163.01,15.71 163.78,14.93 167.63,14.93 167.93,15.24 167.93,18.53 PR1300.1 ; PR709.2 54.83,31.19 PR710.1 53.92,30.68 53.54,30.31 52.91,30.31 v2(52.47,30.76)
  vias: v2(37.53,37.99) v2(37.53,37.35) v2(37.53,36.72) v2(37.53,36.08) v2(37.61,39.48) v2(38.01,39.05) v2(38.04,37.67) v2(38.04,37.04) v2(38.04,36.4) v2(38.04,35.77) v2(38.05,39.86) v2(38.11,38.25) v2(38.68,38.94) v2(38.72,38.31) v2(38.68,37.67) v2(38.68,37.04) v2(38.68,36.4) v2(38.68,35.77) v2(53.22,64.02) v2(53.22,63.39) v2(53.22,61.93) v2(53.85,64.02) v2(53.85,61.93) v2(54.49,64.02) v2(54.49,61.93) v2(55.12,61.93) v2(55.76,61.93) v2(56.39,64.02) v2(56.39,63.39) v2(81.8,6.2) v2(82.41,6.84) v2(82.41,6.19) v2(102.63,5.93) v2(117.02,8.41) v2(117.06,166.2) v2(117.49,166.61) v2(117.6,8.41) v2(118.19,8.41) v2(126.57,167.47) v2(146.05,60.43) v2(146.51,8.53) v2(146.69,60.43) v2(147.14,8.53) v2(148.92,167.47) v2(148.92,166.84) v2(149.43,167.16) v2(189.68,150.57) v2(189.68,149.94) v2(242.33,13.17) v2(242.77,13.61) v2(243.09,12.98) v2(243.41,13.61) v2(243.73,12.98) v2(244.04,13.61) v2(244.36,12.98) v2(244.68,13.61) v2(245,12.98) v2(245.31,13.61) v3(76.34,7.01) v3(142.57,8.36)
+3VALW_PCH:
  vias: v3(152.95,58.3)
+3VALW_PD: length 13.5
  IN1 w0.508: v2(121.63,152.66) 121.4,152.42 121.4,149.48 120.84,148.92 120.84,147.24 121.59,146.49 v2(121.59,144.52)
  BOTTOM w0.152: UT4.H1 123.55,152.08 123.05,152.08 122.85,152.29 121.99,152.29
  BOTTOM w0.203: v1(121.64,143.21) RT53.2
  BOTTOM w0.508: RT53.2 CT88.1 121.39,144.32 v2(121.59,144.52)
+3VALWP: length 20.1
  BOTTOM w0.254: 41.12,40.07 40.54,40.65 37.47,40.65 36.76,39.94 36.76,34.47 v1(36.28,33.99) 34.96,32.68 34.05,32.68 33.87,32.49 32.67,32.49 31.89,31.71 31.89,30.35 PR101.1
+3VLP: length 463
  TOP w0.381: CU26.1 64.2,59.19 64.44,59.44 UU5.5
  TOP w0.508: DU8.1 71.52,62.51 70.82,61.81 70.82,61.36 70.36,60.9 RU4.1 RU5.1 70.37,60.03 70.94,59.46 v2(70.94,59.33) ; v2(22.75,46.08) 22.72,46.05 RU1.1 ; PR25.2 v2(285.51,38.65) 287.07,40.21 287.07,48.06 281,54.13 v3(278.41,54.13) 262.59,54.13 259.28,57.43 258.21,57.43 258.08,57.3 258.08,57.29 PD5.3 ; v2(185.5,11.64) 186.1,12.25 212.26,12.25 v2(212.92,12.9) ; v2(23.19,50.78) 23.63,50.78 23.96,50.46 RU7.1 31.51,50.05 34.49,47.08 38.5,47.08 39.19,47.78 39.19,49.74 40.08,50.63 42.31,50.63 44.07,52.4 44.07,57 48.84,61.77 51.87,61.77 53.97,59.67 56.72,59.67 57.33,59.06 59.37,59.06 60.3,59.99 62.47,59.99 63.27,59.19 CU26.1 63.9,58.83 64.16,58.56 64.29,58.56 v2(64.91,57.94)
  IN1 w0.508: v2(64.91,57.94) 65.43,58.46 65.43,58.65 66.69,59.9 70.37,59.9 v2(70.94,59.33) 70.94,58.72 71.6,58.06 76.34,58.06 79.39,55.02 79.39,50.04 79.26,49.91 79.26,49.36 76.57,46.67 76.57,25.86 77.82,24.61 79,24.61 81.36,22.25 81.36,15.92 82.71,14.57 84.42,14.57 84.78,14.2 v2(85.8,14.2) 86.25,14.2 87.52,15.47 87.52,16.73 88.2,17.42 90.79,17.42 92.47,19.1 95.31,19.1 98.91,22.69 99.75,22.69 100.52,23.46 102.57,23.46 102.94,23.09 106.03,23.09 106.75,23.81 117.07,23.81 117.64,23.24 129.56,23.24 130.04,23.72 143.79,23.72 144.3,23.21 149.79,23.21 150.95,24.37 153.81,24.37 156.15,22.03 156.15,20.86 157.32,19.69 163.3,19.69 164.86,18.13 164.86,17.49 165.29,17.06 167.3,17.06 169.71,14.65 174.45,14.65 174.76,14.97 179.47,14.97 180.95,13.49 182.27,13.49 184.12,11.64 v2(185.5,11.64)
  IN2 w0.508: v2(212.92,12.9) 212.92,12.36 213.39,11.89 216.1,11.89 218.01,13.8 225.39,13.8 225.74,13.44 235.77,13.44 238.48,16.15 238.48,31.9 246.96,40.38 254.61,40.38 255.17,40.94 260.31,40.94 260.86,40.38 266.24,40.38 267.69,38.92 283.08,38.92 283.35,38.65 v2(285.51,38.65)
  IN4 w0.508: v2(30.87,26.52) 30.05,27.35 30.05,30.25 29.54,30.76 29.54,31.85 30.5,32.81 30.5,33.85 29.27,35.08 29.27,42.44 25.9,45.81 23.02,45.81 v2(22.75,46.08) 24.14,47.48 24.14,49.83 v2(23.19,50.78)
  IN5 w0.508: v2(15,29.3) 15.57,29.87 15.57,39.78 21.86,46.06 22.73,46.06 v2(22.75,46.08)
  BOTTOM w0.356: v2(15,29.3) 15.51,28.79 RA85.2
+3VS: length 868.3
  TOP w0.254: UA3.B2 15.95,27.16 14.94,28.17 14.94,28.28 v2(14.95,28.28)
  TOP w0.356: v2(89.42,69.17) 89.73,68.86 92.69,68.86 CG438.1 93.13,68.41 93.13,68.24 92.96,68.07 UG25.5 ; v2(168.67,61.37) 167.44,60.13 RG535.1 ; RG506.1 184.18,61.58 v2(184.21,61.61) ; RG505.1 187.71,59.77 v2(187.25,59.77) ; v2(185.78,55.14) 185.75,55.17 RG561.1
  TOP w0.381: v2(159.02,64.16) 159.16,64.16 159.96,63.36 162.36,63.36 163.65,62.06 RG536.1 ; UH3.5 180.8,34.56 181.09,34.28 CH201.1 182.3,34.28 v2(182.32,34.29)
  TOP w0.508: RF1.2 RF2.2 65.66,54.54 65.97,54.23 v2(65.97,54.13) ; v2(187.17,40.87) 186.97,40.67 RH85.2 ; v2(253.51,66.83) 253.44,66.89 253.44,68.41 249.63,72.22 249.63,76.35 246.56,79.42 246.56,83.53 v2(246.25,83.83) ; RH518.2 173.71,46.27 v2(173.17,46.27) ; PR515.1 89.22,124.99 v2(88.79,124.56) ; RE20.2 77.39,3.51 76.17,3.51 75.71,3.98 v2(75.71,4.09) ; v2(93.74,110.34) 95.64,108.44 95.64,106.41 96.22,105.83 96.22,91.79 95.65,91.21 95.65,78.35 RH525.1 93.59,77.71 92.79,78.51 90.44,78.51 87.77,81.18 87.58,81.18 v2(87.58,81.21) ; CM11.1 292.22,61.34 v2(292.81,61.94) ; v2(188.34,9.28) 188.89,9.28 189.13,9.52 202.39,9.52 204.21,7.71 206.39,7.71 208.29,5.8 R2.1 ; RA11.2 35.13,35.4 v2(35.7,34.82) 36.08,34.82 36.91,35.65 36.91,37.17 36.39,37.69 CA259.1 ; RE651.2 v2(166.71,166.62) ; CH188.1 171.67,46.88 171.91,47.12 171.94,47.12 v2(172.13,47.31) ; PR8219.1 255.93,60.15 v2(256.39,60.6) ; v2(189,155.12) 189.24,154.88 RV16.1 ; RH501.1 181.93,32.77 RH502.1 182.17,32.77 v2(182.52,33.12) ; v2(83.58,17.54) RE84.1
  TOP w1.016: 147.78,55.14 147.78,56.03 147.08,56.73 146.35,56.73 144.98,58.09 144.98,62 147.07,64.09 157.49,64.09
  IN1 w0.508: v2(28.9,30.27) 28.96,30.33 32.78,30.33 35.38,32.94 35.38,34.7 35.51,34.82 v2(35.7,34.82) 36,34.82 36.78,35.6 36.78,36.66 35.26,38.19 35.26,39.27 33.86,40.66 32.91,40.66 28.32,45.26 24.65,45.26 20.84,41.45 18.83,41.45 16.19,38.8 16.19,29.02 15.45,28.28 v2(14.95,28.28) ; v2(83.58,17.54) 85.1,17.54 88.43,20.87 89.44,20.87 90.12,21.55 v2(90.12,22.88) 90.76,23.52 90.76,24.51 89.1,26.16 v2(89.1,26.82) ; v2(154.57,98.98) 154.57,101.01 153.75,101.83 152.78,101.83 v2(152.73,101.88) ; v2(89.42,69.17) 89.05,69.17 87.58,70.64 v2(87.58,81.21) ; v2(126.13,142.9) 126.13,142 125.76,141.63 114.9,141.63 110.63,145.9 110.63,149.06 111.46,149.88 111.46,151.89 110.8,152.55 v2(110.5,152.55)
  IN2 w0.381: v2(161.75,100.42) 161.75,101.81 v2(161.26,102.3)
  IN2 w0.508: v2(235.26,43.26) 237.2,41.32 241.46,41.32 247.28,47.14 252.68,47.14 v2(255.03,49.49) 255.03,50.7 257.14,52.81 257.14,54.67 256.24,55.57 256.24,57.24 256.17,57.3 256.17,60.39 v2(256.39,60.6) 256.39,61.01 257.51,62.13 257.51,64.35 254.78,67.08 253.82,67.08 253.57,66.83 v2(253.51,66.83) ; v2(185.42,14.98) 185.42,13.69 188.34,10.77 v2(188.34,9.28) ; v2(195.15,159.03) 195.21,159.03 197.18,157.06 v2(197.18,156.42) ; v2(88.09,122.47) 90.53,120.03 90.53,117.43 94.63,113.34 94.63,112.18 93.74,111.3 v2(93.74,110.34)
  IN2 w1.016: 177.26,60.22 180.06,60.22 181.62,61.78 181.62,66 182.43,66.81 182.43,69.92 181.5,70.85 181.5,72.03 v2(181.69,72.22) 181.62,72.29 178.13,72.29 177.37,73.05 177.37,74.83 178.2,75.65 181.05,75.65 181.48,76.08 183.33,76.08 183.94,76.69 183.94,79.11 184.55,79.72 188.04,79.72 188.93,78.83 189.18,78.83 ; 174.58,61.62 174.46,61.62 166.72,69.37 163.4,69.37 163.27,69.24 163.27,67.14 162.26,66.13 159.86,66.13 158.84,65.1
  IN3 w0.508: 182.36,58.23 182.36,60.7 183.27,61.61 v2(184.21,61.61) ; 182.36,58.23 185.64,58.23 185.78,58.37 ; 182.36,58.23 180.79,58.23 178.54,60.48 v2(175.97,60.48) ; v2(83.58,17.54) 80.45,17.54 76.09,13.17 70.09,13.17 69.62,13.65 68.18,13.65 67.71,14.12 66.97,14.12 66.5,13.65 64.44,13.65 63.17,12.38 63.17,8.28 64.03,7.42 65.49,7.42 66.08,6.83 66.08,5.43 66.82,4.68 75.11,4.68 v2(75.71,4.09) ; v2(162.32,116.63) 162.32,130.83 164.67,133.18 173.88,133.18 175.27,131.79 175.27,127.79 176.16,126.9 v2(176.73,126.9) ; v2(235.47,152.93) 233.12,152.93 232.55,152.36 232.55,148.49 230.01,145.95 224.49,145.95 223.15,147.28 206.45,147.28 206.07,147.66 206.07,151.6 205.01,152.66 203.51,152.66 203.15,152.3 198.96,152.3 198.32,152.93 198.32,155.41 197.31,156.42 v2(197.18,156.42) ; 185.78,58.37 v2(185.78,55.14) ; 185.78,58.37 185.78,58.78 186.77,59.77 v2(187.25,59.77) ; v2(195.15,159.03) 195.15,160.04 194.77,160.43 192.36,160.43 ; 189.33,160.43 189.3,160.4 189.3,155.42 v2(189,155.12)
  IN3 w1.016: 191.28,160.43 178.26,160.43 175.72,162.97 173.65,162.97 172.27,161.58 167.61,161.58 166.77,160.74 164.99,160.74 v2(164.73,161) 162.96,162.77 159.65,162.77 158.32,161.44 158.32,161.27 157.35,160.3 157.14,160.3 156.22,159.39 156.22,153.06 158.19,151.09
  IN4 w0.508: v2(147.52,51.29) 147.68,51.13 147.68,41.48 146.97,40.77 146.97,37.49 v2(148.67,35.8)
  IN5 w0.508: v2(176.73,126.9) 177.69,126.9 178.26,127.47 178.26,129.5 179.08,130.33 179.08,143.6 179.97,144.49 188.29,144.49 190.39,146.58 192.23,146.58 192.86,147.22 192.86,147.79 v2(193.62,148.54) 193.62,149.26 189,153.87 v2(189,155.12) ; v2(28.9,30.27) 31.63,27.53 31.63,25.67 29.48,23.51 29.48,18.19 29.96,17.7 32.95,17.7 34.29,16.36 34.29,13.21 35.1,12.39 39,12.39 42.33,9.07 54.47,9.07 55.6,7.94 66.06,7.94 68.64,5.36 69.86,5.36 70.5,4.72 75.07,4.72 v2(75.71,4.09) ; v2(167.18,76.85) 167.34,76.7 167.34,74.45 168.67,73.11 168.67,63.14 169.03,62.78 169.03,61.73 v2(168.67,61.37) 170.07,59.97 172.16,59.97
  BOTTOM w0.152: UH1.AD13 172.11,47.2 172.11,47.24 172.13,47.25 v2(172.13,47.31)
  BOTTOM w0.203: CV437.1 152.76,101 153.24,101.48 153.24,101.7 153.5,101.96 155.46,101.96 155.72,102.22 156.08,102.22 156.27,102.41 UV21.60 ; UV21.49 161.09,104.04 161.4,103.73 161.4,102.44 v2(161.26,102.3) ; v2(161.69,109.64) UV21.35 ; UV21.26 158.27,112.75 158.19,112.82 v2(158.19,113.05) ; 156.27,113.45 156.27,113.45 UV21.21
  BOTTOM w0.254: UG16.12 166.53,76.27 166.51,76.29 ; 166.51,76.29 166.51,75.08 166.83,74.77 UG16.9 ; 166.51,76.29 166.51,76.48 166.83,76.8 167.13,76.8 v2(167.18,76.85) ; UM8.24 96.9,150.4 96.57,150.07 v2(96.4,150.07) ; RM81.1 97.55,143.97 v2(97.86,143.66) 98.24,144.05 RM76.1
  BOTTOM w0.305: v2(148.67,35.8) 147.9,35.8 147.53,36.17 JDIMM2.255 ; JDIMM1.255 v2(147.52,51.29)
  BOTTOM w0.356: RM85.1 109.81,155.22 110.38,154.65 v2(110.44,154.65) ; RV47.1 134.13,164.95 134.13,164.73 134.38,164.48 v2(135.65,164.48) 136.37,163.75 RV45.2 ; v2(110.5,152.55) 109.93,152.55 109.8,152.68 RM66.2 RM26.1
  BOTTOM w0.381: RM86.1 v2(108.73,143.79) RM79.1 ; QH5.2 176.13,25.29 176.39,25.55 176.39,26.72 v2(176.28,26.83) ; CM19.1 86.87,151.02 UM4.12 ; UM4.9 86.87,142.78 CM21.1 ; CM20.1 89.47,143.15 UM4.5 ; CM18.1 89.47,151.83 UM4.16 ; RV631.2 161.43,100.1 v2(161.75,100.42)
  BOTTOM w0.432: QH5.5 173.33,25.29 173.12,25.5 173.12,26.31 v2(173.93,27.11)
  BOTTOM w0.508: RL5.2 193.1,148.02 v2(193.62,148.54) ; RM14.1 94.42,150.77 v2(94.12,150.48) ; RH512.2 v2(169.67,29.17) ; RH5.1 179.85,57.18 v2(179.15,56.48) ; CM19.1 v2(85.32,151.72) ; v2(86.24,143) 86.47,142.78 CM21.1 ; v2(176.28,26.83) 175.66,27.45 175.66,27.67 RC62.2 RC65.2 ; v2(166.71,166.62) 165.97,165.88 QX3.1 164.47,165.88 163.84,165.25 163.84,161.89 v2(164.73,161) ; RC65.2 174.28,27.69 173.95,28.02 RH537.2 173.49,27.91 172.89,27.31 v2(172.89,27.24) ; RC65.2 174.38,27.47 174.02,27.11 v2(173.93,27.11) ; v2(154.57,98.98) 154.63,99.03 RV635.1 RV634.1 ; 71.71,57.87 71.71,57.17 70.66,56.13 67.1,56.13 65.97,55 v2(65.97,54.13) ; v2(157.67,99.43) RV21.2 RV629.2 ; v2(96.41,145.81) CM29.1 CM31.1 ; 126.13,143.97 124.04,143.97 123.52,144.49 RT57.1 ; 126.13,143.97 v2(126.13,142.9) ; 126.13,143.97 126.13,145.19 RT58.1 RT107.1 ; v2(162.32,116.63) 162.06,116.63 161.36,115.92 RV19.1 ; v2(246.25,83.83) RF5.2 RF4.2 ; CM33.1 CM30.1 v2(96.44,148.92) ; v2(193.56,27.01) 193.56,28.66 193.37,28.85 193.37,29.81 194.07,30.5 194.13,30.5 194.91,31.28 PR6107.2 ; CM20.1 89.09,142.78 88.17,142.78 v2(87.93,142.54) ; v2(28.9,30.27) 29.2,30.27 RA5.2 ; CV437.1 v2(152.73,101.88) ; v2(91.19,141.25) RM96.1 91.06,141.99 RM20.1 ; CV436.1 156.48,113.45 156.94,112.99 v2(157.11,112.99) ; v2(155.58,99.43) RV623.2 RV627.2 ; CG436.1 174.72,60.63 CG437.1 175.33,60.6 v2(175.37,60.57) ; PR820.1 v2(235.47,152.93) ; v2(93.74,110.34) 94.13,109.95 PR5016.1 ; CM18.1 v2(90.08,151.89) ; QX2.1 195.47,158.71 v2(195.15,159.03) ; RM18.1 v2(93.86,153.42) ; RV659.2 175.1,125.96 176.04,126.9 v2(176.73,126.9)
  vias: v2(57.79,65.23) v2(58.42,65.23) v2(59.06,65.23) v2(59.69,65.23) v2(60.65,65.23) v2(61.28,65.86) v2(61.28,65.23) v2(61.93,65.87) v2(61.92,65.23) v2(62.56,66.51) v2(62.56,65.87) v2(62.55,65.23) v2(63.83,67.27) v2(64.02,66.64) v2(64.02,66) v2(64.02,65.37) v2(119.85,160.98) v2(120.44,160.98) v2(138.51,166.82) v2(138.56,167.4) v2(138.57,166.21) v2(147.71,24.36) v2(147.97,23.84) v2(148.35,24.34) v2(158.41,64.13) v2(158.64,150.07) v2(159.08,149.69) v2(187.21,36.49) v2(187.85,36.49) v2(190.07,78.64) v2(190.07,78) v2(191.91,163.35) v2(191.91,162.71) v2(290.78,52.48) v2(290.91,50.63) v2(291.29,52.98) v2(291.48,51.01) v2(291.73,53.49) v2(292.18,54) v2(292.3,53.3) v2(295.29,68.22) v2(295.29,51.65) v2(295.29,50.95) v2(295.29,50.32) v2(295.61,67.72) v2(295.92,51.65) v2(295.92,50.95) v2(295.92,50.32) v3(161.3,25.45)
+3VS_CAM: length 22.2
  TOP w0.254: JEDP.32 123.1,159.45 123.52,159.03 v2(123.55,159.03) ; v2(127.54,161.81) 127.54,161.63 127.1,161.2 JEDP.24 127.1,158.89 v1(127.31,158.69)
  IN1 w0.508: v2(123.55,159.03) 123.55,159.59 124.07,160.11 126.4,160.11 126.99,160.69 126.99,161.26 v2(127.54,161.81) 127.54,162.14 129.94,164.55 130.72,164.55 131.97,165.8 132.88,165.8 133.64,166.56 134.72,166.56 v2(135.13,166.97)
  BOTTOM w0.508: v2(135.13,166.97) 135.08,166.92 135.08,165.51 134.9,165.33 RV47.2
+3VS_DP: length 9.4
  IN4 w1.016: 202.52,160.43 200.99,160.43 200.67,160.11 198.26,160.11 197.66,160.71 194.29,160.71 193.73,161.27
  vias: v1(203.51,161.72) v2(194.07,163.22) v2(194.07,162.58) v2(203.6,160.74) v2(203.6,160.11)
+3VS_SSD: length 4.7
  TOP w0.508: R365.2 234.9,7.26
  vias: v2(230.33,27.67) v2(230.33,27.03) v2(232.61,45) v2(232.61,44.42) v2(232.61,18.19) v2(232.6,17.41) v2(232.8,41.83) v2(232.8,41.24) v2(232.93,20.28) v2(233.25,18.19) v2(233.21,17.41) v2(233.31,20.73) v2(233.39,41.83) v2(233.39,41.24) v2(235.65,3.19) v2(236.03,3.7) v2(236.41,3.19) v3(236.59,9.64)
+3VS_TBT: length 10.7
  TOP w0.178: UT1.H9 147.87,157.47 v2(148.21,157.81)
  TOP w0.203: v2(150.13,153.89) 149.82,154.2 UT1.R13
  IN3 w0.508: v2(152.03,146.22) 152.03,146.53 151.68,146.89 150.66,146.89 148.93,148.61 148.3,148.61
  BOTTOM w0.254: RT76.2 146.37,145.87 v2(146.64,146.14) ; v2(146.45,143.28) 146.37,143.35 RT20.1
  BOTTOM w0.381: v2(150.13,153.89) 150.13,154.21 CT48.1 ; RT77.2 151.59,145.44 152.03,145.88 v2(152.03,146.22) ; v2(144.47,161.75) 144.5,161.78 RT21.1
  vias: v1(145.37,165.76) v2(144.47,161.11) v2(145.18,166.46) v2(145.62,166.9)
+3VS_TOUCH: length 139.1
  TOP w0.508: RE101.1 RE100.1 93.18,24.74 v2(93.42,24.98) ; v2(208.2,9.04) 208.2,8.47 209.7,6.98 v3(210.22,6.98) 212.8,6.98 213.9,8.08 C2.1 R2.2
  IN1 w0.508: v2(208.2,9.04) 208.2,9 207.43,8.22 193.2,8.22 188.44,12.99 185.74,12.99 184.03,14.69 181.47,14.69 179.99,16.17 175.84,16.17 174.69,17.32 174,17.32 173.66,16.98 171.91,16.98 171.82,17.07 170.71,17.07 168.66,19.12 168.25,19.12 167.34,20.03 165.55,20.03 160.8,24.78 156.73,24.78 155.26,26.25 143.4,26.25 142.63,25.47 125.26,25.47 124.51,24.72 119.55,24.72 118.97,25.3 107.64,25.3 106.44,26.5 94.92,26.5 93.42,25 v2(93.42,24.98)
  BOTTOM w0.305: JTP.11 208.2,11.6 v2(208.2,9.04)
+5V_PVDD:
  vias: v2(25.61,47.67) v3(25.88,48.4)
+5V_USB_PWR1:
  vias: v2(18.17,51.39) v2(18.17,50.75) v2(18.8,51.39) v2(18.8,50.75) v3(16.61,50.94)
+5V_USB_PWR2:
  vias: v2(300.43,60.9) v2(304.51,61.09) v2(304.51,60.44) v3(305.65,63.77)
+5V_USBC_VBUS: length 12.1
  TOP w0.508: CU20.1 CU21.1 312.61,43.71 v2(312.05,43.71) 311.44,43.71 v2(311.43,43.7) ; CU19.1 CU18.1 312.72,41.01 312.37,40.66 v2(312.05,40.66) 311.56,40.17 v2(310.25,40.17)
  BOTTOM w0.279: 312.9,40.92 313.58,40.92 313.83,41.17 314.5,41.17 JUSBC2.B4 ; 312.9,40.92 JUSBC2.A9 ; 312.9,40.92 312.5,40.92 312.24,40.66 312.06,40.66 v2(312.05,40.66) ; v2(312.05,43.71) 312.18,43.71 312.47,43.42 JUSBC2.A4 313.29,43.42 313.64,43.78 314.09,43.78 314.19,43.67 JUSBC2.B9
  vias: v2(301.19,42.44) v2(301.83,43.08) v2(301.83,42.45) v2(302.47,43.08) v2(302.47,42.45) v2(302.47,41.86) v3(302.53,40.92)
+5VA: length 5.6
  TOP w0.508: v2(22.86,44.78) 23.18,44.46 RA8.1
  BOTTOM w0.203: UA1.45 24.81,42.26 v1(24.24,42.84) 23.94,43.13
  BOTTOM w0.508: 23.94,43.13 CA15.1 23.13,43.78 CA14.1 23.44,44.21 v2(22.86,44.78)
+5VALW: length 785.2
  TOP w0.203: v2(127.52,152.49) v1(128.11,152.49)
  TOP w0.305: U19.3 149.11,73.36 149.03,73.28 v2(149.03,73.1) ; v2(210.51,20.68) 210.58,20.62 PU300.7 ; U20.3 153.05,73.51 153.3,73.26 C2520.1 ; UG14.3 v2(191.33,78.5)
  TOP w0.381: v2(129.18,8.91) 129.18,8.53 129.57,8.14 RE533.1 ; RE542.1 v2(129.45,12.97) ; RE449.1 123.78,8.13 v2(123.74,8.17)
  TOP w0.406: QE55.4 136.94,16.33 137.11,16.15 137.36,16.15 137.78,16.57 RE538.1 138.13,17.17 138,17.3 137.68,17.3 v2(137.3,17.68) ; v2(128.92,9.99) 128.62,10.3 QE54.4 ; QE56.1 127.06,14.14 127.44,13.76 128.82,13.76 128.99,13.93 RE542.1 ; v2(127.82,9.85) 127.84,9.85 127.84,9.74 127.32,9.22 QE54.1 ; v2(135.14,15.58) 134.67,15.11 RE539.1 135.4,13.99 135.64,14.23 QE55.1
  TOP w0.508: v2(191.34,48.79) 191.02,48.47 RG541.1 ; v2(217.88,28.79) 218.96,28.79 220.54,30.36 RG543.1 ; v2(171.65,150.54) 171.96,150.84 171.96,151.75 RE156.1 ; PR8200.2 248.55,62.64 247.79,62.64 247.77,62.61 247.73,62.61 247.37,62.25 247.37,62.22 247.35,62.19 v2(247.35,62.06) ; v2(165.36,163.28) 165.98,163.28 166.25,163.55 UE7.5 ; 174.63,62.9 174.93,63.21 175.85,63.21 176.61,62.44 RG509.1 ; 174.63,62.9 RG511.1 ; 174.63,62.9 174.36,63.17 172.13,63.17 171.77,62.81 RG513.1 170.96,62.44 170.57,62.84 v3(164.28,62.84) 163.77,62.84 162.7,63.91 160.19,63.91 159.11,64.98 154.95,64.98 153.11,66.82 149.37,66.82 v2(149.05,66.5) ; v2(288.48,37.73) 288.48,36.1 v3(287.98,35.6) 284.56,35.6 283.96,36.2 PR8.1 ; v2(166.68,15.52) 167.79,16.64 167.79,18.11 170.05,20.37 175.06,20.37 176.09,21.4 176.09,22.19 175.69,22.59 175.69,23.41 177.62,25.34 JWDB.1 ; PR204.1 v2(59.48,46.24) ; v2(243.98,19.65) 243.59,19.25 C2516.1 243.59,16.2 243.29,15.91 U16.3 ; 44.4,13.76 45.24,12.92 45.24,5.05 45.79,4.49 46.73,4.49 PR14.2 ; v2(148.99,69.14) 149.53,69.14 149.73,68.94 153.43,68.94 154.01,69.53 154.01,71.61 153.46,72.16 C2520.1 ; RU23.1 RU21.1 290.21,37.28 v2(289.75,37.73)
  TOP w1.016: 160.99,19.2 163.4,19.2 164.1,18.5 164.1,17.34 165.18,16.26 ; 240.55,144.61 239.85,143.92 201.5,143.92 200.53,144.89 195.17,144.89 194.46,144.18 181.05,144.18 178.58,146.65 178.58,150.46 178.2,150.84
  IN1 w0.508: v2(59.48,46.24) 61.58,46.24 62.05,46.72 v2(62.37,46.72)
  IN2 w0.508: v2(82.15,62.5) 83.02,63.36 141.77,63.36 147.55,69.14 v2(148.99,69.14) 148.77,69.36 148.77,71.36 148.41,71.72 148.41,72.94 148.57,73.1 v2(149.03,73.1)
  IN3 w0.508: v2(148.99,69.14) 149.97,69.14 150.45,68.67 156.97,68.67 159.73,65.91 165.37,65.91 172.19,72.72 180.01,72.72 183.29,76.01 185.61,76.01 186.02,75.6 187.68,75.6 188.39,74.89 189.54,74.89 191.33,76.68 v2(191.33,78.5) ; 129.5,149.3 128.47,150.33 128.47,152.11 128.09,152.49 v2(127.52,152.49) 127.52,153.31 126.65,154.19 126.65,155.42 125.48,156.59 124.37,156.59 124.02,156.95 124.02,157.86 v2(124.53,158.37) ; v2(165.36,163.28) 164.28,163.28 162.65,164.91 158.18,164.91 155.83,162.56 155.83,161.24 154.13,159.54 154.13,155.61 155.36,154.38 155.36,152.7 156.38,151.69 156.38,149.95 157.42,148.91 163.38,148.91 v2(164.48,147.81) ; v2(191.34,48.79) 190.2,48.79 189.03,47.62 189.03,42.44 188.7,42.11 188.7,38.29 189.79,37.2 189.79,33.26 191.97,31.08 191.97,27.2 192.86,26.31 194.26,26.31 195.3,25.27 202.89,25.27 204.25,26.63 206.01,26.63 207.28,25.36 209.44,25.36 210.68,24.12 210.68,22.41 210.2,21.93 210.2,21 v2(210.51,20.68) 210.75,20.68 211.34,20.09 211.34,13.87 210.58,13.11 194.9,13.11 193.44,14.57 193.44,23.24 192.29,24.38 191.1,24.38 190.41,23.7 190.41,22.21 185.03,16.83 179.37,16.83 178.29,15.74 166.9,15.74 v2(166.68,15.52)
  IN3 w3.048: 73.67,62 76.36,62 85.7,71.34 85.7,88.63 87.58,90.51 87.58,119.28 89.57,121.27 98.25,121.27 101.49,124.5
  IN4 w0.508: v2(149.05,66.5) 148.4,67.15 148.4,68.66 148.89,69.14 v2(148.99,69.14) ; v2(210.51,20.68) 210.33,20.87 210.33,22.19 212.99,24.85 216.83,24.85 217.88,25.91 v2(217.88,28.79)
  IN4 w1.016: v2(171.65,150.54) 171.06,149.95 168.04,149.95 165.75,147.66
  BOTTOM w0.203: UT4.H10 127.99,152.08 127.59,152.49 v2(127.52,152.49) ; v2(55.45,60.4) U17.4
  BOTTOM w0.254: UZ21.4 98.08,88.35
  BOTTOM w0.305: v2(179.21,8.97) 179.52,8.97 181.5,10.95 JKB.1
  BOTTOM w0.508: v2(82.15,62.5) 82.15,63.05 89.22,70.12 89.22,71.9 97.94,80.62 C2519.1 97.94,88.22 98.08,88.35 ; CG384.1 v2(124.53,158.37) 124.78,158.37 125.3,158.89 RM91.1 RM92.1 126.17,159.55 126.66,159.05 128.12,159.05 128.36,158.81 130.69,158.81 130.94,159.05 131.5,159.05 132.07,158.48 RM93.1 RM94.1 ; v2(62.37,46.72) 62.12,46.72 61.62,46.22 PR203.1 ; v2(59.48,46.24) 58.94,46.78 58.94,49.44 57.18,51.2 57.18,54.85 C264.1 ; v2(247.35,62.06) 247.35,61.17 249.82,58.7 252.11,58.7 253.95,56.86 256.17,56.86 256.81,57.49 262.88,57.49 266.5,53.87 284.3,53.87 286.15,52.03 286.15,42.63 288.48,40.29 v2(288.48,38.37) ; PC308.1 210.62,20.79 v2(210.51,20.68)
  BOTTOM w1.016: 128.35,140.7 131.15,140.7 132.44,139.41 161.88,139.41 165.81,143.34 165.81,146.65
  BOTTOM w3.048: 128.35,140.7 128.24,140.8 110.63,140.8 103.07,133.25 103.07,129.96
  vias: v2(18.36,45.29) v2(18.36,44.66) v2(19.05,45.29) v2(19.05,44.66) v2(36.26,15.36) v2(36.26,14.72) v2(36.96,15.36) v2(36.96,14.72) v2(37.66,15.36) v2(37.66,14.72) v2(38.36,15.36) v2(38.36,14.72) v2(39.06,15.36) v2(39.06,14.72) v2(40.77,15.19) v2(40.77,14.56) v2(41.47,15.19) v2(41.47,14.56) v2(42.17,15.19) v2(42.17,14.56) v2(42.87,15.19) v2(42.87,14.56) v2(43.57,15.19) v2(43.57,14.56) v2(51.83,50.06) v2(52.21,50.7) v2(52.53,50.06) v2(52.88,50.68) v2(53.23,50.06) v2(55.12,57.67) v2(55.12,57.04) v2(55.12,56.4) v2(55.5,58.24) v2(55.76,57.67) v2(55.76,57.04) v2(55.76,56.4) v2(56.14,58.24) v2(56.39,57.67) v2(56.39,57.04) v2(56.39,56.4) v2(101.93,128.25) v2(101.93,127.62) v2(101.93,126.98) v2(101.93,126.35) v2(102.56,128.25) v2(102.56,127.62) v2(102.56,126.98) v2(102.56,126.35) v2(114.28,10.62) v2(114.86,10.62) v2(128.86,147.95) v2(129.03,148.55) v2(129.5,147.92) v2(129.5,147.29) v2(160.9,18.05) v2(160.99,17.46) v2(164.8,147.22) v2(165.98,15.52) v2(175.72,152.53) v2(175.72,151.92) v2(195.85,162.14) v2(196.17,161.57) v2(240.93,145.44) v2(241.57,145.44) v2(272.48,36.34) v2(272.48,35.7) v2(289.12,38.37) v2(289.12,37.73) v2(289.75,38.37) v2(296.36,60.85) v2(296.36,60.21) v2(296.69,59.65) v2(296.99,60.78) v2(296.99,60.15)
