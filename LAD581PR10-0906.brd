# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18456772: length 2.6
  BOTTOM w0.127: v2(60.46,31.98) v1(60.46,32.7)
  BOTTOM w0.508: PR707.2 60.97,31.03 60.46,31.54 v2(60.46,31.98)
N18456789: length 3.7
  TOP w0.508: v2(62.75,29.99) 62.74,30 PD700.1
  BOTTOM w0.114: v2(62.75,29.99) v1(63.3,29.99)
  BOTTOM w0.508: v2(62.75,29.99) 62.25,29.99 61.67,29.41 PR707.1
N18456799: length 4.3
  TOP w0.114: PR724.2 58.78,38.53 58.62,38.7 58.62,39 58.43,39.19 v1(58.43,40.66)
  TOP w0.203: PU700.10 58.81,37.63 58.75,37.69 58.75,38.22 PR724.2
N18456859: length 2.8
  TOP w0.114: v1(59.44,28.95) 59.58,29.09 PC702.2
  TOP w0.508: PR708.1 58.56,29.57 58.86,29.88 PC702.2
N18456884: length 4.6
  TOP w0.114: PC718.2 61.29,37.92 v1(61.22,38)
  TOP w0.203: PC718.2 61.41,37.15 61.41,36.78 60.76,36.13 PU700.7
  TOP w0.254: PC718.2 63.1,37.92 PR717.1
N18456888: length 2.9
  TOP w0.114: PC720.2 60.75,39.27 v1(60.94,39.27)
  TOP w0.203: PU700.8 59.61,37.39 59.64,37.43 59.64,38.16 PC720.2
N18456944: length 2.8
  TOP w0.114: PQ705.1 52.29,31.64 v1(51.81,31.15)
  TOP w0.508: v2(53.23,32.25) 53.23,32.03 PQ705.1
  BOTTOM w0.508: PR710.2 53.78,32.25 v2(53.23,32.25)
N18456952: length 3.6
  TOP w0.114: PR720.1 57.05,39.46 v1(57.99,39.46) 57.99,39.33 58.41,38.91 PU700.11
N18456954: length 2.8
  TOP w0.114: PU700.12 v1(58.01,38.1) 58.01,38.6 57.79,38.81 57.36,38.81 PR721.1
N18498179: length 4.4
  TOP w0.114: UU7.1 293.65,43.17 293.44,43.39 RU15.1 292.59,46.04 v1(292.51,45.96)
N18498181: length 3.2
  TOP w0.114: UU7.20 294.91,44.37 294.72,44.56 293.98,44.56 293.77,44.77 v1(293.77,45.09) 293.77,45.49 RU16.1
N18498183: length 4.6
  TOP w0.114: UU7.16 297.7,43.17 298.05,43.52 298.05,45.88 RU17.1 v1(298.88,46.04)
N18498185: length 2.3
  TOP w0.114: UU7.19 295.41,44.74 v1(295.06,45.08) 295.06,45.89 RU20.1
N18498187: length 2.3
  TOP w0.114: RU19.1 296.34,45.8 v1(296.34,45.08) 295.91,44.65 UU7.18
N18498189: length 3.3
  TOP w0.114: UU7.17 296.41,44.46 296.59,44.64 297.36,44.64 297.64,44.91 v1(297.64,45.06) 297.64,45.4 RU18.1
N18650921: length 4.1
  BOTTOM w0.114: RV634.2 154.35,101.67 155.58,101.67 155.84,101.94 156.2,101.94 156.67,102.41 UV21.59
N18651247: length 3.6
  BOTTOM w0.114: RV635.2 155.06,101.43 155.68,101.43 155.94,101.69 156.49,101.69 157.07,102.27 UV21.58
N18781336: length 2.6
  TOP w0.114: RV13.2 CV374.1 126.46,155.6 v1(127.19,154.86)
N18809163: length 1.9
  TOP w0.089: v2(102.32,85.26) 103.1,86.04 T44.1
  BOTTOM w0.076: v2(102.32,85.26) 102.72,85.66 CPU1.BT2
N18809164: length 2.4
  TOP w0.089: T43.1 102.17,84.35 v2(102,84.52)
  BOTTOM w0.076: CPU1.BR1 103.09,85.09 102.68,84.67 102.15,84.67 v2(102,84.52)
N18809165: length 1.8
  TOP w0.089: T41.1 140.97,86.28 v2(141.54,85.71)
  BOTTOM w0.076: CPU1.E3 140.99,86.32 141.54,85.77 v2(141.54,85.71)
N18809166: length 1.7
  TOP w0.089: T82.1 108.22,108.77 107.78,108.77 107.77,108.78 v2(107.4,108.78)
  BOTTOM w0.076: v2(107.4,108.78) 107.07,108.46 CPU1.BJ33
N18809168: length 5.1
  BOTTOM w0.127: T85.1 144.95,82.02 142.8,84.16 CPU1.B2
N18809169: length 4.3
  TOP w0.089: v2(101.63,84.06) 101.7,83.99 T88.1
  BOTTOM w0.076: v2(101.63,84.06) 102.69,84.06 103.23,84.6 103.48,84.6 103.77,84.89 103.77,85.56 CPU1.BR2
N18809170: length 1.1
  TOP w0.089: v2(107.4,109.43) 106.94,109.43 106.9,109.47 T81.1
  BOTTOM w0.076: v2(107.4,109.43) 107.07,109.11 CPU1.BJ34
N18809172: length 3.8
  BOTTOM w0.127: CPU1.C1 142.52,84.77 142.52,83.69 T89.1
N18809173: length 1.5
  TOP w0.089: v2(107.84,94.98) 107.89,95.03 T73.1
  BOTTOM w0.076: v2(107.84,94.98) 107.84,95.03 CPU1.BJ16
N18809174: length 1.2
  TOP w0.089: T74.1 106.2,96.06 v2(106.39,95.87)
  BOTTOM w0.076: v2(106.39,95.87) 106.74,95.52 CPU1.BK16
N18809175: length 1.1
  TOP w0.089: v2(106.36,101.37) 106.31,101.32 T75.1
  BOTTOM w0.076: CPU1.BK24 106.74,101.74 v2(106.36,101.37)
N18809176: length 1.3
  TOP w0.089: T76.1 107.92,100.99 v2(107.92,101.51)
  BOTTOM w0.076: CPU1.BJ24 107.66,101.77 v2(107.92,101.51)
N18809177: length 1.1
  TOP w0.089: v2(105.11,108.47) 105.11,108.16 T66.1
  BOTTOM w0.076: CPU1.BM33 105.44,108.14 v2(105.11,108.47)
N18809178: length 1.5
  TOP w0.089: v2(107.9,94.27) 107.56,94.61 T68.1
  BOTTOM w0.076: CPU1.BJ14 107.53,93.94 107.86,94.27 v2(107.9,94.27)
N18809179: length 2.6
  TOP w0.089: T69.1 107.99,93.84 v2(108.47,94.32)
  BOTTOM w0.076: v2(108.47,94.32) 108.06,93.91 107.84,93.91 107.34,93.42 CPU1.BJ13
N18809180: length 1.2
  TOP w0.089: v2(106.61,108.78) 106.15,108.33 T67.1
  BOTTOM w0.076: v2(106.61,108.78) 106.29,108.46 CPU1.BL33
N18809182: length 6.3
  TOP w0.089: RH192.2 142.99,102.01 v1(143.41,102.42)
  TOP w0.114: v2(139.22,101.59) 139.61,101.21 142.71,101.21 RH192.2
  BOTTOM w0.076: v2(139.22,101.59) 138.59,101.59 CPU1.J23
N18809184: length 4.7
  TOP w0.114: v2(139.24,100.82) 139.62,100.44 141.68,100.44 v1(142.07,100.04) 142.31,99.8 RH167.2
  BOTTOM w0.076: v2(139.24,100.82) 138.86,101.19 CPU1.H23
N19473413: length 4.1
  BOTTOM w0.254: 164.54,26.29 164.54,27.71 PC1305.2 165.38,28.03 165.53,27.88 PR1305.1 165.85,27.88 PR1304.2
N19473595: length 5.4
  BOTTOM w0.254: PU1300.1 165.81,21.96 166.09,22.24 v1(167.4,22.24) 167.82,21.82 PR1300.2
N19477426: length 4.1
  TOP w0.114: UU7.9 295.91,38.97 296.52,38.36 296.52,37.75 RU14.1 v1(298.02,37.28)
N19477490: length 2.8
  TOP w0.114: v1(293.46,38.19) RU21.2 294.91,38.71 UU7.7
N19496810: length 0.6
  BOTTOM w0.114: 242.55,151.12 v1(243.11,151.12)
N19497031: length 1.9
  BOTTOM w0.114: v1(238.74,146.54) 238.3,146.98 238.3,147.81 238.57,148.08 238.57,148.14
N19534507: length 4.6
  BOTTOM w0.114: 197.5,26.75 PC6119.2 197.5,25.86 v1(197.56,25.79)
  BOTTOM w0.203: PU6100.10 199.27,29.22 198.47,28.43 PR6122.2
  BOTTOM w0.254: 197.5,26.75 198.03,27.28 198.03,27.35 198.33,27.65 PR6122.2
N19534529: length 1.1
  BOTTOM w0.114: v1(204.65,34.84) 203.57,34.84 PC6107.2
N19534538: length 0.5
  BOTTOM w0.114: 196.56,34.84 v1(196.04,34.84)
N19534760: length 1.9
  TOP w0.114: v1(197.56,26.01) PR6125.2
  TOP w0.254: PR6125.2 198.45,26.94 PR6120.2
N19535281: length 5.3
  TOP w0.254: v2(201.25,28.28) v1(200.8,27.84) PC6118.1 PR6120.1
  BOTTOM w0.203: PU6100.7 200.47,29.06 v2(201.25,28.28)
  BOTTOM w0.254: v2(201.25,28.28) 201.1,28.14 PR6118.1
N19535283: length 4
  BOTTOM w0.114: PR6127.2 v1(200.24,25.79)
  BOTTOM w0.203: PR6119.2 202.88,27.59 PC6121.1
  BOTTOM w0.254: PR6119.2 PR6118.2 PR6127.2
N19535308: length 2.6
  BOTTOM w0.203: PR6110.2 203.14,29.25 v1(202.69,29.7) 201.99,30.4 PU6100.5
N19535327: length 6.3
  TOP w0.254: PC6110.1 195.27,30.9 PR6113.2 195.8,30.38 196.41,30.38 PC6109.1 196.72,30.06 v2(197.82,30.06)
  BOTTOM w0.203: PR6115.2 196.94,29.5 v1(197.27,29.83) 197.64,29.83 197.82,30.01 v2(197.82,30.06) 198.15,30.4 PU6100.11
N19535343: length 4.2
  BOTTOM w0.114: v1(197.56,28.58) 197.5,28.52 PC6119.1
  BOTTOM w0.203: PR6115.1 196.33,28.61 PC6117.1
  BOTTOM w0.254: PC6117.1 196.38,27.86 PR6123.2 PC6119.1
N19535360: length 2.3
  TOP w0.254: PR6113.1 v1(195.28,28.94) 195,28.66 v2(194.83,28.66)
  BOTTOM w0.254: v2(194.83,28.66) 194.88,28.61 PC6117.2
N19535469: length 2.1
  BOTTOM w0.203: PU6100.9 199.67,29.12 199.36,28.81 v1(199.36,28.59) PR6117.1
N19535500: length 5.5
  TOP w0.114: PC6110.2 v1(195.27,33.65)
  TOP w0.254: PC6110.2 194.44,31.9 194.44,29.82 v2(194.58,29.68)
  BOTTOM w0.254: PR6112.1 195.28,30.38 v2(194.58,29.68)
N19616464: length 16.6
  TOP w0.381: CG230.1 184.9,87.19 v2(184.9,87.65)
  IN5 w0.381: v2(184.9,87.65) 184.9,84.62 185.64,83.88 185.64,79.64 v2(186.7,78.57)
  BOTTOM w0.25: UG9.BC12 v2(184.9,87.65)
  BOTTOM w0.508: v2(186.7,78.57) 186.32,78.19 v1(186.32,77.77) CG231.1 187.15,76.35 187.3,76.5 CG232.1 189.3,76.5 LG4.2
N19616930: length 64.2
  TOP w0.254: CG233.1 186.06,95.59 v2(185.65,96) ; v2(203.05,108) 203.6,107.45 CG237.1 ; CG234.1 196.28,87.47 v2(196.75,87)
  TOP w0.457: CG239.1 179.88,86.84 v1(180.2,86.84) CG238.1 CG236.1 182.3,87.03 CG235.1 184.2,87.07 v2(184.2,87.65)
  TOP w0.508: CG239.1 178.72,85.68 LG3.2
  IN1 w0.381: v2(185.65,96) 186.67,97.02 186.67,107.05 187.53,107.91 189.43,107.91 190.39,106.96 202.01,106.96 v2(203.05,108)
  IN3 w0.381: v2(184.2,87.65) 184.2,88.64 184.61,89.05 185.88,89.05 186.32,89.5 186.32,95.27 185.65,95.95 v2(185.65,96)
  BOTTOM w0.25: v2(185.65,96) 185.55,96 UG9.BB24
  BOTTOM w0.254: v2(203.05,108) 202.8,108.25 UG9.U42
  BOTTOM w0.381: UG9.BD12 183.9,87.09 184.23,86.77 184.85,86.77 185.32,87.24 186.27,87.24 186.56,87.53 196.39,87.53 196.67,87.24
N19618056: length 2.1
  TOP w0.089: v2(180.1,83.45) 180.11,83.46 RG101.1 180.72,82.8 v1(180.99,82.53)
  BOTTOM w0.114: UG9.BJ6 v2(180.1,83.45)
N19795707: length 3.8
  BOTTOM w0.114: RG7.1 183.89,61.2 183.59,61.49 RG537.1 183.69,61.81 183.78,61.81 184.1,62.13 184.44,62.13 UG10.4 185.02,61.99 185.02,62.15 RG562.1
N19799736: length 2.2
  TOP w0.089: v1(180.65,84.92) RG19.1 181.55,84.87 182.1,84.32 v2(182.1,84.25)
  BOTTOM w0.114: UG9.BG8 v2(182.1,84.25)
N19799738: length 1.7
  TOP w0.089: v1(182.55,83.81) 182.55,84 v2(182.8,84.25) 183.3,84.25 RG20.1
  BOTTOM w0.114: UG9.BF8 v2(182.8,84.25)
N19842722: length 1.8
  TOP w0.089: v1(233.89,84.35) v2(234.25,84.71) 234.93,84.71 RG130.1
  BOTTOM w0.089: v2(234.25,84.71) 234.65,84.31 UG5.J13
N19842724: length 1.8
  TOP w0.089: v1(234.65,74.64) v2(234.65,74.13) 234.57,74.06 RG126.1
  BOTTOM w0.254: UG5.J1 234.65,74.13 v2(234.65,74.13)
N19842731: length 2
  TOP w0.089: RG128.1 235.21,80.75 v2(234.6,81.36) 234.05,81.36 v1(234.05,81.36)
  BOTTOM w0.089: UG5.J10 234.65,81.41 v2(234.6,81.36)
N19847413: length 3.4
  BOTTOM w0.089: 226.94,136.35 225.38,136.35 UG4.J13
  BOTTOM w0.114: RG120.1 v1(227.28,136.35) 226.94,136.35
N19847417: length 2
  TOP w0.089: 214.38,135.95 v2(214.79,135.95) 215.14,135.95 v1(215.28,135.81)
  TOP w0.114: RG116.1 214.38,135.95
  BOTTOM w0.254: UG4.J1 214.81,135.98 v2(214.79,135.95)
N19847426: length 1.8
  TOP w0.089: v1(222.57,135.93) v2(222.06,135.93) 221.97,135.84 RG118.1
  BOTTOM w0.089: v2(222.06,135.93) 222.11,135.98 UG4.J10
N19848462: length 3.1
  BOTTOM w0.114: QG3.1 239.73,124.47 v1(239.3,124.05) RG122.1
N19849394: length 3
  TOP w0.089: v1(237.11,120.65) 237.11,120.4 v2(236.28,119.57)
  TOP w0.114: RG119.1 237.11,121.5 v1(237.11,120.65)
  BOTTOM w0.089: UG3.J13 236.68,119.17 v2(236.28,119.57)
N19849396: length 2.2
  TOP w0.089: v2(236.68,108.99) 236.68,108.99 236.68,108.38
  TOP w0.114: 236.68,108.38 RG115.1 v1(237.63,108.29)
  BOTTOM w0.254: UG3.J1 236.68,108.99 v2(236.68,108.99)
N19849403: length 3.6
  TOP w0.254: v2(236.68,116.23) 236.23,115.78 v1(236.23,114.27) RG117.1
  BOTTOM w0.254: UG3.J10 v2(236.68,116.23)
N19854250: length 2.5
  TOP w0.254: RG109.1 v1(191.13,135.97) v2(190.74,135.58)
  BOTTOM w0.254: v2(190.74,135.58) 190.34,135.98 UG2.J13
N19854254: length 1.9
  TOP w0.089: v2(180.09,135.95) v1(180.62,135.95)
  TOP w0.254: v2(180.09,135.95) 179.98,135.84 RG105.1
  BOTTOM w0.254: v2(180.09,135.95) 180.12,135.98 UG2.J1
N19854263: length 1.9
  TOP w0.089: v2(187.39,135.93) v1(187.39,135.42)
  TOP w0.381: RG107.1 186.89,136.42 v2(187.39,135.93)
  BOTTOM w0.254: UG2.J10 187.44,135.98 v2(187.39,135.93)
N19855299: length 3.2
  BOTTOM w0.114: QG2.1 195.66,136.55 RG111.1 196.67,136.1 v1(196.7,136.08)
N19856231: length 2.3
  TOP w0.089: v2(199.81,135.58) 199.61,135.58 v1(199.33,135.85) 198.88,136.31 RG108.1
  BOTTOM w0.089: UG1.J13 v2(199.81,135.58)
N19856233: length 2.9
  TOP w0.089: 210.81,136.27 210.7,136.27 v2(210.41,135.98)
  TOP w0.114: RG104.1 211.98,135.75 v1(211.46,136.27) 210.81,136.27
  BOTTOM w0.254: UG1.J1 v2(210.41,135.98)
N19856240: length 2.2
  TOP w0.089: v2(203.16,135.93) v1(203.7,135.93)
  TOP w0.381: RG106.1 202.84,135.61
  TOP w0.4: 202.84,135.61 v2(203.16,135.93)
  BOTTOM w0.089: v2(203.16,135.93) 203.11,135.98 UG1.J10
N20118187: length 3.8
  TOP w0.114: UU7.8 295.41,38.32 RU23.2 296,37.47 v1(296,36.4)
N20539566: length 7.1
  BOTTOM w0.114: v1(174.19,91.59) 174.51,91.91 RG26.1 175.3,92.19 175.46,92.35 176.48,92.35 178.83,94.7 179.14,94.7 179.49,95.05 UG9.BK23
N20881316: length 6.3
  BOTTOM w0.114: v1(95.91,102.46) PR5033.1
  BOTTOM w0.254: PR5033.1 95.38,106.41 95.24,106.41 95,106.65 PR5034.2 94.94,106.77 PU509.13
N20881504: length 3.2
  BOTTOM w0.114: PR5017.1 93.73,111.1 v1(93.33,110.7)
  BOTTOM w0.254: PR5012.1 92.52,111.56 PR5014.2 93.67,111.56 PR5017.1
N20881570: length 0.6
  TOP w0.114: v2(92.95,104.3) v1(92.95,104.89)
N20881862: length 12.3
  IN5 w0.254: v2(94.37,106.09) 94.37,110.53 91.77,113.14 v2(91.61,113.14)
  BOTTOM w0.114: v1(91.63,114.76) PC820.2
  BOTTOM w0.254: PR5015.1 91.59,112.45 PR5012.2 v2(91.61,113.14) 91.61,113.79 PC820.2 ; PU509.14 94.14,106.32 v2(94.37,106.09)
N20904379:
  vias: v1(127.2,147.04)
N20905578: length 2.4
  TOP w0.114: v2(126.38,152.55) 126.38,153.06 CT104.1 127.12,153.25 v1(127.47,153.61)
  BOTTOM w0.076: UT4.H7 126.55,152.38 v2(126.38,152.55)
N20905857: length 3.3
  TOP w0.114: v2(122.39,151.17) 122.55,151.33 123.65,151.33 124.07,150.91 RT83.2
  BOTTOM w0.076: UT4.F1 123.32,151.31 122.54,151.31
  BOTTOM w0.127: 122.54,151.31 v2(122.39,151.17)
N20960615: length 4
  TOP w0.114: QE54.2 127.97,8.34 v1(127.4,7.78) 127.33,7.78 127.31,7.77 125.81,7.77 125.64,7.94 RE543.1 RE449.2
N20960628: length 1.7
  TOP w0.114: QE39.5 143.72,5.84 RE456.1 RE455.2
N20960654: length 1.6
  TOP w0.114: QE29.5 130.63,5.88 RE397.1 RE396.2
N20960689: length 1.6
  TOP w0.114: QE29.2 130.63,2.78 RE401.1 RE399.2
N20960760: length 1.7
  TOP w0.114: QE39.2 143.72,3.08 143.44,2.79 RE453.1 RE454.2
N20960882: length 2.3
  TOP w0.114: QE49.2 125.36,9.23 125.49,9.36 125.89,9.36 126.01,9.23 QE49.3 126.01,8.52 126.23,8.31 RE543.2
N20960884: length 1.7
  TOP w0.114: RE460.2 RE458.1 146.28,2.8 QE40.2
N20960892: length 2.6
  TOP w0.114: QE40.5 146.28,5.76 RE462.1 RE461.2 v1(146.7,7.68)
N20960976: length 1.7
  TOP w0.114: QE41.2 133.26,2.8 RE465.1 RE467.2
N20960982: length 1.7
  TOP w0.114: QE41.5 133.26,5.86 RE468.1 RE466.2
N20961145: length 1.7
  TOP w0.114: RE474.2 RE472.1 135.56,2.79 135.88,3.11 QE42.2
N20961166: length 1.6
  TOP w0.114: QE42.5 135.88,5.93 RE473.1 RE471.2
N20961197: length 2.8
  TOP w0.114: QE43.2 125.1,14.36 124.77,14.03 RE479.1 RE480.2 124.77,12.55 v1(124.47,12.25)
N20961228: length 2.6
  TOP w0.114: v1(124.61,18.46) 124.83,18.25 RE476.2 RE478.1 125.1,17.26 QE43.5
N20961418: length 1.7
  TOP w0.114: QE44.2 141.11,2.78 RE485.1 RE486.2
N20961454: length 1.7
  TOP w0.114: QE44.5 141.11,5.88 RE484.1 RE482.2
N20961510: length 1.7
  TOP w0.114: QE45.2 128.01,2.82 RE491.1 RE492.2
N20961531: length 1.6
  TOP w0.114: RE488.2 RE490.1 128.01,5.88 QE45.5
N20961580: length 1.6
  TOP w0.114: RE498.2 RE496.1 138.23,2.73 138.5,3 QE46.2
N20961592: length 1.6
  TOP w0.114: RE495.2 RE497.1 138.5,5.9 QE46.5
N20961740: length 1.7
  TOP w0.114: RE503.2 RE501.1 125.39,2.81 QE47.2
N20961750: length 1.6
  TOP w0.114: QE47.5 125.39,5.9 RE504.1 RE502.2
N20961813: length 2.6
  TOP w0.114: QE48.2 122.8,2.88 RE508.1 RE510.2 122.42,1.32 v1(122.14,1.04)
N20961825: length 2.5
  TOP w0.114: v1(122.22,7.02) 122.42,6.82 RE507.2 RE509.1 123.05,5.9 122.8,5.65 QE48.5
N21146007: length 0.7
  TOP w0.114: 203.24,35.44 v1(203.24,34.77)
N21146153: length 0.9
  TOP w0.114: 198.43,35.27 v1(198.43,34.42)
N21146805: length 1
  TOP w0.114: 216.82,34.54 v1(216.82,33.58)
N21148887: length 2.6
  BOTTOM w0.114: v1(120.21,137.11) PR591.2
  BOTTOM w0.254: PU510.1 121.64,135.88 121.41,136.1 121.41,136.36 121.15,136.61 PR591.2
N21148889: length 1.6
  BOTTOM w0.254: PR594.2 121.92,136.98 121.92,136.29 122.14,136.07 PU510.2
N21287548: length 4
  BOTTOM w0.114: PR820.2 236.67,153.4 235.22,153.4 v1(235,153.17)
  BOTTOM w0.254: PR820.2 237.45,152.61 237.69,152.61 237.96,152.35 PU802.4
N21374779: length 4.6
  TOP w0.114: PR8214.2 260.61,56.91 v1(261.07,56.44)
  TOP w0.254: PQ8202.2 260.7,60.23 261.09,59.84 261.09,58.86 PC8222.1 PR8214.2
N21374792: length 5.8
  TOP w0.114: v1(258,58.11) PR8215.2
  TOP w0.203: PR8208.2 256.31,61.67 255.87,61.67 255.76,61.78 PU8200.7
  TOP w0.254: PR8208.2 257.96,60.87 258,60.91 ; 258,60.91 PC8216.1 ; 258,60.91 PR8211.1 258,60.02 PR8215.2
N21374806: length 3
  TOP w0.114: PR8215.1 258.92,58.5 v1(259.41,58)
  TOP w0.203: PR8215.1 259.9,59.08 PQ8202.3
N22226841: length 3.6
  TOP w0.114: QV97.2 196.7,151.79 196.95,152.04 196.95,153.02 UX1.4 196.86,154.13 v1(197.25,154.13)
N22279740: length 1.6
  BOTTOM w0.114: DV13.1 171.73,157.56 RV653.2
N22279742: length 1.3
  BOTTOM w0.114: RV649.2 169.04,157.25 169.24,157.05 DV12.1
N22280311: length 2.5
  TOP w0.114: v1(125.81,13.09) 125.67,12.95 RE513.2 RE512.1 125.36,11.34 QE49.5
N22281033: length 3.1
  TOP w0.114: QE50.5 130.63,11.07 130.06,11.64 v1(130.06,11.84) 130.06,12.15 130.25,12.34 RE531.2 RE532.1
N22281062: length 6.1
  TOP w0.114: RE544.1 RE533.2 130.15,8.13 129.83,8.45 129.8,8.45 129.58,8.66 129.58,9.2 129.24,9.55 128.67,9.55 127.97,10.25 QE54.5 127.97,11.11 v1(128.69,11.84)
N22281110: length 3.4
  TOP w0.114: QE50.2 130.63,9.3 130.72,9.39 131.16,9.39 131.28,9.26 QE50.3 131.28,8.58 131.5,8.37 RE544.2 131.73,8.09 v1(132.32,8.69)
N22281666: length 2.5
  TOP w0.114: QE51.5 133.64,17.07 RE535.1 RE534.2 v1(132.81,18.38)
N22281686: length 4.8
  TOP w0.114: RE545.1 RE539.2 134.09,13.55 134.22,13.42 v3(136.07,13.42) 136.16,13.42 136.29,13.55 QE55.2
N22281703: length 2.5
  TOP w0.114: QE52.5 139.71,17.4 RE537.1 RE536.2 v1(139.12,18.31)
N22281752: length 4.8
  TOP w0.114: RE546.1 RE538.2 137.9,15.99 137.56,15.65 136.48,15.65 136.29,15.84 QE55.5 v1(136.29,17.87)
N22281797: length 4.4
  TOP w0.114: RE546.2 138.13,14.16 138.27,14.02 v1(138.71,14.02) 139.57,14.02 139.71,14.16 QE52.2 139.71,15.14 139.97,15.39 140.24,15.39 140.36,15.26 QE52.3
N22281839: length 4
  TOP w0.114: QE51.3 134.08,15.31 133.94,15.45 133.55,15.45 133.43,15.33 QE51.2 133.43,14.69 132.82,14.08 RE545.2 132.82,13.95 v1(133.71,13.06)
N22282133: length 2.4
  TOP w0.114: QE53.5 130.27,17.38 130.41,17.51 RE541.1 RE540.2 v1(129.55,18.38)
N22282153: length 5.1
  TOP w0.114: QE56.2 127.71,14.31 127.9,14.12 128.67,14.12 128.98,14.44 129.91,14.44 130.04,14.31 RE542.2 ; RE547.1 RE542.2 ; RE542.2 130.04,13.32 v1(130.25,13.11)
N22282201: length 4.1
  TOP w0.114: v1(132.39,13.16) 131.62,13.93 RE547.2 131.31,14.21 130.92,14.59 QE53.3 130.92,15.31 130.8,15.44 130.4,15.44 130.27,15.31 QE53.2
N22363411: length 3
  TOP w0.114: RE530.2 CE63.2 120.25,7.81 120.25,8.97 120.16,9.05 UE10.3
N22579775: length 1.3
  TOP w0.114: R367.1 152.78,60.74 152.48,61.05 U18.3
N24948778: length 1.1
  TOP w0.114: RE153.2 164.52,154.89 QE13.6
N24949488: length 3.9
  TOP w0.114: v1(173.95,153.92) 173.07,153.92 172.69,154.3 172.15,154.3 171.63,154.82 QE21.6 171.25,154.83 RE155.2
N24950010: length 1.4
  TOP w0.114: RE157.2 176.77,155.42 176.9,155.29 QE22.6
N25433867: length 6.8
  TOP w0.114: PQ202.5 56.13,46.71 55.83,47.01 54.12,47.01 53.99,47.14 53.99,47.2 53.61,47.59 53.21,47.59 PC218.1 52.53,47.54 PR214.2 52.53,48.21 53.47,49.15 v1(53.47,49.38)
N25435297: length 1.1
  TOP w0.114: PQ202.3 55.48,48.88 PR215.2
N25436981: length 10.9
  TOP w0.114: v2(54.94,49.3) 54.87,49.38 v1(54.87,49.83)
  TOP w0.203: PU201.6 59.88,51.53 59.45,51.53 58.89,52.08 v2(58.73,52.08)
  TOP w0.254: PR213.1 54.5,48.67 54.94,49.11 v2(54.94,49.3) 54.99,49.3 PR215.1
  IN5 w0.254: v2(54.94,49.3) 55.13,49.3 56.4,50.57 57.22,50.57 v2(58.73,52.08)
  BOTTOM w0.254: PR207.1 58.99,52.34 v2(58.73,52.08) 58.53,52.28 PR205.1
N25523951: length 7.2
  TOP w0.114: PR212.2 54.24,46.07 v1(53.8,46.07)
  TOP w0.254: PR212.2 PC217.1 56.58,45.74 56.91,45.74 57.29,46.13 57.29,47.4 56.96,47.72 56.46,47.72 56.13,48.05 PQ202.2
N25523965: length 4.4
  TOP w0.114: v1(53.54,48.08) 53.67,48.08 54.18,47.57 PR213.2
  TOP w0.254: PQ202.6 56.78,47.2 56.62,47.37 56.24,47.37 56.03,47.57 PR213.2
N26393873: length 5.5
  TOP w0.114: v2(191.15,159.47) 190.9,159.73 190.9,161.25 189.8,162.35 189.8,162.53 RV672.1
  BOTTOM w0.114: UV3.12 191.64,159.6 191.51,159.47 v2(191.15,159.47)
N26393875: length 7.1
  TOP w0.114: RV671.1 189.56,162.42 189.56,162.28 190.68,161.16 190.68,159.64 v2(190.51,159.47)
  BOTTOM w0.114: v2(190.51,159.47) 190.2,159.47 189.69,159.98 UV3.9 189.69,162.09 v1(189.78,162.18)
N26668634: length 3
  TOP w0.114: CG313.1 196.61,134.43 RG102.2 RG523.2 197.03,132.08 v1(196.99,132.04)
N26671206: length 3.2
  TOP w0.114: CG314.1 194.2,133.16 RG103.2 RG524.2 194.22,134.99 v1(194.45,135.22)
N26672234: length 3.3
  TOP w0.114: CG315.1 236.13,122.58 RG525.2 RG113.2 234.34,122.73 v1(234,123.07)
N26672631: length 3.1
  BOTTOM w0.114: v1(229.82,132.04) 229.34,132.52 RG114.2 RG526.2 229.34,134.94 CG316.1
N26673021: length 3
  TOP w0.114: RG124.2 RG527.2 236.65,88 CG317.1 237.57,87.97 v1(237.69,87.84)
N26673418: length 3.3
  TOP w0.114: v1(233.82,90.58) 233.85,90.55 RG125.2 RG528.2 237.09,90.55 CG318.1
N26979734: length 2.7
  BOTTOM w0.114: QG4.1 236.44,90.26 RG133.1 235.55,91.43 v1(236.18,92.06)
N26987587: length 3.1
  TOP w0.114: v2(200.42,153.19) 200.42,153.29 v1(200.1,153.61) 199.4,153.61 RL2.2
  BOTTOM w0.114: UL1.5 200.69,152.52 200.72,152.55 200.72,152.73 200.42,153.03 v2(200.42,153.19)
N26987818: length 5.2
  BOTTOM w0.114: QL3.1 232.99,155.65 232.67,155.97 232.67,157.16 RL13.2 233.35,157.24 RL14.2 v1(234.24,159.07)
N26987825: length 9.5
  BOTTOM w0.114: JLAN.12 226.47,163.88 227.97,162.38 v3(228.8,162.38) 231.77,162.38 CL31.1 231.86,162.29 LL1.2
N27160639: length 1.5
  TOP w0.114: QV2.1 117.73,152.88 RV12.2
N27381541: length 4
  BOTTOM w0.114: UG11.9 200.59,76.95 200.42,77.11 v1(198.26,77.11) 197.79,77.11 RG529.1
N27381544: length 20.2
  TOP w0.114: v1(196.1,76.86) 196.04,76.92 195.72,76.92 v2(195.59,76.8)
  IN3 w0.124: v2(185.96,70.62) 187.21,70.62 187.99,71.4 188.67,71.4 188.8,71.53 188.8,73.56 192.61,77.37 193.94,77.37 194.51,76.8 v2(195.59,76.8)
  BOTTOM w0.114: QG5.3 185.31,71.27 v2(185.96,70.62) ; v2(195.59,76.8) RG529.2 197.05,76.63 197.05,76.54 197.16,76.43 197.49,76.43 RG63.2 198.63,75.29 UG11.8
N27864293: length 2.9
  BOTTOM w0.114: v1(68.21,2.95) 68.27,2.88 RE14.2 UE2.3
N27864303: length 4.7
  BOTTOM w0.114: 69.38,13.21 RE11.1 ; 69.38,13.21 68.98,13.6 68.98,14.51 69.29,14.82 v1(69.29,15.2) ; 69.38,13.21 CE20.1 UE2.6
N27864309: length 8.4
  BOTTOM w0.114: v1(66.63,6.82) 66.82,7.01 66.88,7.01 68.2,8.33 UE2.5 68.2,12.73 67.96,12.98 67.96,13.47 67.58,13.85 RE9.1
N27864330: length 4.1
  BOTTOM w0.114: v1(70.69,15.39) 70.44,15.14 70.44,14.63 70.25,14.44 70.25,13.55 70.59,13.21 RE13.2 UE2.7
N27864389: length 3.9
  TOP w0.114: UE1.20 266.22,47.77 v1(267.07,48.63) CE8.1
N27864390: length 4
  TOP w0.114: CE9.1 269.13,49.3 v1(268.4,48.58) 267.02,47.19 UE1.19
N27864395: length 4
  TOP w0.114: v1(273.78,39.99) 272.54,39.99 CE18.1 271.55,40.98 UE1.11
N27864397: length 1.9
  TOP w0.114: UE1.12 271.7,41.78 CE17.1
N27864399: length 1.9
  TOP w0.114: UE1.13 271.82,42.58 CE16.1
N27864402: length 1.8
  TOP w0.114: CE15.1 271.9,43.38 UE1.14
N27864404: length 1.8
  TOP w0.114: UE1.15 271.93,44.18 CE14.1
N27864406: length 2.9
  TOP w0.114: v1(271.97,46.14) CE13.1 271.82,44.98 UE1.16
N27864434: length 1.6
  BOTTOM w0.114: UE2.2 70.74,2.95 RE10.1
N27869543: length 11.3
  TOP w0.254: DF1.1 65.85,56.11 v3(64.37,57.59) v2(63.96,58) 63.26,58.7 RF3.1
  BOTTOM w0.114: v2(63.96,58) 63.87,58.09 63.87,61.46 64.69,62.28 64.95,62.28 65.46,62.79 65.46,63.39 65.22,63.62
N27869598: length 4.4
  TOP w0.114: v1(245.24,87.01) 245.22,86.98 v2(244.72,86.98)
  BOTTOM w0.114: JFAN2.2 v2(244.72,86.98) 244.51,86.88 RF6.1 DF2.1
N28776742: length 2.7
  TOP w0.114: v1(165.3,58.63) UG24.2 UG24.3 166.66,59.72 RG535.2
N28827302: length 1.1
  TOP w0.114: LX8.1 179.66,159.48 RX38.2
N28827395: length 0.9
  TOP w0.114: RX37.2 LX7.1
N28827433: length 1.2
  TOP w0.114: LX6.1 181.81,159.73 RX36.2
N28827473: length 1.2
  TOP w0.114: RX35.2 182.45,159.8 LX5.1
N28827533: length 1.3
  TOP w0.114: LX4.1 184.29,159.67 RX34.2
N28827572: length 1.2
  TOP w0.114: LX3.1 184.93,159.86 RX33.2
N28827613: length 1.4
  TOP w0.114: LX2.1 187.28,159.1 RX32.2
N28827656: length 1.2
  TOP w0.114: LX1.1 187.91,159.67 RX31.2
N29018046: length 14.3
  TOP w0.114: 302.3,39.36 302.95,40 302.95,44.53 v1(302.67,44.8) 301.96,45.52 301.96,45.81 300.67,47.09 QU1.2 ; 302.3,39.36 RU24.2 ; 302.3,39.36 302.38,39.36 303.2,38.53 303.2,37.45 302.16,36.41 301.26,36.41 300.9,36.77 RU25.1
N29026996: length 4.6
  BOTTOM w0.114: JLAN.9 v3(209.36,161.86) 208.62,161.12 RL8.1
N29187218: length 5.2
  BOTTOM w0.114: RV45.1 137.56,163.41 137.63,163.49 139,163.49 139.13,163.36 139.13,163.25 139.42,162.96 UV17.3 141.56,162.96 v1(141.75,162.77)
N29403961: length 2.7
  BOTTOM w0.114: UE4.24 169.79,19.74 169.27,20.26 RE32.2 v1(168.82,19.2)
N29403963: length 2.7
  BOTTOM w0.114: UE4.30 173.6,21.22 173.34,21.47 172.95,21.47 v1(172.73,21.69) 172.67,21.75 RE37.1
N29418337: length 2
  TOP w0.114: v2(87.49,129.8) v1(86.79,129.8)
  BOTTOM w0.254: PC508.2 87.49,129.16 v2(87.49,129.8) PR525.1
N29418339: length 5.5
  BOTTOM w0.114: v1(86.54,132.23) 86.6,132.17 PR522.1
  BOTTOM w0.203: PR531.1 88.98,131.92 88.98,132.19 89.41,132.62 PU500.5
  BOTTOM w0.254: PR531.1 PR525.2 PR522.1
N29418355: length 2
  BOTTOM w0.114: PC533.2 92.3,140.55 v1(92.67,140.92)
  BOTTOM w0.254: PR546.2 92.3,139.08 PC533.2
N29418359: length 4.3
  BOTTOM w0.203: PR546.1 92.32,137.99 92.66,137.65 92.66,137.33 92.93,137.06 PU500.17
  BOTTOM w0.254: PR550.2 PR546.1 PR549.1
N29418369: length 2
  BOTTOM w0.114: PC514.1 v1(102.07,136.02)
  BOTTOM w0.254: PC514.1 101.04,135.98 PR532.2
N29418371: length 53.6
  IN1 w0.254: v2(90.46,137.42) 91.45,138.41 95.9,138.41 96.72,139.24 107.63,139.24 107.9,138.96 112.36,138.96 113.23,138.09 115.96,138.09 116.22,138.35 117.61,138.35 118,138.73 120.41,138.73 121.17,137.97 124.66,137.97 125.42,138.72 128.88,138.72 129.66,137.94 131.89,137.94 132.6,138.64 135.17,138.64 v2(135.66,138.16)
  BOTTOM w0.114: PC5011.2 v1(86.64,138.41)
  BOTTOM w0.254: v2(90.46,137.42) PR545.1 90.45,138.16 PR547.2 89.5,138.07 87.9,138.07 PC5011.2 ; PH504.2 v2(135.66,138.16)
N29418373: length 6.7
  BOTTOM w0.114: PR532.1 98.5,135.98 v1(98.22,135.71)
  BOTTOM w0.203: PU500.30 98.23,133.42 98.69,133.88 98.69,134.52 PR533.1
  BOTTOM w0.254: PR536.1 99.22,136.89 PR532.1 99.22,135.06 PR533.1
N29418377: length 2.2
  BOTTOM w0.203: PU500.15 92.13,136.87 91.58,137.42 91.58,137.97 PR545.2
N29418393: length 28
  IN4 w0.137: v2(88.21,127.23) 89.53,128.55 96.15,128.55 96.6,128.99 100.2,128.99 105.42,134.22 v2(106.82,134.22)
  BOTTOM w0.114: v2(106.82,134.22) v1(108.28,134.22) 109.17,134.22 109.58,134.63 PH500.2
  BOTTOM w0.254: v2(88.21,127.23) 88.07,127.37 PR513.2 ; PR513.2 87.5,126.5 PC5010.2 ; PR513.2 87.48,127.4 PR514.1
N29418395: length 4.9
  BOTTOM w0.203: PU500.3 89.94,131.82 89.1,130.98 89.1,130.3 89.3,130.11 v1(89.3,129.79) 89.3,129.17 PR514.2
N29418397: length 3.8
  TOP w0.114: v1(87.9,131.33) PR521.2
  TOP w0.254: PC505.2 90.02,131.57 89.53,132.06 v2(89.49,132.06) 89.49,131.97 PR521.2
  BOTTOM w0.203: PU500.4 89.64,132.22 89.49,132.06 89.49,132.06 v2(89.49,132.06)
N29418405: length 3.8
  TOP w0.114: v2(97.33,130.02) v1(97.33,130.55)
  TOP w0.254: PR527.1 96.89,129.68 97.23,130.02 v2(97.33,130.02)
  BOTTOM w0.203: v2(97.33,130.02) 97.36,130.04 97.36,130.6 96.94,131.02 PU500.36
N29418417: length 3.9
  BOTTOM w0.203: PR524.1 99.1,131.5 98.67,131.93 v1(98.02,131.93) 97.93,131.93 97.64,132.22 PU500.33
  BOTTOM w0.254: PC509.2 99.2,131.35 99.23,131.37 PR524.1
N29418423: length 3.6
  TOP w0.254: PC520.2 96.71,134.39 PR537.1 97.11,134.4 v2(97.61,133.9)
  BOTTOM w0.114: v1(98.12,133.85) 98.06,133.9 v2(97.61,133.9)
  BOTTOM w0.203: v2(97.61,133.9) 97.53,133.82 PU500.29
N29418425: length 6.1
  TOP w0.114: PC519.1 v1(96.42,137.76)
  TOP w0.254: v2(98.18,134.36) 97.77,134.36 96.42,135.71 PR539.1 PC519.1
  BOTTOM w0.203: v2(98.18,134.36) 97.31,134.36 97.17,134.22 PU500.28
N29418433: length 4.1
  TOP w0.114: v1(91.51,128.64) 91.13,129.01 v2(91.13,129.08)
  TOP w0.254: v2(91.13,129.08) 90.86,128.8 PR520.1 PR515.2
  BOTTOM w0.203: v2(91.13,129.08) 91.26,129.08 91.73,129.54 PU500.47
N29418441: length 2.1
  BOTTOM w0.203: PU500.40 94.53,129.56 94.88,129.2 94.88,128.55 PR518.1
N29418445: length 2.1
  BOTTOM w0.203: PR517.1 95.21,128.68 95.21,129.34 94.93,129.63 PU500.39
N29418451: length 2.3
  BOTTOM w0.203: PR516.1 95.58,129.2 95.58,129.46 95.33,129.71 PU500.38
N29418455: length 3.7
  BOTTOM w0.114: PR519.1 97.99,128.99 v1(98.2,128.99)
  BOTTOM w0.203: PR519.1 96.28,129.39 96.15,129.39 95.73,129.82 PU500.37
N29418473: length 4.3
  TOP w0.254: v2(92.09,137.52) 91.89,137.32 PR551.1 91.89,135.86 92.28,135.47 PC536.1
  BOTTOM w0.203: PU500.16 92.53,136.96 92.09,137.39 v2(92.09,137.52)
N29418487: length 5.2
  TOP w0.114: v2(94.37,128.96) 96.29,128.96 v1(96.43,128.82)
  TOP w0.254: PC504.1 94.69,129.28 v2(94.37,128.96) 94.65,128.68 PR506.2
  BOTTOM w0.203: v2(94.37,128.96) 94.37,129.2 94.13,129.45 PU500.41
N29418491: length 2.4
  BOTTOM w0.203: PR523.1 90.5,128.62 90.5,129.2 90.88,129.58 91.07,129.58 91.33,129.84 PU500.48
N29419473: length 3.6
  TOP w0.114: v2(89.56,130.66) v1(89.11,130.21)
  TOP w0.254: v2(89.56,130.66) 89.58,130.64 PC500.2 PR500.2
  BOTTOM w0.203: PU500.2 90.05,131.42 89.55,130.92 89.55,130.68 v2(89.56,130.66)
N29419486: length 3.5
  BOTTOM w0.203: PC518.2 88.91,134.39 88.91,134.23 89.15,133.99 89.23,133.99 89.4,133.82 PU500.8
  BOTTOM w0.254: PC518.2 PR540.2
N29419576: length 2.7
  TOP w0.114: PR521.1 88.28,132.24 v1(87.9,132.63)
  TOP w0.254: PR521.1 88.99,132.24 89.3,132.55 90.11,132.55 PC506.2
N29419623: length 59.1
  TOP w0.254: PR534.2 89.71,140.71 89.86,140.85 90.11,140.85 v1(90.12,140.86) 90.13,140.87 v2(90.63,140.87)
  IN1 w0.254: v2(121.11,121.37) 116.41,121.37 115.77,122.01 87.45,122.01 86.25,123.21 86.25,138.64 88.47,140.87 v2(90.63,140.87)
  BOTTOM w0.254: PH502.1 121.11,120.86 v2(121.11,121.37)
N29419647: length 2
  TOP w0.114: PC521.1 97.1,132.55 v1(97.62,133.07)
  TOP w0.254: PR537.2 96.74,133.48 PC521.1
N29419655: length 1.8
  BOTTOM w0.114: v1(101.09,137.79) PC522.1
  BOTTOM w0.254: PC522.1 PR536.2
N29419663: length 0.9
  BOTTOM w0.254: PR530.1 PH501.2
N29419667: length 66.9
  TOP w0.254: v2(89.86,137.52) 89.54,137.85 v1(89.54,138.39) 89.54,138.7 89.91,139.07 PR544.1
  IN5 w0.254: v2(89.86,137.52) 90.5,138.16 92.28,138.16 92.6,137.84 92.6,137.33 93.04,136.89 95.71,136.89 96.79,137.97 97.61,137.97 99.01,136.57 100.88,136.57 103.86,133.59 103.86,123.93 109.26,118.53 125.81,118.53 128.41,121.14 136.66,121.14 136.79,121.27 136.79,121.43 v2(136.8,121.44)
  BOTTOM w0.254: PH503.2 v2(136.8,121.44)
N29419693: length 1.8
  BOTTOM w0.114: v1(89.42,136.65) PR538.2
  BOTTOM w0.254: PR538.2 88.46,135.78 PC518.1
N29419713: length 3.4
  BOTTOM w0.203: PR526.2 89.33,128.73 90.06,129.46 90.06,130.92 90.16,131.02 PU500.1
N29419730: length 2.5
  BOTTOM w0.114: v1(97.83,130.23) 98.37,129.7 PC509.1
  BOTTOM w0.254: PC509.1 PR528.2
N29419832: length 3.6
  TOP w0.114: PR505.2 92.95,128.34 v1(92.85,128.43)
  TOP w0.254: PC503.1 93.59,129.29 v2(93.8,129.08) 93.78,129.05 PR505.2
  BOTTOM w0.203: v2(93.8,129.08) 93.73,129.15 PU500.42
N29419860: length 5.4
  TOP w0.114: v1(89.51,136.32) 90.02,135.81 PR548.1
  TOP w0.254: PR548.1 PC535.2 91.33,135.84 91.33,136.95 v2(91.07,137.2)
  BOTTOM w0.203: v2(91.07,137.2) 91.2,137.2 91.73,136.68 PU500.14
N29419910: length 2.1
  TOP w0.114: v1(93.21,134.78) 92.84,135.15 PC538.2
  TOP w0.254: PC538.2 92.8,135.89 PR551.2
N29419918: length 0.9
  BOTTOM w0.254: PC537.1 90.56,139.96 PR549.2
N29419943: length 4
  BOTTOM w0.114: PC532.1 94.34,139.87 v1(94.16,140.04)
  BOTTOM w0.203: PR541.1 94.25,138.08 94.25,137.2 94.13,137.08 PU500.20
  BOTTOM w0.254: PR541.1 PC532.1
N29419947: length 1.8
  BOTTOM w0.114: PR543.1 96.13,139.92 v1(96.06,139.98)
  BOTTOM w0.254: PC532.2 96.11,139.06 PR543.1
N29425467: length 5.7
  TOP w0.254: PR577.2 147.6,126.34 PR578.1 148.16,125.77 v2(148.28,125.65)
  TOP w0.508: PR575.1 v2(146.95,129.77)
  BOTTOM w0.254: PL503.2 147.9,126.03 v2(148.28,125.65)
  vias: v1(145.2,129.5)
N29425497: length 5.3
  TOP w0.254: PR567.2 139.87,126.44 PR568.1 140.46,125.86 v2(140.54,125.77)
  TOP w0.508: PR565.1 v2(139.08,129.71)
  BOTTOM w0.254: v2(140.54,125.77) 140.22,126.09 PL502.2
  vias: v1(137.31,129.51)
N29425633: length 5.5
  TOP w0.254: PR557.2 132.47,126.91 PR558.1 v2(133.17,125.73)
  TOP w0.508: PR555.1 v2(130.25,129.77)
  BOTTOM w0.254: PL501.2 132.54,126.36 v2(133.17,125.73)
  vias: v1(128.91,129.49)
N29426641: length 2.7
  BOTTOM w0.114: PR573.2 144.92,137.06 144.79,136.94 v1(144.79,136.93)
  BOTTOM w0.254: PR573.2 145.77,137.04 145.77,136.56 146.02,136.31 146.02,136.17 146.25,135.94 PU504.1
N29426805: length 3.5
  TOP w0.114: PR555.2 v1(132.92,130.11)
  TOP w0.508: PR555.2 133.55,127.93 PC548.1
N29426831: length 3.1
  TOP w0.114: v1(141.74,130.01) PR565.2
  TOP w0.508: PR565.2 PC556.1
N29426855: length 3.2
  TOP w0.114: v1(149.51,130.06) 149.62,129.95 PR575.2
  TOP w0.508: PR575.2 PC564.1
N29435109:
  vias: v2(156.92,122.33) v2(157.56,122.33) v3(157.48,123.1)
N29435333: length 5.7
  TOP w0.254: PR595.2 124.1,126.82 PR596.1 124.47,125.77 v2(124.85,125.39)
  TOP w0.508: PR593.1 v2(122.44,129.77)
  BOTTOM w0.254: v2(124.85,125.39) 124.92,125.46 PL506.2
  vias: v1(121.16,129.5)
N29435335: length 0.8
  TOP w0.114: 151.67,122.72 v1(150.85,122.72)
N29436554: length 5.4
  TOP w0.254: v2(117.3,125.65) 117.26,125.69 PR587.1 116.65,126.16 PR586.2
  TOP w0.508: PR584.1 v2(114.76,129.58)
  BOTTOM w0.254: PL505.2 v2(117.3,125.65)
  vias: v1(112.66,128.68)
N29436709: length 3.2
  TOP w0.114: v1(125.11,130.01) PR593.2
  TOP w0.508: PR593.2 PC580.1
N29436789: length 3.5
  TOP w0.114: PR584.2 117.42,129.19 v1(116.73,129.88)
  TOP w0.508: PC570.1 117.42,126.79 PR584.2
N29438561: length 2
  BOTTOM w0.203: PR512.2 93.33,128.79 PU500.43
N29438565: length 1.9
  BOTTOM w0.203: PR510.2 92.93,128.38 PU500.44
N29438567: length 2.8
  TOP w0.114: v1(92.8,127.14) 92.89,127.05 v2(92.89,126.64) 92.88,126.63 PR502.2
  BOTTOM w0.114: PR509.1 v2(92.89,126.64) PR510.1
N29438569: length 3.2
  TOP w0.114: PR501.2 91.99,126.38 v2(91.68,126.69) 91.68,126.94 v1(91.47,127.15)
  BOTTOM w0.114: PR507.1 91.68,126.24 v2(91.68,126.69) 91.68,127.11 PR508.1
N29438571: length 2.1
  BOTTOM w0.203: PR508.2 92,128.73 92.53,129.26 PU500.45
N29438583: length 3.6
  TOP w0.114: v1(94.71,125.92) PR503.2 93.77,126.31 v2(94.09,126.64)
  BOTTOM w0.114: PR511.1 93.78,126.32 v2(94.09,126.64) 94.09,127.11 PR512.1
N29438934: length 2.3
  BOTTOM w0.203: PU500.46 92.13,129.35 PR504.2
N29599145: length 2.2
  BOTTOM w0.114: v1(85.61,130.41) PR522.2
  BOTTOM w0.254: PR522.2 PC507.1
N29808551: length 2.4
  TOP w0.114: v2(108.17,150.58) v1(107.42,150.58)
  BOTTOM w0.114: RM100.2 108.27,150.58 v2(108.17,150.58) 107.99,150.4 UM8.49
N29808553: length 1.5
  BOTTOM w0.114: RM99.2 108.57,150.2 108.28,149.9 UM8.50
N30070819: length 2.2
  TOP w0.089: v2(234.25,93.95) 234.32,93.88 RG131.1 v1(234.89,92.94)
  BOTTOM w0.089: UG6.J13 234.64,94.35 v2(234.25,93.95)
N30070822: length 2
  TOP w0.089: v1(234.6,104.09) v2(234.6,104.6) 234.52,104.68 RG127.1
  BOTTOM w0.254: UG6.J1 234.65,104.55 v2(234.6,104.6)
N30070830: length 1.2
  TOP w0.089: v2(234.6,97.3) 234.6,97.92 RG129.1
  BOTTOM w0.254: v2(234.6,97.3) 234.65,97.25 UG6.J10
N30306722: length 3.3
  BOTTOM w0.114: RM28.1 CM99.1 RM29.1 85.38,154.18 v1(85.37,154.19)
N30306724: length 3.6
  BOTTOM w0.114: v1(90.4,154.47) 90.11,154.18 RM38.1 CM98.1 RM27.1
N30306755: length 4.5
  BOTTOM w0.114: UM4.20 92.07,151.89 CM17.1 CM16.1 RM18.2 93.86,151.16 v1(93.65,150.95)
N30306794: length 3.8
  BOTTOM w0.114: UM4.18 90.77,151.87 RM25.2 91.39,152.54 v1(91.39,153.67)
N30306843: length 1.8
  BOTTOM w0.114: UM4.13 87.52,151.69 RM28.2
N30306845: length 1.8
  BOTTOM w0.114: RM27.2 88.17,151.74 UM4.14
N30314421: length 1.3
  BOTTOM w0.114: UG12.12 194.98,73.59 CG64.1
N30314423: length 1.3
  BOTTOM w0.114: UG12.10 194.18,73.56 CG65.1
N30316795: length 7.5
  TOP w0.114: QG502.6 185.74,61.03 185.33,60.63 185.06,60.63 184.25,59.82 183.95,59.82 183.28,60.49 ; 183.28,60.49 183.4,60.61 183.4,61.17 183.26,61.31 183.26,61.38 183.02,61.62 UG22.2 ; 183.28,60.49 182.63,60.49 RG516.2 182.39,60.03 v1(182.96,59.46)
N30317275: length 2.6
  TOP w0.089: RG546.2 189.5,79.64 189.5,80.61 189.37,80.74 UG23.3 UG23.2
N30319723: length 114.6
  TOP w0.089: v2(182.32,55.08) 182.45,55.08 v1(182.89,54.63)
  TOP w0.114: DG6.2 181.83,57.8 RG550.2 182.31,56.77 CG443.1 181.88,55.93 181.88,55.27 182.07,55.08 v2(182.32,55.08) ; v2(88.98,65.24) 89.1,65.24 89.49,64.86 89.49,63.99 89.82,63.65 90.31,63.65 90.57,63.91 UG28.2
  IN2 w0.097: v2(88.98,65.24) 140.35,65.24 144.98,69.87 v2(146.06,69.87)
  IN3 w0.124: v2(182.32,55.08) 181.69,54.44 177.24,54.44 175.4,56.29 173.33,56.29 170.32,59.3 167.81,59.3 163.81,63.3 157.2,63.3 156.86,62.95 v2(156.86,62.83)
  IN5 w0.097: v2(156.86,62.83) 155.97,62.83 153.87,60.73 151.4,60.73 150.06,62.06 150.06,66.06 146.25,69.87 v2(146.06,69.87)
N30322028: length 3.6
  TOP w0.114: v1(179.25,62.69) 179.01,62.44 RG509.2 178.26,62.37 QG503.5 178.26,61.11 178,60.86 177.74,60.86 177.61,60.98 QG503.6
N30322035: length 2.3
  TOP w0.114: v1(180.1,59.78) 179.85,59.53 QG503.3 178.91,58.76 RG510.2
N30322061: length 2.5
  TOP w0.114: RG511.2 175.46,62.37 QG504.5 175.46,61.05 175.39,60.97 174.91,60.97 174.81,61.06 QG504.6
N30322074: length 2.2
  TOP w0.114: QG504.3 176.11,58.99 176.13,58.98 176.13,58.96 176.49,58.6 RG512.2 176.98,58.09 v1(176.98,57.7)
N30322100: length 3.7
  TOP w0.114: v1(173.59,62.44) RG513.2 172.68,61.95 172.67,61.94 QG505.5 172.67,60.92 172.54,60.79 172.16,60.79 172.02,60.94 QG505.6
N30322113: length 2.4
  TOP w0.114: v1(174.1,58.14) 173.38,58.14 173,58.52 RG514.2 173.32,58.85 QG505.3
N30322153: length 4.7
  TOP w0.114: RG541.2 189.1,48.53 189.84,49.26 189.84,49.9 190.2,50.25 QG507.5 QG507.6 190.64,51.96 v1(190.9,52.22)
N30322159: length 6.1
  TOP w0.114: v1(187.67,44.94) 188.33,44.94 RG542.2 188.83,47.12 188.32,47.62 188.32,49.47 188.45,49.6 QG507.3
N30322217: length 3
  TOP w0.114: QG509.6 QG509.5 221.45,29.63 RG543.2 221.45,31.19 v1(221.06,31.58)
N30322223: length 2.7
  TOP w0.114: RG544.2 221.07,25.82 v1(221.69,26.44) 221.97,26.72 QG509.3
N30365509: length 2.8
  TOP w0.114: QG502.5 186.46,61.68 186.58,61.56 186.58,60.86 186.27,60.54 185.88,60.54 185.59,60.25 RG554.2
N30365512: length 9.7
  TOP w0.114: RG554.1 186.17,60.06 186.8,60.69 186.8,62.41 185.88,63.33 v1(184.8,63.33) 184.35,63.33 184.01,63.68 182.64,63.68 181.24,62.27 UG22.4
N30365520: length 6.3
  TOP w0.114: QG502.2 188.29,61.68 188.42,61.56 188.42,60.79 188.16,60.54 188.16,58.32 188.04,58.19 v1(187.91,58.19) 187.85,58.19 187.66,58.38 187.34,58.38 187.28,58.32 187.28,58.19 187.91,57.56 RG553.2
N30373122: length 2.6
  TOP w0.114: v3(97.26,69.28) RG545.1 97.26,67.84 96.8,67.39 UG26.4
N30712936: length 3.2
  TOP w0.114: v1(54.64,38.38) PR727.1
  TOP w0.203: PR727.1 55.93,36.13 PU700.15
N30746783: length 5.5
  TOP w0.114: v1(58.18,45.3) 58.37,45.49 58.37,46.95 59.25,47.83 PR210.2
  TOP w0.203: PU201.10 59.44,49.93 59.21,49.69 59.21,48.45 59.25,48.41 PR210.2
N31077401: length 4.5
  TOP w0.114: v1(93.17,70.32) 92.91,70.32 92.85,70.26 90.61,70.26 PQ710.3
  TOP w0.254: PQ710.3 89.93,70.66 89.36,71.23 PR732.2
N31077403: length 3.9
  TOP w0.114: PR729.1 v1(94.07,72.17)
  TOP w0.254: PR730.2 92.19,72.6 92.11,72.52 PQ710.6 ; PQ710.6 92.56,71.96 92.78,72.17 PR729.1 ; PQ710.6 PQ710.5
N31077444: length 3.7
  TOP w0.114: v1(89.13,73.13) PC724.1
  TOP w0.254: PR731.2 88.22,71.27 PC724.1 89.99,71.31 PQ710.2
N31195648: length 2.9
  TOP w0.203: PR8219.2 254.82,58.75 254.2,58.75 v1(254.12,58.84) 254.12,59.7 254.22,59.81 PU8200.4
N31245253: length 1.4
  TOP w0.114: PR8221.2 262.31,62.8 v1(262.71,63.21)
N31306212: length 2.2
  BOTTOM w0.254: PR5006.2 153.43,130.46 153.43,129.77 153.62,129.58 153.99,129.58 154.12,129.46 PU511.1
N31395965: length 3.2
  TOP w0.114: v1(47.17,49.99) PR726.1
  TOP w0.508: PQ707.4 49.09,48.4 48.07,49.42 PR726.1
N31397225: length 4
  BOTTOM w0.114: PR725.1 48.08,42.89 v1(48.27,42.7)
  BOTTOM w0.508: PQ701.4 48.77,44.59 47.33,43.15 PR725.1
N31412307: length 4.3
  BOTTOM w0.114: PR5007.2 95,110.18 v1(95.28,110.46)
  BOTTOM w0.254: PU509.11 94.95,107.67 PC590.1 PR5008.1 PR5007.2
N31413382: length 0.6
  BOTTOM w0.114: 88.69,102.88 v1(88.69,102.32)
N31426895: length 1
  BOTTOM w0.114: v1(131.32,139.39) 131.78,138.94 131.78,138.61
N31426902: length 2.6
  BOTTOM w0.114: v1(128.34,137.08) PR552.2
  BOTTOM w0.254: PU502.1 129.76,135.85 129.54,136.08 129.54,136.33 129.28,136.59 PR552.2
N31426905: length 1.6
  BOTTOM w0.254: PU502.2 130.26,136.05 130.04,136.27 130.04,136.96 PR556.2
N31426910: length 3.5
  TOP w0.114: v1(127.7,133.22) 127.94,133.46 v2(128.16,133.46)
  TOP w0.254: v2(128.16,133.46) 128.58,133.03 PR5028.2 128.99,132.21 PC5005.1
  BOTTOM w0.254: v2(128.16,133.46) 128.57,133.87 PU502.24
N31427446: length 3.2
  TOP w0.114: v2(130.63,136.44) v1(130.63,137.24)
  TOP w0.254: PC540.2 130.52,136.33 v2(130.63,136.44)
  BOTTOM w0.254: PU502.3 130.76,136.28 130.63,136.42 v2(130.63,136.44) 130.63,136.57 131.06,137 PR553.1
N31432086: length 0.9
  BOTTOM w0.114: 142.22,138.42 v1(143.08,138.42)
N31432114: length 1
  BOTTOM w0.114: 142.29,137.11 v1(143.25,137.11)
N31436402: length 1.6
  BOTTOM w0.254: PU503.2 138.79,136 138.57,136.22 138.57,136.85 PR566.2
N31436405: length 2.5
  BOTTOM w0.114: v1(136.88,136.98) PR563.2
  BOTTOM w0.254: PR563.2 137.81,136.34 138.29,135.86 PU503.1
N31436410: length 1
  BOTTOM w0.114: 150.09,138.4 v1(151.07,138.4)
N31436414: length 0.9
  BOTTOM w0.114: 150.18,137.06 v1(151.11,137.06)
N31436415: length 1.6
  BOTTOM w0.254: PU504.2 146.75,136.02 146.53,136.24 146.53,136.93 PR576.2
N31438582: length 3.4
  TOP w0.114: v2(144.67,133.39) 144.45,133.39 v1(144.2,133.15)
  TOP w0.254: PC5007.1 145.45,132.29 PR5030.2 144.97,133.09 v2(144.67,133.39)
  BOTTOM w0.254: v2(144.67,133.39) 145.12,133.85 PU504.24
N31438896: length 3.1
  TOP w0.114: v2(147.08,136.38) v1(147.08,136.89)
  TOP w0.254: v2(147.08,136.38) 146.62,135.92 PC557.2
  BOTTOM w0.254: PU504.3 147.25,136.21 v2(147.08,136.38) 147.08,136.51 147.54,136.97 PR5020.1
N31439632: length 0.9
  BOTTOM w0.114: 117.27,138.56 v1(118.18,138.56)
N31439658: length 0.9
  BOTTOM w0.114: 117.27,137.11 v1(118.21,137.11)
N31439736: length 1.5
  BOTTOM w0.254: PR585.2 113.71,136.17 113.8,136.08 PU507.2
N31439790: length 2.6
  BOTTOM w0.114: v1(111.86,137.02) PR590.2
  BOTTOM w0.254: PU507.1 113.3,136.53 112.82,137.01 PR590.2
N31442956: length 3.2
  TOP w0.114: v2(114.17,136.35) v1(114.17,137.15)
  TOP w0.254: PC566.2 114.08,136.26 v2(114.17,136.35)
  BOTTOM w0.254: PU507.3 114.3,136.22 v2(114.17,136.35) 114.17,136.59 114.6,137.01 PR5022.1
N31442990: length 5
  TOP w0.254: PC5008.1 112.54,132.19 PR5031.2 112.45,133.12 112.4,133.12 112.02,133.5 112.02,133.62 111.87,133.77 111.26,133.77 v1(111.25,133.77) 111.08,133.95 v2(111.08,134.33)
  BOTTOM w0.254: v2(111.08,134.33) 111.08,134.14 111.4,133.81 PU507.24
N31443441: length 3.1
  TOP w0.114: v2(139.14,136.38) v1(139.14,137.1)
  TOP w0.254: v2(139.14,136.38) 138.96,136.2 PC549.2
  BOTTOM w0.254: PR5004.1 139.59,136.89 139.14,136.44 v2(139.14,136.38) 139.29,136.23 PU503.3
N31452288: length 0.8
  BOTTOM w0.114: 125.62,138.63 v1(126.44,138.63)
N31452290: length 0.8
  BOTTOM w0.114: 125.64,137.18 v1(126.46,137.18)
N31459506: length 3.3
  TOP w0.114: v2(122.51,136.49) 122.51,136.55 122.5,136.55 122.5,137.16 v1(122.43,137.24)
  TOP w0.254: v2(122.51,136.49) 122.51,136.45 122.38,136.33 PC573.2
  BOTTOM w0.254: PU510.3 122.64,136.31 122.51,136.44 v2(122.51,136.49) 122.51,136.55 122.93,136.97 PR5024.1
N31460044: length 3.4
  TOP w0.114: v2(120.03,133.46) 119.85,133.46 v1(119.59,133.2)
  TOP w0.254: v2(120.03,133.46) 120.34,133.15 PR5032.2 PC5009.1
  BOTTOM w0.254: v2(120.03,133.46) 120.47,133.9 PU510.24
N31466143: length 23.8
  TOP w0.254: v2(52.98,35.13) PR733.1
  TOP w0.508: PC725.1 v2(65.04,21.63)
  IN5 w0.254: v2(65.04,21.63) 63.7,22.96 63.7,29.99 61.19,32.5 60.86,32.5 60.04,33.32 57.08,33.32 55.49,34.91 53.2,34.91 v2(52.98,35.13)
N31494164:
  vias: v1(156.92,131.98)
N31494209:
  vias: v1(158.18,129.28)
N31494627: length 2.7
  BOTTOM w0.254: PR5001.1 152.86,128.63 153.07,128.41 PU511.12
N31495785: length 3.6
  TOP w0.114: v2(154,130.09) v1(153.59,130.51)
  TOP w0.254: v2(154,130.09) 153.75,129.84 PC588.2
  BOTTOM w0.254: PR5025.1 154.63,130.73 v2(154,130.09) 154.06,130.09 154.62,129.54 PU511.2
N31495969: length 3.7
  TOP w0.114: v1(152.29,126.83) 152.35,126.9 152.35,127.43 v2(152.54,127.62)
  TOP w0.254: PC5002.2 153.28,127.38 152.77,127.38 v2(152.54,127.62) 152.86,127.93 PR5026.2
  BOTTOM w0.254: PU511.11 152.84,127.91 v2(152.54,127.62)
N31535656: length 1.8
  BOTTOM w0.203: PU100.19 34.11,25.48 33.86,25.23 33.86,24.81 33.6,24.56 PR107.1
N31545452: length 8.9
  TOP w0.114: v2(177.16,76.9) v1(177.16,76.29)
  IN5 w0.097: v2(175.55,77.48) 176.58,77.48 v2(177.16,76.9)
  BOTTOM w0.114: v2(177.16,76.9) 178.26,78 180.68,78 181.1,78.42 UG9.BH1 ; RG556.1 v2(175.55,77.48)
N31545504: length 10.5
  TOP w0.114: v2(175.72,80.59) v1(175.19,80.59)
  IN1 w0.097: v2(182.1,81.45) 181.66,81.45 181.12,82 181.12,82.32 180.52,82.92 177.27,82.92 175.72,81.37 v2(175.72,80.59)
  BOTTOM w0.114: RG555.1 175.29,80.16 v2(175.72,80.59) ; UG9.BG4 181.81,81.75 v2(182.1,81.45)
N31565200: length 1.9
  TOP w0.114: v2(129.01,135.55) 129.01,135.92 v1(128.89,136.04)
  TOP w0.254: v2(129.01,135.55) 129.03,135.53 PR599.1
  BOTTOM w0.254: PU502.26 v2(129.01,135.55)
N31565645: length 1.9
  TOP w0.114: v1(137.49,136) 137.54,135.96 v2(137.54,135.49)
  TOP w0.254: PR5011.1 137.55,135.48 v2(137.54,135.49)
  BOTTOM w0.254: PU503.26 v2(137.54,135.49)
N31565698: length 3.4
  TOP w0.114: v2(136.66,133.46) v1(136.15,133.46)
  TOP w0.254: PC5006.1 137.5,132.21 PR5029.2 137.09,133.03 v2(136.66,133.46)
  BOTTOM w0.254: PU503.24 137.03,133.82 v2(136.66,133.46)
N31566286: length 2.5
  TOP w0.114: v2(145.74,135.52) 145.74,136.48 v1(145.77,136.51)
  TOP w0.254: PR5019.1 145.74,134.92 v2(145.74,135.52)
  BOTTOM w0.254: v2(145.74,135.52) 145.74,135.09 PU504.26
N31567454: length 1.8
  TOP w0.114: v2(112.56,135.48) v1(112.56,135.99)
  TOP w0.254: v2(112.56,135.48) 112.57,135.47 PR5021.1
  BOTTOM w0.254: PU507.26 v2(112.56,135.48)
N31567631: length 1.9
  TOP w0.114: v1(120.82,136.07) 120.89,136.01 v2(120.89,135.57)
  TOP w0.254: v2(120.89,135.57) 120.9,135.56 PR5023.1
  BOTTOM w0.254: PU510.26 v2(120.89,135.57)
N32111887: length 2.8
  TOP w0.203: PC8215.1 257.98,61.78 PR8208.1 256.83,62.06 255.98,62.06 255.87,62.18 PU8200.8
N32112416:
  vias: v1(234.06,59.84)
N32112456: length 1.1
  TOP w0.114: PC8219.1 v1(245.65,76.02)
N32519781: length 2.4
  BOTTOM w0.114: UG29.4 187.51,66.98 187.05,67.45 RG1.2
N32520109: length 2.6
  BOTTOM w0.114: QG510.2 184.86,68.03 RG1.1
N32576494: length 4.3
  BOTTOM w0.114: v1(175.85,14.09) 176.46,14.71 RE641.1 177,14.71 177.31,14.4 QE57.5 178.13,14.4 178.37,14.64 178.37,15.8 RE640.2
N32576646: length 3.4
  BOTTOM w0.114: QE57.3 180.07,13.75 180.46,14.13 v1(180.46,14.73) 180.46,15.2 RE639.2
N32910596: length 3.1
  TOP w0.089: v2(183.54,82.78) 183.02,82.27 RG564.1
  BOTTOM w0.114: UG9.BE5 v2(183.54,82.78)
N33138349: length 2.3
  TOP w0.114: v1(199.1,73.34) 198.78,73.02 v2(198.78,72.94)
  BOTTOM w0.114: RG65.2 198.54,72.94 v2(198.78,72.94) 199.19,73.34 UG11.5
N33204017: length 4.1
  BOTTOM w0.1: UG9.BD2 183.9,80.15
  BOTTOM w0.114: 183.9,80.15 184.23,79.82 184.23,78.47 183.93,78.17 RG566.1
N33413702: length 2.4
  TOP w0.114: RE651.1 169.83,166.62 170.12,166.32 170.12,165.66 169.92,165.45 UE7.3
N33479859: length 10.8
  TOP w0.114: v1(125.57,149.11) 125.8,149.35 v2(125.8,149.66)
  IN5 w0.097: v2(125.8,149.66) 126.27,149.19 127.69,149.19 128.36,149.86 132.97,149.86 v2(133.4,150.29)
  BOTTOM w0.089: UT4.D6 126.05,149.91 v2(125.8,149.66)
  BOTTOM w0.114: RT108.1 132.72,149.59 RT109.2 133.32,150.21 v2(133.4,150.29)
N33792732: length 3.4
  BOTTOM w0.114: UL2.3 193.99,150.13 RL5.1 193.36,148.93 193.45,149.02 193.94,149.02 v1(194.06,148.91)
N33792861: length 2.5
  TOP w0.114: RE20.1 v1(78.82,2.13)
  TOP w0.254: UE9.3 77.62,1.89 RE20.1
N34045293: length 2.5
  BOTTOM w0.114: UM8.27 96.01,151.9 RM72.2 v1(95.75,153.03)
N34045300: length 3.4
  TOP w0.114: v2(108.15,151.21) v1(108.88,151.21)
  BOTTOM w0.114: RM66.1 RM64.1 108.66,151.83 108.66,151.78 108.15,151.27 v2(108.15,151.21) 107.85,150.9 UM8.48
N35007428: length 1.5
  BOTTOM w0.114: UM4.4 90.12,143.02 RM20.2
N36403640: length 4.2
  BOTTOM w0.114: QM1.2 126.64,160.16 RM92.2 127.97,159.72 128.26,160.01 ; QM2.6 128.26,160.01 ; 128.26,160.01 128.26,159.68 v1(128.59,159.35)
N36403695: length 7.5
  BOTTOM w0.114: v1(129.81,163.08) 129.81,162.66 129.56,162.41 QM2.3 133.1,162.13 133.29,161.94 QM3.2 133.29,159.56 RM94.2
N37551658: length 2.7
  BOTTOM w0.114: v1(109.69,147.84) 109.36,147.84 RM61.2 108.3,148.9 UM8.52
N39829069: length 13.9
  BOTTOM w0.254: U2407.7 72.53,64.02 72.53,64.54 72.21,64.86 v1(72.21,65.56) 72.59,65.94 75.39,65.94 76.25,65.08 76.25,64.57 72.41,60.74 R181.2
N39831434: length 2.5
  BOTTOM w0.114: C3.1 v1(98.52,93.94)
  BOTTOM w0.127: UZ21.6 98.58,91.99 98.66,92.07 98.66,92.42 98.52,92.57 C3.1
N41521526: length 8
  TOP w0.114: QE2.2 83.02,23.48 83.97,23.48 CE51.1 84.14,22.58 v1(83.24,21.68) 82.82,21.25 82.82,19.01 83.39,18.44 RE85.1
N45888836: length 3.1
  TOP w0.114: UU1.16 17.53,48.22 RU3.2 17.21,47.79 16.6,47.17 16.6,47.14 v1(16.23,46.77)
N45888842: length 2.7
  TOP w0.114: v1(16.27,48.06) 16.39,48.06 17.1,48.77 RU2.2 17.26,48.72 UU1.15
N45888957: length 2.5
  TOP w0.114: v1(23.04,49.11) RU7.2 22.71,49.72 UU1.8
N45888961: length 2.6
  TOP w0.114: UU1.4 20.88,46.37 RU1.2 21.2,45.28 v1(21.36,45.12)
N45889254: length 6.8
  TOP w0.381: CU27.1 68.65,60.09 UU5.2
  TOP w0.508: CU27.1 69.61,59.12 RU5.2 70.64,58.52 71.15,58.52 v1(71.29,58.66) 71.64,59.02 71.64,60.42 DU8.2
N46084233: length 2.4
  BOTTOM w0.114: RX2.1 197.37,159.44 QX2.2 197.89,158.98 v1(198.35,158.52)
N59110666: length 3.1
  TOP w0.114: UE5.2 89.07,4.48 88.85,4.25 RE646.1 88.05,3.55 v1(88.03,3.58)
N72585933: length 0.8
  TOP w0.114: 74.13,46.42 v1(74.13,45.63)
N83720760: length 4.3
  TOP w0.254: v2(207.09,31.2) 206.95,31.35 v1(206.95,32.64) 207.36,33.05 PC6210.2
  BOTTOM w0.254: PR6210.1 207.21,31.08 v2(207.09,31.2)
