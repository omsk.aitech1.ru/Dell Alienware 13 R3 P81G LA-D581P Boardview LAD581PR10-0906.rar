# Allegro board LAD581PR10-0906.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 159.46,120.93 159.46,118.13 159.27,117.94 155.72,117.94 155.4,118.26 155.4,120.67 155.78,121.06 159.34,121.06
GND on TOP (solid shape): 161.69,8.47 161.69,1.1 161.43,0.85 155.27,0.85 155.14,0.98 155.14,8.28 156.22,9.36 160.8,9.36
GND on TOP (solid shape): 191.49,84.92 191.49,83.93 191.05,83.49 190.36,83.49 190.3,83.55 190.3,84.95 190.39,85.04 191.38,85.04
GND on TOP (solid shape): 195.52,85.09 195.52,82.7 195.33,82.51 194.07,82.51 193.92,82.66 193.92,85.37 194.02,85.47 195.14,85.47
GND on TOP (solid shape): 201.44,56.6 201.44,54 201.31,53.87 198.52,53.87 198.39,54 198.39,56.41 198.83,56.86 201.18,56.86
GND on TOP (solid shape): 222.39,56.79 222.39,54.19 222.26,54.06 219.47,54.06 219.34,54.19 219.34,56.6 219.79,57.05 222.14,57.05
GND on TOP (solid shape): 223.95,8.41 223.95,1.04 223.69,0.79 217.53,0.79 217.41,0.91 217.41,8.22 218.49,9.3 223.06,9.3
GND on TOP (solid shape): 201.31,32.22 201.31,30.57 200.99,30.25 199.21,30.25 199.02,30.44 199.02,32.16 199.2,32.33 201.19,32.33
GND on TOP (solid shape): 44.02,21.25 44.02,20.49 43.83,20.3 43.51,20.3 43.19,20.62 42.37,20.62 42.3,20.68 42.3,21.38 42.37,21.44 43.83,21.44
GND on TOP (solid shape): 54.3,27.86 54.3,25.25 54.62,24.94 54.62,23.92 54.5,23.79 52.97,23.79 52.84,23.92 52.84,27.86 52.97,27.98 54.18,27.98
GND on TOP (solid shape): 89.86,106.85 89.86,105.77 89.67,105.58 87.83,105.58 87.71,105.71 87.71,106.85 87.9,107.04 89.67,107.04
GND on TOP (solid shape): 130,120.55 130,118.52 129.57,118.09 125.68,118.09 125.55,118.22 125.55,121.01 125.62,121.07 129.47,121.07
GND on TOP (solid shape): 140.29,120.8 140.29,119.02 139.52,118.26 136.67,118.26 136.6,118.32 136.6,120.99 136.67,121.06 140.03,121.06
GND on TOP (solid shape): 206.26,56.79 206.26,53.75 206.14,53.62 203.09,53.62 202.9,53.81 202.9,56.79 203.34,57.24 205.82,57.24
GND on TOP (solid shape): 214.26,32.08 214.26,30.44 214.01,30.19 212.1,30.19 211.98,30.31 211.98,32.08 212.08,32.18 214.16,32.18
GND on TOP (solid shape): 244.3,59.27 244.3,56.35 244.04,56.09 244.04,54.51 243.92,54.38 242.97,54.38 242.77,54.57 242.77,59.33 242.9,59.46 244.11,59.46
GND on TOP (solid shape): 292.43,63.33 292.88,63.33 292.94,63.27 292.94,62.44 292.88,62.38 291.1,62.38 290.91,62.57 290.91,63.71 291.1,63.91 291.86,63.91
GND on TOP (solid shape): 59.38,28.36 59.38,25.82 58.88,25.32 57.54,25.32 57.35,25.51 57.35,27.92 57.35,27.92 57.35,28.03 57.19,28.19 57.19,28.84 57.41,29.06 58.69,29.06
GND on TOP (solid shape): 60.78,56.11 60.78,54.72 60.53,54.46 60.53,53.96 60.02,53.96 59.89,53.83 59.89,53.45 59.77,53.32 58.88,53.32 58.75,53.45 58.75,55.73 59.26,56.24 60.65,56.24
GND on TOP (solid shape): 71.96,48.66 71.96,47.67 72.28,47.35 73.23,47.35 73.48,47.1 73.48,44.11 72.97,43.6 70.5,43.6 70.18,43.92 70.18,48.62 70.34,48.78 71.84,48.78
GND on TOP (solid shape): 157.61,43.26 157.61,38.51 157.36,38.26 156.48,38.26 155.6,39.14 155.34,39.14 155.21,39.27 155.21,41.84 155.21,41.84 155.21,43 155.53,43.32 157.55,43.32
GND on TOP (solid shape): 183.08,94.87 183.08,94.44 183.31,94.21 183.59,94.21 183.76,94.04 183.76,93.85 183.64,93.74 182.84,93.74 182.53,94.06 179.27,94.06 179.17,94.16 179.17,94.82 179.34,94.98 182.97,94.98
GND on TOP (solid shape): 240.49,71.91 240.49,68.73 240.36,68.6 239.54,68.6 238.36,67.43 238.36,61.65 238.27,61.56 235.85,61.56 235.54,61.87 235.54,70.51 237,71.97 240.43,71.97
GND on TOP (solid shape): 301.83,38.89 302.53,38.89 302.97,38.44 302.97,37.81 302.78,37.62 301.89,37.62 301.64,37.36 298.91,37.36 298.72,37.55 298.72,39.01 298.85,39.14 301.58,39.14
GND on TOP (solid shape): 51.39,33.12 51.39,30.25 51.2,30.06 49.15,30.06 49.1,30.11 49.1,31.41 49.19,31.5 49.96,31.5 50.18,31.72 50.18,33.22 50.22,33.27 51.23,33.27
GND on TOP (solid shape): 169.86,154.96 169.88,154.94 169.88,154.77 170.19,154.46 170.19,154.08 170.13,154.01 169.81,154.01 169.75,154.08 168.04,154.08 167.72,154.39 167.72,155.22 167.78,155.28 169.86,155.28
GND on TOP (solid shape): 61.81,49.57 61.81,48.73 62.56,47.98 62.56,47.76 62.45,47.65 62.23,47.65 62.07,47.81 62.07,47.94 61.93,48.08 61.75,48.08 61.63,48.2 61.63,48.55 61.6,48.59 61.6,49.57 61.65,49.62 61.76,49.62
GND on TOP (solid shape): 147.33,166.26 147.33,164.35 146.68,163.69 146.68,163.22 145.18,163.22 145.18,164.31 145.22,164.36 145.59,164.36 145.85,164.62 145.85,166.05 146.26,166.45 147.14,166.45
GND on TOP (solid shape): 158.06,159.26 158.06,158.91 158.18,158.79 158.78,158.79 158.83,158.74 158.83,158.22 158.67,158.07 158.17,158.07 158.04,157.94 158.04,157.45 158.03,157.44 157.64,157.44 157.52,157.56 157.52,159.25 157.63,159.37 157.96,159.37
GND on TOP (solid shape): 23.19,28.15 23.19,27.81 23.34,27.66 23.4,27.66 23.4,27.65 23.52,27.65 23.57,27.6 23.57,27.1 23.53,27.06 22.14,27.06 22.11,27.09 22.11,27.62 22.14,27.65 22.54,27.65 22.75,27.85 22.75,28.14 22.86,28.26 23.09,28.26
GND on TOP (solid shape): 128.8,96.88 128.8,95.61 128.74,95.54 127.72,95.54 127.53,95.35 127.53,93.95 127.4,93.83 126.58,93.83 126.52,93.89 126.52,95.22 126.64,95.35 126.96,95.35 127.02,95.41 127.05,95.41 127.05,95.44 127.21,95.61 127.21,96.94 127.34,97.07 128.61,97.07
GND on TOP (solid shape): 132.36,96.94 132.36,94.53 132.29,94.46 131.34,94.46 131.28,94.53 131.28,95.07 131.29,95.16 131.28,95.25 131.28,95.35 131.09,95.54 130.9,95.54 130.83,95.61 130.83,97 130.9,97.07 132.23,97.07
GND on TOP (solid shape): 125.18,96.94 125.18,95.25 125.17,95.16 125.18,95.07 125.18,93.8 125.21,93.8 125.56,93.45 125.56,93.07 125.5,93 124.61,93 124.48,93.13 124.48,96.88 124.61,97 125.12,97
GND on TOP (solid shape): 138.01,106.27 138.01,105.77 137.95,105.7 137.44,105.7 137.25,105.51 137.25,101.26 137.37,101.13 137.37,97.89 137.31,97.83 136.61,97.83 136.48,97.96 136.48,101.19 136.68,101.38 136.68,106.27 136.8,106.4 137.88,106.4
GND on TOP (solid shape): 26.3,13.55 26.3,13.32 26.56,13.06 27.13,13.06 27.38,12.81 27.95,12.81 28.08,12.68 28.08,11.98 28.08,11.98 28.08,11.78 27.97,11.67 25.03,11.67 24.84,11.86 24.84,12.65 24.93,12.74 25.43,12.74 25.69,13 25.69,13.47 25.82,13.6 26.25,13.6
GND on TOP (solid shape): 61.42,52.68 61.42,51.61 61.46,51.57 61.89,51.57 62,51.69 62,52.65 62.07,52.72 62.16,52.72 62.22,52.65 62.22,51.56 62.16,51.5 62.16,49.88 62.14,49.87 60.45,49.87 60.45,51.57 61.14,51.57 61.2,51.64 61.2,52.69 61.25,52.73 61.37,52.73
GND on TOP (solid shape): 64.83,67.47 64.83,67.37 64.94,67.37 65.03,67.28 65.04,67.26 65.04,64.54 61.95,61.45 60.17,61.45 59.89,61.73 59.89,63.02 60.15,63.27 62.69,63.27 64.4,64.98 64.4,67.53 64.47,67.59 64.72,67.59
GND on TOP (solid shape): 117.82,106.08 117.82,103.54 117.31,103.04 117.31,100.43 117.18,100.3 116.7,100.3 116.61,100.39 116.61,101.23 116.62,101.32 116.61,101.41 116.61,103.35 116.74,103.48 116.74,106.08 116.86,106.21 117.69,106.21
GND on TOP (solid shape): 19.27,26.78 19.27,25.83 19.39,25.71 20.38,25.71 20.46,25.62 20.46,25.12 20.35,25.01 19.86,25.01 19.78,24.93 19.78,24.93 19.61,24.76 19.61,24.76 18.91,24.06 17.64,24.06 17.54,24.15 17.54,24.48 17.66,24.6 18.29,24.6 18.58,24.89 18.58,26.8 18.67,26.88 19.17,26.88
GND on TOP (solid shape): 27.11,28.11 27.11,27.8 27.28,27.64 27.43,27.64 27.44,27.64 27.58,27.61 27.72,27.64 27.73,27.64 27.93,27.64 27.99,27.58 27.99,27.12 27.92,27.05 25.62,27.05 25.56,27.11 25.56,27.65 25.92,28.01 25.92,28.12 26.07,28.27 26.95,28.27
GND on TOP (solid shape): 125.05,106.91 125.05,106.78 124.86,106.59 124.86,103.92 124.99,103.8 125.31,103.8 125.5,103.61 125.5,101.04 125.12,100.66 125.12,99.84 125.01,99.73 124.76,99.73 124.64,99.85 124.64,100.86 124.78,101.01 124.78,101.85 124.29,102.34 124.29,106.91 124.42,107.04 124.93,107.04
GND on TOP (solid shape): 136.73,132.19 136.73,126.66 136.41,126.35 134.25,126.35 134.06,126.54 134.06,129.58 133.24,130.41 128.85,130.41 128.66,130.6 128.66,131.62 128.79,131.74 129.49,131.74 129.71,131.96 129.71,132.46 129.8,132.55 130.3,132.55 130.5,132.76 134.63,132.76 134.82,132.95 135.97,132.95
GND on TOP (solid shape): 45.09,34.35 45.09,32.55 45.03,32.49 45.03,28.81 44.59,28.36 44.59,27.6 43.51,26.52 41.22,26.52 41.1,26.65 41.1,28.05 40.78,28.36 39.95,28.36 39.83,28.49 39.83,30.46 41.16,31.79 41.67,31.79 41.92,32.05 41.92,32.81 41.99,32.87 42.99,32.87 43.16,33.04 43.16,34.22 43.41,34.47 44.97,34.47
GND on TOP (solid shape): 110.39,106.08 110.39,100.37 110.26,100.24 109.81,100.24 109.56,100.5 109.56,101.23 109.57,101.32 109.56,101.41 109.56,103.23 109.31,103.48 109.31,104.72 109.32,104.81 109.31,104.91 109.31,106.08 109.37,106.15 110.32,106.15
GND on TOP (solid shape): 144.73,136.63 144.73,135.96 144.7,135.93 143.15,135.93 142.93,135.71 139.64,135.71 139.52,135.59 139.52,133.97 139.39,133.84 138.63,133.84 138.12,134.35 138.12,135.55 138.19,135.62 138.88,135.62 139.37,136.1 139.41,136.15 139.6,136.33 139.6,137.33 139.68,137.41 143.95,137.41
GND on TOP (solid shape): 241.31,21.61 241.31,17.74 240.49,16.92 240.49,16.47 240.41,16.39 239.93,16.39 239.85,16.47 237.06,16.47 236.82,16.56 236.58,16.47 235.03,16.47 234.65,16.85 234.65,22.06 234.77,22.19 240.74,22.19
GND on TOP (solid shape): 120.29,106.02 120.29,103.1 119.72,102.53 119.72,100.3 119.66,100.24 119.21,100.24 119.09,100.37 119.09,101.23 119.1,101.32 119.09,101.41 119.09,103.29 119.21,103.42 119.21,104.78 119.23,104.88 119.21,104.97 119.21,106.15 120.17,106.15
GND on TOP (solid shape): 191.53,62.06 191.53,61.11 191.78,60.86 197.63,60.86 198.96,59.52 206.39,59.52 206.64,59.78 206.64,60.41 207.21,60.98 218.45,60.98 219.15,60.29 222.58,60.29 223.6,61.3 230.96,61.3 231.41,60.86 231.41,57.81 230.96,57.36 198.2,57.36 195.98,55.14 190.45,55.14 190.2,55.4 190.2,62.06 190.32,62.19 191.4,62.19
GND on TOP (solid shape): 298.18,59.55 298.18,58.74 298.29,58.63 298.57,58.63 298.59,58.64 299.36,58.64 299.61,58.4 303.87,58.4 304.11,58.16 304.11,55.64 303.38,54.91 298.91,54.91 298.4,55.42 298.4,57.07 298.14,57.32 297.7,57.32 297.28,57.74 297.28,59.3 297.58,59.59 298.15,59.59
GND on TOP (solid shape): 115.34,106.08 115.34,103.48 114.96,103.1 114.96,100.3 114.83,100.18 114.39,100.18 114.2,100.37 114.2,101.23 114.21,101.32 114.2,101.41 114.2,103.23 114.26,103.29 114.26,104.72 114.27,104.81 114.26,104.91 114.26,106.08 114.32,106.15 115.28,106.15
GND on TOP (solid shape): 127.64,132.95 127.7,132.94 127.77,132.95 127.84,132.95 128.28,132.5 128.28,125.2 128.09,125.01 126.12,125.01 125.74,125.39 125.74,129.77 125.11,130.41 120.73,130.41 120.54,130.6 120.54,131.62 120.66,131.74 121.36,131.74 121.56,131.94 121.56,132.46 121.73,132.63 122.16,132.63 122.33,132.8 126.55,132.8 126.69,132.95
GND on TOP (solid shape): 119.9,132.38 119.9,130.09 120.54,129.46 120.54,125.46 120.09,125.01 118.76,125.01 118.31,125.46 118.31,129.08 118.06,129.33 117.68,129.33 116.73,130.28 112.34,130.28 112.15,130.47 112.15,131.49 112.28,131.62 112.98,131.62 113.2,131.84 113.2,132.46 113.29,132.54 113.96,132.54 114.15,132.73 118.22,132.73 118.31,132.82 119.46,132.82
GND on TOP (solid shape): 112.86,106.08 112.86,103.42 112.67,103.23 112.67,100.37 112.61,100.3 112.04,100.3 111.78,100.56 111.78,101.11 111.86,101.32 111.78,101.53 111.78,104.72 111.8,104.81 111.78,104.91 111.78,106.08 111.85,106.15 112.8,106.15
GND on TOP (solid shape): 152.16,132.76 152.16,127.11 151.33,126.28 151.33,124.5 151.08,124.25 150.32,124.25 150.06,124.5 150.06,127.3 150.32,127.55 150.32,129.71 149.68,130.35 145.3,130.35 145.11,130.54 145.11,131.55 145.24,131.68 145.94,131.68 146.07,131.82 146.07,132.29 146.38,132.6 146.85,132.6 147.01,132.75 151.14,132.75 151.27,132.89 152.03,132.89
GND on TOP (solid shape): 133.85,136.95 136.02,136.95 136.26,136.71 136.26,135.98 136.17,135.9 134.73,135.9 134.62,135.78 131.28,135.78 131.15,135.66 131.15,133.87 131.06,133.77 130,133.77 129.55,134.22 129.55,135.62 129.62,135.68 130.34,135.68 130.78,136.12 130.88,136.19 130.95,136.29 131.16,136.49 131.16,137.2 131.34,137.38 133.42,137.38
GND on TOP (solid shape): 127.96,137.19 127.96,135.97 127.9,135.91 126.35,135.91 126.25,135.81 123.04,135.81 122.88,135.65 122.88,133.97 122.76,133.84 121.87,133.84 121.49,134.22 121.49,135.62 121.55,135.68 122.15,135.68 122.61,136.15 122.76,136.23 122.85,136.38 123.01,136.54 123.01,136.76 123.01,137.29 123.09,137.38 127.78,137.38
GND on TOP (solid shape): 144.09,132.89 144.2,132.87 144.3,132.89 144.54,132.89 144.98,132.44 144.98,125.46 144.47,124.95 142.38,124.95 142.19,125.14 142.19,127.36 142.44,127.62 142.44,129.71 141.81,130.35 137.43,130.35 137.24,130.54 137.24,131.55 137.36,131.68 138.06,131.68 138.14,131.76 138.14,132.3 138.39,132.55 138.93,132.55 139.11,132.73 143.24,132.73 143.4,132.89
GND on TOP (solid shape): 176.73,95.06 177.41,95.06 177.54,94.93 177.54,92.69 177.41,92.56 177.41,92.27 177.61,92.07 177.76,92.07 177.85,91.99 177.85,91.67 177.74,91.55 177.28,91.55 177.19,91.46 177.19,90.47 177.36,90.31 177.64,90.31 177.85,90.09 177.85,87.03 177.62,86.8 176.23,86.8 175.97,87.06 175.91,87.14 175.82,87.21 175.57,87.46 175.57,94.87 176.1,95.4 176.39,95.4
GND on TOP (solid shape): 119.82,136.84 119.82,135.93 119.75,135.86 118.31,135.86 118.12,135.66 116.65,135.66 116.51,135.8 114.78,135.8 114.67,135.69 114.67,133.95 114.49,133.77 113.68,133.77 113.11,134.35 113.11,135.49 113.23,135.62 113.9,135.62 114.31,136.02 114.42,136.1 114.5,136.22 114.54,136.25 114.54,137.12 114.76,137.35 119.31,137.35
GND on TOP (solid shape): 146.48,42.8 147.28,42.8 147.42,42.67 147.42,36.23 147.17,35.97 147.17,35.43 147.09,35.35 146.8,35.35 146.6,35.15 146.6,34.71 146.75,34.56 147.29,34.56 147.41,34.45 147.41,34.23 147.29,34.12 146.18,34.12 145.45,34.84 145.45,38.74 146.18,39.46 146.18,39.95 146.02,40.1 145.64,40.1 145.53,40.21 145.53,40.49 145.61,40.57 146.23,40.57 146.46,40.8 146.46,41.53 146.18,41.81 145.67,41.81 145.49,41.99 145.49,43.06 145.68,43.25 146.04,43.25
GND on TOP (solid shape): 132.17,106.85 132.17,106.62 132.17,106.59 132.1,106.53 132.1,103.86 132.17,103.8 132.55,103.8 132.74,103.61 132.74,101.07 132.45,100.78 132.42,100.78 132.42,100.75 132.36,100.69 132.36,99.86 132.29,99.8 131.4,99.8 131.34,99.86 131.34,100.75 131.02,101.07 131.02,105.16 131.04,105.26 131.02,105.35 131.02,106.53 130.96,106.59 130.96,106.62 130.93,106.62 130.77,106.78 130.77,106.97 130.9,107.1 131.91,107.1
GND on TOP (solid shape): 134.96,106.91 134.96,104.11 134.71,103.86 134.71,100.05 134.45,99.8 133.75,99.8 133.69,99.86 133.69,99.89 133.7,99.98 133.69,100.08 133.69,103.73 133.44,103.99 133.44,105.16 133.45,105.26 133.44,105.35 133.44,106.51 133.19,106.76 133.18,106.77 133.18,106.97 133.31,107.09 134.78,107.09
GND on TOP (solid shape): 142.52,166.83 142.52,166.77 142.8,166.49 142.95,166.49 142.96,166.49 143.62,166.49 143.78,166.34 143.78,163.09 143.59,162.9 143.59,162.26 144.02,161.82 144.02,160.92 144.28,160.66 144.28,160.4 144.41,160.27 144.66,160.27 144.73,160.2 144.73,160.01 144.66,159.95 144.08,159.95 143.41,160.62 143.41,160.87 142.34,161.94 142.34,162.01 142.31,162.04 140.98,162.04 140.98,162.62 140.83,162.77 138.77,162.77 138.26,163.29 138.26,165.69 138.39,165.82 139.16,165.82 140.19,166.85 142.49,166.85
GND on TOP (solid shape): 189.37,85.81 189.37,85.18 189.31,85.11 189.31,83.78 189.19,83.66 187.48,83.66 187.03,83.21 185.56,83.21 185.4,83.37 185.4,83.55 185.01,83.94 184.01,83.94 183.94,84 183.94,84.58 183.98,84.62 184.62,84.62 184.78,84.47 185.13,84.47 185.51,84.09 186.44,84.09 186.89,84.54 186.89,85.46 187.18,85.74 187.47,85.74 187.51,85.75 188.08,85.75 188.08,85.75 188.16,85.75 188.29,85.88 189.31,85.88
GND on TOP (solid shape): 152.41,136.82 153.21,136.82 153.33,136.71 153.33,136.15 153.23,136.05 151.59,136.05 151.38,135.85 151.38,135.63 151.31,135.56 149.84,135.56 149.62,135.78 148.1,135.78 148.1,135.78 147.97,135.78 147.83,135.65 147.83,135.02 147.62,134.81 147.62,134.43 147.64,134.4 147.64,134.17 147.62,134.13 147.62,134.02 147.43,133.84 146.46,133.84 146.25,134.06 146.25,134.72 146.7,135.18 146.83,135.18 147.15,135.5 147.15,135.93 148.04,136.82 148.04,137.3 148.11,137.36 151.87,137.36
GND on TOP (solid shape): 159.71,62.83 160.28,62.83 160.33,62.78 160.33,62.03 160.23,61.94 156.97,61.94 156.69,62.22 156.69,62.37 156.72,62.45 156.8,62.47 157.14,62.6 157.19,62.95 157.2,63.05 157.29,63.09 159.44,63.09
GND on TOP (solid shape): 114.49,122.6 116.62,122.6 117.74,123.72 119.33,123.72 119.46,123.6 119.46,122.01 119.22,121.77 117.55,121.77 117.36,121.58 117.36,121.27 117.17,121.07 114.59,121.07 114.48,121.19 114.48,121.56 114.3,121.74 113.87,121.74 113.68,121.55 113.68,121.22 113.53,121.07 112.96,121.07 112.78,121.26 112.78,121.6 112.63,121.75 112.04,121.75 111.86,121.58 111.86,121.16 111.77,121.07 111.26,121.07 111.07,121.27 111.07,121.58 110.88,121.77 110.38,121.77 110.37,121.76 108.59,121.76 108.09,122.26 108.09,123.85 108.41,124.17 112.92,124.17
GND on TOP (solid shape): 122.32,98.24 122.32,97.92 122.26,97.86 121.94,97.86 121.82,97.73 121.82,97.72 121.8,97.71 121.74,97.51 121.8,97.31 121.82,97.3 121.82,97.29 121.94,97.16 122.2,97.16 122.32,97.03 122.32,96.65 122.26,96.59 121.94,96.59 121.82,96.46 121.82,96.45 121.8,96.44 121.74,96.25 121.79,96.06 121.82,96.02 121.75,95.96 121.24,95.96 121.18,96.02 121.18,98.37 121.24,98.43 122.13,98.43
GND on TOP (solid shape): 110.83,98.21 110.83,97.89 110.77,97.83 110.73,97.83 110.64,97.84 110.55,97.83 110.45,97.83 110.32,97.7 110.32,97.6 110.31,97.51 110.32,97.42 110.32,97.26 110.45,97.13 110.7,97.13 110.83,97 110.83,96.62 110.77,96.56 110.73,96.56 110.64,96.57 110.55,96.56 110.45,96.56 110.32,96.43 110.32,96.33 110.31,96.24 110.32,96.15 110.32,95.99 110.26,95.92 109.75,95.92 109.69,95.99 109.69,98.34 109.75,98.4 110.64,98.4
GND on TOP (solid shape): 135.96,97.4 135.97,97.34 135.98,97.29 135.98,96.08 135.97,96.03 135.96,95.97 135.79,95.8 135.28,95.8 134.94,95.46 134.93,95.45 134.85,95.4 134.79,95.31 134.71,95.22 134.71,93.95 134.64,93.89 134.33,93.89 134.26,93.96 134.23,94.03 134.2,94.09 134.2,94.21 134.07,94.34 133.88,94.34 133.69,94.53 133.69,95.22 133.82,95.35 134.14,95.35 134.39,95.61 134.39,97.38 134.58,97.57 135.79,97.57
GND on TOP (solid shape): 199.56,152.74 199.62,152.69 199.68,152.66 199.8,152.54 199.8,152.13 199.79,152.12 199.79,151.95 199.93,151.82 202.93,151.82 203.4,151.34 203.4,149.44 203.09,149.12 203.09,148.23 203.15,148.17 203.72,148.17 203.85,148.04 203.85,147.41 203.24,146.8 203.16,146.8 203.16,146.72 202.96,146.52 202.96,146.14 202.83,146.01 202.2,146.01 201.75,146.46 200.15,146.46 199.43,145.73 198.74,145.73 198.64,145.83 198.64,146.46 198.32,146.77 198.32,147.03 198.45,147.15 198.83,147.15 199.28,147.6 199.28,147.85 198.7,148.42 198.7,150.05 198.71,150.06 198.71,151.06 198.81,151.06 198.81,151.77 199.02,151.98 199.02,152.61 199.15,152.74
GND on TOP (solid shape): 206.26,106.77 206.26,106.07 205.37,105.18 205.37,101.37 204.93,101.37 204.8,101.24 204.8,100.67 204.87,100.61 205.37,100.61 205.44,100.54 205.44,94.51 205.31,94.39 204.99,94.39 204.8,94.19 204.8,93.75 205.25,93.31 206.26,93.31 206.39,93.18 206.39,92.86 206.2,92.67 205.56,92.67 205.31,92.42 205.31,90.07 205.56,89.81 205.56,89.05 205.25,88.73 205.25,87.34 204.74,87.34 204.67,87.4 204.67,87.91 204.36,88.23 202.9,88.23 202.83,88.29 202.83,88.73 204.17,88.73 204.36,88.92 204.36,91.72 204.04,92.04 201.75,92.04 201.63,92.16 201.63,94.7 201.82,94.89 204.1,94.89 204.36,95.15 204.36,106.58 204.61,106.83 206.2,106.83
GND on TOP (solid shape): 155.9,132.37 155.9,128.95 155.97,128.89 155.97,124.74 156.16,124.55 157.24,124.55 157.43,124.74 157.43,126.98 157.56,127.11 158.64,127.11 158.65,127.1 160.28,127.1 160.42,126.96 160.42,124.93 159.46,123.98 152.73,123.98 152.48,123.72 152.48,123.6 152.36,123.48 151.71,123.48 151.59,123.6 151.59,126.16 152.02,126.59 152.15,126.59 152.29,126.55 152.43,126.59 153.55,126.59 153.81,126.85 153.81,127.49 153.71,127.59 153.71,127.74 153.3,128.14 153.3,128.63 153.49,128.82 154.06,128.82 154.38,129.14 154.38,130.6 155.03,131.25 155.03,132.35 155.09,132.41 155.87,132.41
GND on TOP (solid shape): 113.12,98.24 113.12,97.92 113.07,97.88 113.03,97.89 112.9,97.9 112.77,97.87 112.76,97.86 112.74,97.86 112.61,97.73 112.61,97.67 112.6,97.57 112.61,97.48 112.61,97.29 112.74,97.16 112.99,97.16 113.12,97.03 113.12,96.65 113.07,96.61 113.03,96.62 112.9,96.63 112.77,96.6 112.76,96.59 112.74,96.59 112.61,96.46 112.61,96.4 112.6,96.3 112.61,96.21 112.61,96.02 112.55,95.96 112.04,95.96 111.97,96.02 111.97,98.37 112.04,98.43 112.93,98.43
GND on TOP (solid shape): 117.69,98.24 117.69,97.92 117.64,97.88 117.6,97.89 117.47,97.9 117.34,97.87 117.33,97.86 117.31,97.86 117.18,97.73 117.18,97.67 117.17,97.57 117.18,97.48 117.18,97.29 117.31,97.16 117.56,97.16 117.69,97.03 117.69,96.65 117.64,96.61 117.6,96.62 117.47,96.63 117.34,96.6 117.33,96.59 117.31,96.59 117.18,96.46 117.18,96.4 117.17,96.3 117.18,96.21 117.18,96.02 117.12,95.96 116.61,95.96 116.55,96.02 116.55,98.37 116.61,98.43 117.5,98.43
GND on TOP (solid shape): 120.04,98.24 120.04,97.92 119.99,97.88 119.95,97.89 119.82,97.9 119.69,97.87 119.68,97.86 119.66,97.86 119.53,97.73 119.53,97.67 119.52,97.57 119.53,97.48 119.53,97.29 119.66,97.16 119.91,97.16 120.04,97.03 120.04,96.65 119.99,96.61 119.95,96.62 119.82,96.63 119.69,96.6 119.68,96.59 119.66,96.59 119.53,96.46 119.53,96.4 119.52,96.3 119.53,96.21 119.53,96.02 119.47,95.96 118.96,95.96 118.9,96.02 118.9,98.37 118.96,98.43 119.85,98.43
GND on TOP (solid shape): 25.03,25.16 25.03,23.67 25.16,23.54 26.24,23.54 26.41,23.71 26.41,25.15 26.48,25.22 26.96,25.22 27.01,25.17 27.01,23.66 27.13,23.54 28.21,23.54 28.21,18.9 27.95,18.9 27.83,18.78 27.83,17.28 27.76,17.22 27.28,17.22 27.19,17.3 27.19,18.78 27.06,18.9 24.84,18.9 24.62,18.69 24.62,17.26 24.55,17.19 24.08,17.19 24.02,17.25 24.02,18.52 23.63,18.9 23.63,21.44 23.36,21.72 21.61,21.72 20.99,21.11 20.56,21.11 20.5,21.17 20.5,21.74 20.53,21.77 20.95,21.77 21.52,22.34 23.45,22.34 23.58,22.47 23.58,23.52 23.6,23.54 24.65,23.54 24.8,23.69 24.8,25.16 24.87,25.23 24.96,25.23
GND on TOP (solid shape): 115.4,98.24 115.4,97.92 115.34,97.86 115.32,97.86 114.9,97.8 114.88,97.38 114.89,97.36 114.89,97.29 115.02,97.16 115.28,97.16 115.4,97.03 115.4,96.65 115.34,96.59 115.32,96.59 114.9,96.53 114.88,96.11 114.89,96.09 114.89,96.02 114.83,95.96 114.32,95.96 114.26,96.02 114.26,98.37 114.32,98.43 115.21,98.43
GND on TOP (solid shape): 122.71,106.08 122.71,104.69 122.96,104.43 122.96,102.84 122.83,102.72 122.83,99.23 122.71,99.1 122.13,99.1 122.07,99.16 122.07,99.2 122.08,99.28 122.07,99.38 122.07,99.48 121.88,99.67 121.63,99.67 121.5,99.8 121.5,100.05 121.56,100.11 121.88,100.11 122.07,100.3 122.07,100.47 122.08,100.56 122.07,100.65 122.07,100.75 121.94,100.88 121.85,100.88 121.75,100.89 121.66,100.88 121.63,100.88 121.5,101 121.5,101.32 121.63,101.45 121.94,101.45 122.07,101.57 122.07,101.8 122.08,101.89 122.07,101.99 122.07,102.08 121.88,102.27 121.63,102.27 121.5,102.4 121.5,102.59 121.63,102.72 121.63,103.13 121.64,103.23 121.63,103.32 121.63,106.08 121.69,106.15 122.64,106.15
GND on TOP (solid shape): 95.84,136.99 95.84,135.22 95.39,134.77 95.39,133.95 95.52,133.82 96.03,133.82 96.28,133.57 96.28,132.11 96.53,131.85 96.53,130.64 96.2,130.31 92.94,130.31 92.07,129.44 90.76,129.44 90.69,129.5 90.69,131.02 90.5,131.22 90.5,131.91 90.69,132.1 90.69,133.06 90.5,133.25 90.5,133.88 90.31,134.07 89.87,134.07 89.74,134.2 89.74,134.77 89.87,134.9 89.93,134.9 89.99,134.83 91.05,134.83 91.32,135.1 91.32,135.33 91.39,135.41 91.71,135.41 91.84,135.28 91.84,134.64 91.96,134.52 92.79,134.52 92.95,134.68 93.43,134.62 93.23,135.06 93.23,136.04 93.42,136.23 94.95,136.23 95.14,136.42 95.14,136.99 95.2,137.06 95.77,137.06
GND on TOP (solid shape): 129.69,107.45 129.69,103.99 129.56,103.86 129.44,103.86 129.37,103.8 129.35,103.8 129.35,103.77 129.25,103.67 129.25,100.94 129.37,100.81 129.88,100.81 129.99,100.71 129.99,99.9 129.85,99.76 128.99,99.76 128.88,99.87 128.88,99.97 128.87,100.04 128.86,100.08 128.86,100.75 128.74,100.88 127.7,100.88 127.57,100.75 127.57,99.9 127.47,99.8 127.46,99.8 127.41,99.74 126.61,99.74 126.47,99.88 126.47,100.7 126.52,100.75 127.15,100.75 127.28,100.88 127.28,102.02 127.4,102.15 127.4,103.61 127.02,103.99 126.2,103.99 126.2,105.16 126.21,105.26 126.2,105.35 126.2,106.46 126.26,106.53 126.35,106.53 126.64,106.53 126.83,106.72 126.83,106.97 126.96,107.1 127.21,107.1 127.31,107 127.31,105.04 127.28,105 127.28,103.99 127.34,103.92 127.34,103.9 127.37,103.9 127.4,103.86 128.48,103.86 128.52,103.9 128.55,103.9 128.55,103.92 128.61,103.99 128.61,105.16 128.62,105.26 128.61,105.35 128.61,106.59 128.42,106.78 128.42,106.97 128.55,107.1 128.96,107.1 129.06,107.21 129.06,107.51 129.32,107.77 129.37,107.77
GND on TOP (solid shape): 110.4,168.96 110.53,168.93 113.32,165.01 109.56,162.01 106.05,162.01 106.05,173.3 106.29,173.86 106.85,174.1 109.4,174.1 109.75,174.15 110.07,174.3 110.4,174.3
GND on TOP (solid shape): outline of 112 points within 176.29,85.42 189.36,110.65
GND on TOP (solid shape): 231.76,170.8 233.82,170.08 234.98,168.23 235.4,167.56 236.15,167.3 238.05,167.3 238.09,167.3 239.13,167.3 239.41,167.17 239.68,167.02 240.72,163.14 236.97,161.7 230.39,164.23 228.15,167.51 230.41,170.77 230.47,170.8 231.61,170.8
GND on TOP (solid shape): 144.95,157.6 145.02,157.57 145.05,157.5 145.08,157.35 145.2,157.25 145.24,157.24 145.24,157.05 145.2,157.04 145.04,156.82 145.2,156.6 145.24,156.59 145.24,156.4 145.2,156.39 145.04,156.17 145.2,155.95 145.24,155.94 145.24,155.75 145.2,155.74 145.04,155.52 145.2,155.3 145.24,155.29 145.24,155.1 145.21,155.09 145.04,154.87 145.2,154.65 145.24,154.64 145.24,154.45 145.2,154.44 145.04,154.22 145.21,154 145.24,153.99 145.24,153.8 145.2,153.79 145.1,153.72 145.05,153.62 145.04,153.57 145.01,153.5 144.94,153.47 144.54,153.47 144.47,153.54 144.47,153.82 144.56,153.91 144.58,153.91 144.8,154.15 144.57,154.37 144.5,154.4 144.47,154.47 144.47,154.74 144.56,154.83 144.58,154.83 144.8,155.07 144.57,155.29 144.5,155.32 144.47,155.39 144.47,155.66 144.56,155.75 144.58,155.75 144.8,155.99 144.57,156.21 144.5,156.24 144.47,156.31 144.47,156.58 144.56,156.67 144.58,156.67 144.8,156.91 144.57,157.13 144.5,157.16 144.47,157.23 144.47,157.48 144.58,157.59 144.61,157.59 144.65,157.6
GND on TOP (solid shape): outline of 264 points within 164.61,156.33 168.99,162.74
GND on TOP (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.24 205.75,168.24 205.67,168.32 205.08,168.18 204.53,168.43 197.52,168.43 196.72,168.19 196.03,168.68 191.09,168.68 191.06,168.71 190.2,167.59 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on TOP (solid shape): outline of 302 points within 146.77,108.88 154.91,113.24
GND on TOP (solid shape): outline of 143 points within 16.77,0.2 320.25,62.45
GND on TOP (solid shape): outline of 711 points within 176.35,108.61 189.24,116.48
GND on TOP (solid shape): outline of 809 points within 210.9,35.65 218.45,47.9
GND on TOP (solid shape): outline of 167 points within 226.85,65.89 319.75,176.3
GND on TOP (solid shape): outline of 1117 points within 1.45,51.84 177.1,178.6
GND on TOP (solid shape): outline of 1669 points within 194.51,35.52 207.48,48.79
GND on TOP (solid shape): outline of 1443 points within 145.78,150.78 154.45,160.29
GND on BOTTOM (solid shape): 240.87,147.79 239.6,147.79 239.22,148.17 239.22,153.06 239.28,153.12 240.87,153.12
GND on BOTTOM (solid shape): 47.76,21 47.76,18.27 47.57,18.08 44.97,18.08 44.59,18.46 44.59,20.74 44.97,21.13 47.64,21.13
GND on BOTTOM (solid shape): 101.23,128.14 101.23,125.39 101.1,125.27 97.74,125.27 97.55,125.46 97.55,126.92 98.82,128.19 101.18,128.19
GND on BOTTOM (solid shape): 157.94,151.47 157.94,149.76 157.81,149.63 156.67,149.63 156.29,150.01 156.29,151.92 156.35,151.98 157.43,151.98
GND on BOTTOM (solid shape): 166.21,9.27 166.21,7.3 165.97,7.06 161.32,7.06 161.15,7.23 161.15,9.05 161.46,9.36 166.12,9.36
GND on BOTTOM (solid shape): 179.4,121.56 179.4,119.72 179.08,119.4 174.64,119.4 174.26,119.79 174.26,121.25 174.77,121.75 179.21,121.75
GND on BOTTOM (solid shape): 190.31,48.18 190.31,43.1 190.2,42.99 188.62,42.99 188.46,43.15 188.46,48 188.8,48.35 190.15,48.35
GND on BOTTOM (solid shape): 204.61,70.51 204.61,68.22 204.42,68.03 203.6,68.03 203.4,68.22 203.4,70.45 203.6,70.64 204.48,70.64
GND on BOTTOM (solid shape): 205.12,15.73 205.12,14.52 204.99,14.39 203.66,14.39 203.59,14.46 203.59,15.79 203.66,15.86 204.99,15.86
GND on BOTTOM (solid shape): 210.32,35.07 210.32,33.84 210.26,33.78 207.05,33.78 206.93,33.9 206.93,35.12 207.07,35.27 210.13,35.27
GND on BOTTOM (solid shape): 220.3,72.41 220.3,69.49 220.11,69.3 216.93,69.3 216.74,69.49 216.74,72.16 217.18,72.6 220.11,72.6
GND on BOTTOM (solid shape): 222,50.13 222,49.2 221.56,48.76 220.77,48.76 220.44,49.09 220.44,50.11 220.51,50.19 221.93,50.19
GND on BOTTOM (solid shape): 233.81,150.27 233.81,147.03 233.69,146.91 233.24,146.91 233.12,147.03 233.12,150.27 233.24,150.4 233.69,150.4
GND on BOTTOM (solid shape): 236.36,136.55 236.36,134.64 235.98,134.26 232.36,134.26 232.23,134.39 232.23,136.87 232.3,136.93 235.98,136.93
GND on BOTTOM (solid shape): 67,44.08 67,35.83 66.5,35.32 65.12,35.32 64.39,36.05 64.39,44.08 64.52,44.21 66.88,44.21
GND on BOTTOM (solid shape): 56.18,66.13 56.18,64.55 56.04,64.41 53.85,64.41 53.77,64.48 53.77,65.14 54.05,65.42 54.51,65.42 55.35,66.26 56.06,66.26
GND on BOTTOM (solid shape): 93.93,123.74 93.93,120.88 93.67,120.63 90.75,120.63 90.56,120.82 90.56,123.42 90.88,123.74 91.26,123.74 91.52,124 93.67,124
GND on BOTTOM (solid shape): 104.87,118.77 104.87,115.97 104.79,115.89 101.68,115.89 101.21,116.36 101.21,118.44 101.67,118.9 104.74,118.9
GND on BOTTOM (solid shape): 110.69,123.93 110.69,123.42 110.06,122.79 110.06,120.69 109.93,120.57 107.52,120.57 107.45,120.63 107.45,123.42 108.22,124.19 110.44,124.19
GND on BOTTOM (solid shape): 163.4,18.82 163.4,16.95 163.18,16.73 162.23,16.73 161.42,17.54 161.42,18.77 161.68,19.03 163.19,19.03
GND on BOTTOM (solid shape): 244.3,59.21 244.3,56.35 243.98,56.03 243.98,54.44 243.79,54.25 242.97,54.25 242.77,54.44 242.77,59.27 242.9,59.4 244.11,59.4
GND on BOTTOM (solid shape): 247.47,92.35 247.47,91.46 247.22,91.21 246.14,91.21 245.89,90.96 244.81,90.96 244.68,91.08 244.68,92.42 244.87,92.61 247.22,92.61
GND on BOTTOM (solid shape): 56.77,54.59 56.77,53.6 56.5,53.33 54.73,53.33 54.62,53.44 54.62,54.08 54.62,54.08 54.62,54.93 54.79,55.11 56.25,55.11
GND on BOTTOM (solid shape): 131.91,119.78 131.91,119.72 131.9,119.72 131.9,116.31 129.16,116.31 128.86,116.61 128.86,120.36 128.98,120.48 131.21,120.48
GND on BOTTOM (solid shape): 141.49,120.17 141.49,120.16 141.64,120.01 141.64,116.12 141.55,116.03 138.98,116.03 138.88,116.12 138.88,119.91 139.52,120.55 141.11,120.55
GND on BOTTOM (solid shape): 195.91,15.67 195.91,13.77 195.69,13.55 186.75,13.55 186.58,13.73 186.58,16.15 187.02,16.59 194.99,16.59
GND on BOTTOM (solid shape): 210.4,16.43 210.4,14.85 210.01,14.46 209.1,14.46 208.96,14.61 208.96,16.42 209.13,16.59 210.24,16.59
GND on BOTTOM (solid shape): 63.57,54.5 63.57,53.63 63.39,53.45 62.52,53.45 62.04,53.93 61.15,53.93 61.09,53.99 61.09,54.62 61.15,54.69 63.38,54.69
GND on BOTTOM (solid shape): 89.86,106.91 89.86,106.03 89.42,105.58 87.9,105.58 87.71,105.77 87.71,106.91 87.9,107.1 89.67,107.1
GND on BOTTOM (solid shape): 219.56,35.33 219.56,34.09 219.46,33.98 216.4,33.98 216.35,34.03 216.35,35.35 216.43,35.43 219.46,35.43
GND on BOTTOM (solid shape): 115.11,119.2 115.11,114.57 114.82,114.28 112.79,114.28 112.36,114.71 112.36,119.06 112.55,119.25 115.06,119.25
GND on BOTTOM (solid shape): 213.76,21.11 213.76,19.07 213.56,18.88 211.15,18.88 211.02,19.01 211.02,19.71 211.09,19.77 211.98,19.77 212.14,19.94 212.14,21.18 212.24,21.28 213.58,21.28
GND on BOTTOM (solid shape): 52.97,40.68 52.97,38.21 52.84,38.08 50.23,38.08 50.12,38.1 50,38.08 49.86,38.08 49.73,38.21 49.73,40.87 49.86,41 52.65,41
GND on BOTTOM (solid shape): 65.41,54.31 65.41,53.04 65.22,52.85 64.39,52.85 63.97,52.43 62.65,52.43 62.6,52.48 62.6,53.27 62.63,53.3 63.53,53.3 63.87,53.64 63.87,54.38 63.99,54.5 65.22,54.5
GND on BOTTOM (solid shape): 209.4,17.24 209.4,16.77 209.37,16.74 209.07,16.74 208.81,16.49 208.81,16.29 208.69,16.16 208.32,16.16 207.8,16.68 207.8,17.25 207.85,17.3 209.33,17.3
GND on BOTTOM (solid shape): 221.88,28.35 221.88,25.93 222.33,25.49 222.52,25.49 222.65,25.36 222.65,25.11 222.52,24.98 221.18,24.98 220.87,24.66 219.03,24.66 218.9,24.79 218.9,27.08 220.3,28.47 221.76,28.47
GND on BOTTOM (solid shape): 139.67,133.72 139.65,133.7 138.59,133.7 138.05,133.15 137.13,133.15 137.07,133.22 137.07,133.34 137.2,133.47 137.93,133.47 138.28,133.81 138.28,134.74 138.34,134.8 139.67,134.8
GND on BOTTOM (solid shape): 147.64,133.75 147.61,133.72 146.56,133.72 146.01,133.18 145.1,133.18 145.03,133.24 145.03,133.37 145.16,133.5 145.9,133.5 146.24,133.84 146.24,134.77 146.3,134.83 147.64,134.83
GND on BOTTOM (solid shape): 231.54,60.92 231.54,58.19 232.3,57.43 240.81,57.43 241,57.24 241,54.44 240.74,54.19 223.66,54.19 222.71,55.14 222.71,60.79 223.28,61.37 231.09,61.37
GND on BOTTOM (solid shape): 127.32,106.92 127.32,106.73 126.94,106.35 126.94,105.72 127.28,105.38 127.28,105.13 127.15,105 126.39,105 126.26,105.13 126.26,105.42 126.5,105.65 126.5,106.48 126.88,106.86 126.88,106.92 127.01,107.05 127.2,107.05
GND on BOTTOM (solid shape): 158,126.92 158,125.46 157.75,125.2 156.48,125.2 156.29,125.39 153.94,125.39 153.05,124.5 151.78,124.5 151.52,124.76 151.52,126.22 151.71,126.41 152.48,126.41 152.67,126.22 154.7,126.22 154.7,127.04 157.87,127.04
GND on BOTTOM (solid shape): 120.21,106.96 120.21,106.77 119.83,106.4 119.83,105.65 119.77,105.59 119.51,105.59 119.39,105.72 119.39,106.35 119.01,106.73 119.01,106.92 119.13,107.05 119.32,107.05 119.47,106.91 119.74,106.91 119.9,107.07 120.09,107.07
GND on BOTTOM (solid shape): 141.16,167.34 141.16,165.71 140.98,165.52 140.06,165.52 139.87,165.33 138.37,165.33 138.24,165.45 138.24,165.72 138.35,165.83 138.82,165.83 138.93,165.94 138.93,167.45 139.01,167.53 140.97,167.53
GND on BOTTOM (solid shape): 142.3,133.27 143.78,133.27 143.97,133.08 143.97,132.5 144.28,132.19 144.28,125.46 143.9,125.08 142.38,125.08 142.2,125.26 142.2,131.14 141.99,131.34 138.31,131.34 138.31,132.48 139.14,132.48 139.14,133.37 142.19,133.37
GND on BOTTOM (solid shape): 152.16,133.04 152.16,127.3 151.33,126.47 151.33,124.63 151.08,124.38 150.25,124.38 150.06,124.57 150.06,127.66 150.21,127.81 150.21,131.11 149.96,131.37 146.27,131.37 146.27,132.51 147.1,132.51 147.1,133.4 151.8,133.4
GND on BOTTOM (solid shape): 27.12,28.07 27.12,27.86 26.95,27.69 26.95,27.09 26.86,27.01 25.48,27.01 25.4,27.09 25.4,27.57 25.48,27.65 25.63,27.65 25.8,27.81 25.8,28.15 25.92,28.28 26.91,28.28
GND on BOTTOM (solid shape): 110.03,106.88 110.22,106.88 110.43,107.08 110.59,107.08 110.75,106.92 110.75,106.73 110.37,106.35 110.37,105.72 110.24,105.59 109.99,105.59 109.92,105.65 109.92,106.36 109.54,106.75 109.54,106.94 109.68,107.08 109.83,107.08
GND on BOTTOM (solid shape): 112.38,106.88 112.57,106.88 112.78,107.08 112.94,107.08 113.1,106.92 113.1,106.73 112.72,106.35 112.72,105.72 112.59,105.59 112.34,105.59 112.27,105.65 112.27,106.36 111.89,106.75 111.89,106.94 112.03,107.08 112.18,107.08
GND on BOTTOM (solid shape): 114.79,106.88 114.99,106.88 115.19,107.08 115.35,107.08 115.51,106.92 115.51,106.73 115.13,106.35 115.13,105.72 115,105.59 114.75,105.59 114.69,105.65 114.69,106.36 114.3,106.75 114.3,106.94 114.44,107.08 114.59,107.08
GND on BOTTOM (solid shape): 117.14,106.88 117.34,106.88 117.54,107.08 117.7,107.08 117.86,106.92 117.86,106.73 117.48,106.35 117.48,105.72 117.35,105.59 117.1,105.59 117.04,105.65 117.04,106.36 116.65,106.75 116.65,106.94 116.79,107.08 116.94,107.08
GND on BOTTOM (solid shape): 122.55,106.94 122.55,106.75 122.18,106.37 122.18,105.65 122.12,105.59 121.86,105.59 121.74,105.72 121.74,106.35 121.35,106.73 121.35,106.92 121.48,107.05 121.67,107.05 121.82,106.91 122.07,106.91 122.25,107.08 122.42,107.08
GND on BOTTOM (solid shape): 160.8,31.47 160.8,31.41 160.8,31.18 160.69,31.07 160.69,30.46 159.96,29.74 159.56,29.74 159.42,29.88 159.42,30.8 159.84,31.22 160.03,31.41 160.42,31.41 160.58,31.57 160.7,31.57
GND on BOTTOM (solid shape): 126.75,132.95 127.39,132.95 128.22,132.12 128.22,125.2 128.09,125.08 127.2,125.08 127.01,125.27 127.01,129.14 126.76,129.39 125.92,129.39 125.6,129.71 125.6,131.16 125.34,131.42 121.66,131.42 121.66,132.56 122.49,132.56 122.49,133.45 126.25,133.45
GND on BOTTOM (solid shape): 144.6,167.28 144.6,166.36 144.85,166.11 145.1,166.11 145.18,166.1 145.25,166.11 145.48,166.11 145.83,166.46 148.09,166.46 148.28,166.27 148.28,165.31 147.13,164.17 144.64,164.17 144.02,164.79 144.02,167.34 144.1,167.41 144.48,167.41
GND on BOTTOM (solid shape): 73.92,28.32 73.92,24.44 73.67,24.19 72.71,24.19 72.35,24.55 72.35,28.16 72.16,28.35 67.51,28.35 67.06,28.8 67.06,29.74 67.26,29.94 72.3,29.94
GND on BOTTOM (solid shape): 123.29,136.04 123.29,134.96 123.02,134.69 123.02,133.8 123,133.77 121.95,133.77 121.41,133.24 120.52,133.24 120.43,133.32 120.43,133.47 120.52,133.56 121.3,133.56 121.63,133.89 121.63,134.82 121.69,134.88 122.76,134.88 122.97,135.1 122.97,136.02 123.05,136.1 123.23,136.1
GND on BOTTOM (solid shape): 131.42,135.98 131.42,134.96 131.19,134.73 131.19,133.75 131.17,133.73 130.05,133.73 129.53,133.2 128.61,133.2 128.55,133.27 128.55,133.39 128.68,133.52 129.41,133.52 129.73,133.84 129.73,134.84 129.77,134.88 130.94,134.88 131.11,135.06 131.11,136 131.19,136.07 131.33,136.07
GND on BOTTOM (solid shape): 155.26,129.55 155.26,128.54 155.31,128.48 155.31,127.29 155.26,127.24 152.99,127.24 152.92,127.3 152.92,127.52 152.97,127.57 153.28,127.57 153.29,127.56 153.91,127.56 154.07,127.71 154.07,128.41 154.12,128.46 154.8,128.46 154.98,128.64 154.98,129.58 155.04,129.64 155.17,129.64
GND on BOTTOM (solid shape): 181.45,31.94 181.45,31.56 181.58,31.43 182.38,31.43 183.14,30.67 183.14,30.49 183.01,30.37 181.64,30.37 181.21,30.8 181.21,31.09 181.11,31.19 181.11,31.96 181.17,32.03 181.36,32.03
GND on BOTTOM (solid shape): 96.15,98.32 96.15,94.07 95.14,93.05 93.62,93.05 93.57,93.1 93.57,93.98 93.65,94.06 94.4,94.06 94.4,94.07 94.44,94.07 94.69,94.32 94.69,96.78 94.82,96.91 94.82,97.88 95.15,98.2 95.15,98.42 95.3,98.58 95.9,98.58
GND on BOTTOM (solid shape): 32.15,60.29 32.15,58.19 32.15,58.19 32.15,48.92 32.01,48.78 28.4,48.78 28.27,48.91 28.27,54.25 27.95,54.57 26.37,54.57 26.01,54.22 26.01,48.96 25.92,48.87 25.36,48.87 25.24,49 25.24,56.39 26.87,58.03 26.87,60.22 27.19,60.54 31.89,60.54
GND on BOTTOM (solid shape): 128.96,106.9 129.15,106.9 129.18,106.92 129.23,106.92 129.36,107.05 129.55,107.05 129.67,106.92 129.67,106.73 129.29,106.35 129.29,105.72 129.69,105.32 129.69,105.13 129.56,105 128.8,105 128.67,105.13 128.67,105.59 128.85,105.77 128.85,106.33 128.45,106.72 128.45,106.94 128.59,107.08 128.78,107.08
GND on BOTTOM (solid shape): 139.94,135.95 139.94,134.94 139.67,134.68 139.67,133.72 139.65,133.7 138.59,133.7 138.05,133.15 137.13,133.15 137.07,133.22 137.07,133.34 137.2,133.47 137.93,133.47 138.28,133.81 138.28,134.74 138.34,134.8 139.36,134.8 139.62,135.07 139.62,135.96 139.67,136.01 139.88,136.01
GND on BOTTOM (solid shape): 147.9,135.96 147.9,134.92 147.64,134.65 147.64,133.75 147.61,133.72 146.56,133.72 146.01,133.18 145.1,133.18 145.03,133.24 145.03,133.37 145.16,133.5 145.9,133.5 146.24,133.84 146.24,134.77 146.3,134.83 147.37,134.83 147.6,135.06 147.6,135.97 147.68,136.05 147.82,136.05
GND on BOTTOM (solid shape): 199.02,70.57 199.02,70.13 199.34,69.81 199.72,69.81 199.85,69.68 199.85,67.52 200.36,67.02 200.36,63.71 200.23,63.59 198.32,63.59 198.13,63.78 198.13,67.78 198.32,67.97 198.32,70.64 198.39,70.7 198.9,70.7
GND on BOTTOM (solid shape): 210.26,23.6 210.26,21.76 209.41,20.91 209.41,19.44 209.33,19.36 207.9,19.36 207.78,19.47 207.78,20.74 207.47,21.06 206.39,21.06 206.2,21.25 206.2,22.97 206.45,23.22 207.97,23.22 208.23,23.48 208.23,23.79 208.36,23.92 209.94,23.92
GND on BOTTOM (solid shape): 171.62,155.06 174.1,155.06 174.32,154.84 175.27,154.84 175.34,154.77 175.34,154.27 175.21,154.14 173.12,154.14 172.86,154.39 170.17,154.39 169.81,154.03 168.48,154.03 168.42,154.09 168.42,154.66 168.48,154.72 168.87,154.72 169,154.86 169,155.53 169.07,155.6 171.08,155.6
GND on BOTTOM (solid shape): 184.63,60.63 185.01,60.24 185.01,59.62 184.88,59.49 183.77,59.49 183.49,59.77 183.51,59.8 183.54,60.06 183.39,60.27 183.36,60.28 183.36,60.34 183.42,60.39 183.89,60.39 184.13,60.63 184.63,60.63
GND on BOTTOM (solid shape): 195.12,77.37 195.12,76.03 195.57,75.59 196.42,75.59 196.55,75.46 196.55,74.89 196.36,74.7 195.85,74.7 195.34,74.19 193.44,74.19 193,74.62 192.11,74.62 191.85,74.89 191.85,75.65 192.04,75.84 193.45,75.84 193.51,75.91 193.51,77.25 193.69,77.43 195.06,77.43
GND on BOTTOM (solid shape): 188.84,75.75 188.84,75.43 188.73,75.32 188.73,74.64 188.93,74.45 190.06,74.45 190.29,74.22 190.29,72.95 190.13,72.8 188.86,72.8 188.5,73.16 188.5,73.48 188.29,73.69 188.08,73.69 187.84,73.94 187.39,74.39 186.06,74.39 185.88,74.57 185.88,75.78 186.01,75.91 188.68,75.91
GND on BOTTOM (solid shape): 28.01,15.9 28.01,13.06 28.01,13.06 28.01,12.75 28.02,12.74 28.02,11.98 27.7,11.66 25,11.66 22.87,13.79 22.87,15.65 23,15.77 23.51,15.77 23.75,16.02 24.45,16.02 24.45,14.4 24.77,14.09 24.77,13.2 24.97,13 26.87,13 27.18,13.31 27.18,16 27.22,16.03 27.88,16.03
GND on BOTTOM (solid shape): 135.74,133.23 135.74,132.66 136.66,131.74 136.66,126.54 136.54,126.41 135.01,126.41 134.57,126.85 134.57,128.93 133.64,129.86 133.64,131.23 133.5,131.36 129.77,131.36 129.76,131.37 129.76,132.52 129.77,132.54 130.61,132.54 130.61,133.42 135.55,133.42
GND on BOTTOM (solid shape): 119.25,133.2 119.25,132.68 119.9,132.04 119.9,129.33 120.41,128.82 120.41,125.27 120.15,125.01 119.46,125.01 119.27,125.2 119.27,129.01 119.01,129.27 117.58,129.27 117.27,129.58 117.27,131.07 117.05,131.3 113.32,131.3 113.3,131.31 113.3,132.46 113.31,132.47 114.16,132.47 114.16,133.36 119.1,133.36
GND on BOTTOM (solid shape): 27.89,24.3 27.89,23.77 28.27,23.39 28.27,21.42 28.08,21.23 27,21.23 26.87,21.11 26.87,19.46 27,19.33 28.08,19.33 28.21,19.2 28.21,18.88 26.85,17.52 24.66,17.52 24.32,17.19 23.19,17.19 23.06,17.32 23.06,18.73 22.75,19.04 22.75,23.67 23.44,24.36 27.83,24.36
GND on BOTTOM (solid shape): 132.05,106.95 132.05,106.76 131.64,106.35 131.64,105.65 131.85,105.45 131.98,105.45 132.1,105.32 132.1,105.13 132.04,105.07 131.15,105.07 131.09,105.13 131.09,105.61 131.2,105.72 131.2,106.35 130.82,106.73 130.82,106.92 130.94,107.05 131.13,107.05 131.26,106.92 131.41,106.92 131.55,106.92 131.71,107.08 131.92,107.08
GND on BOTTOM (solid shape): 133.67,106.92 133.77,106.92 133.93,106.92 134.05,107.05 134.25,107.05 134.37,106.92 134.37,106.73 133.99,106.35 133.99,105.11 133.88,105 133.56,105 133.46,105.1 133.46,106.43 133.18,106.71 133.18,106.98 133.3,107.1 133.49,107.1
GND on BOTTOM (solid shape): 93.04,111.02 93.04,110.32 92.6,109.88 92.6,109.52 92.21,109.14 92.21,107.68 92.57,107.32 92.57,106.32 92.21,105.96 92.21,104.44 92.98,103.67 92.98,103.34 92.91,103.28 92.03,103.28 91.9,103.4 91.9,103.59 91.9,103.59 91.9,105.83 91.45,106.28 91.45,110.07 90.95,110.58 90.95,110.9 91.2,111.15 92.91,111.15
GND on BOTTOM (solid shape): 196.7,106.35 196.7,106.18 196.6,106.08 196.6,105.73 196.69,105.64 196.69,105.49 196.61,105.41 196.61,105 196.75,104.86 196.75,104.19 197,103.94 197,103.69 196.57,103.26 196.43,103.26 196.32,103.38 196.32,103.5 196.45,103.63 196.45,103.96 196.28,104.13 196.28,104.9 196.41,105.03 196.41,105.4 196.34,105.46 196.34,105.66 196.43,105.75 196.43,106.06 196.33,106.16 196.33,106.36 196.39,106.42 196.62,106.42
GND on BOTTOM (solid shape): 164.31,153.59 164.93,153.59 164.93,153.59 165.18,153.59 165.24,153.52 165.24,153.33 165.37,153.21 166.6,153.21 166.66,153.14 166.66,153.01 166.61,152.95 165.37,152.95 165.24,152.82 165.24,152.63 165.18,152.57 163.65,152.57 163.59,152.51 162.64,152.51 162.26,152.13 162.26,150.77 162.13,150.65 160.86,150.65 160.73,150.77 160.73,151.94 162,153.21 163.72,153.21 164.1,153.59 164.31,153.59
GND on BOTTOM (solid shape): 212.44,47.82 212.44,47.31 212.87,46.89 213.26,46.89 213.51,46.63 213.51,43.59 213.32,43.39 212.75,43.39 212.43,43.08 212.43,41.87 212.75,41.55 213.26,41.55 213.51,41.3 213.51,34.6 213.3,34.39 212.31,34.39 212.15,34.55 212.15,35.56 210.91,36.8 210.91,46.38 210.9,46.39 210.9,47.35 211.46,47.91 212.35,47.91
GND on BOTTOM (solid shape): 316.7,48.8 316.75,48.54 316.89,48.31 316.9,47.8 311.3,47.8 310.8,49.3 310.8,53.4 311.25,54.45 312.3,54.9 316.7,54.9
GND on BOTTOM (solid shape): 202.83,48.03 202.83,46.89 203.22,46.5 203.56,46.5 203.81,46.24 203.81,43.2 203.62,43.01 203.05,43.01 202.73,42.69 202.73,41.48 203.05,41.16 203.56,41.16 203.81,40.91 203.81,37.2 203.34,36.73 199.79,36.73 199.4,37.11 199.4,38.89 199.21,39.08 198.45,39.08 198.26,39.27 198.26,42.12 198.45,42.32 198.83,42.32 199.21,42.7 199.21,44.47 198.96,44.73 198.45,44.73 198.26,44.92 198.26,48.03 199.02,48.79 202.07,48.79
GND on BOTTOM (solid shape): 53.37,18.05 55.62,18.05 55.96,17.7 55.96,16.03 55.96,16.03 55.96,3.33 55.85,3.22 50.66,3.22 50.53,3.36 50.53,4.97 50.69,5.68 50.53,6.38 50.53,8.18 50.37,8.34 50.37,15.45 50.37,15.46 50.37,17.47 50.2,17.63 48.61,17.63 48.46,17.77 48.46,18.97 48.85,19.35 52.06,19.35
GND on BOTTOM (solid shape): 165.13,174.9 165.36,174.75 165.62,174.7 171.68,174.7 171.73,174.7 171.73,170.3 171.29,169.24 170.22,168.8 166.12,168.8 164.63,169.3 164.63,174.9
GND on BOTTOM (solid shape): 153.63,169.3 152.12,168.8 148.03,168.8 146.96,169.24 146.52,170.3 146.52,174.7 146.57,174.7 146.62,174.7 152.63,174.7 152.89,174.75 153.12,174.9 153.63,174.9
GND on BOTTOM (solid shape): 206.87,12.19 206.87,9.87 207.34,9.39 207.34,7.65 207.86,7.14 209.75,7.14 210.07,7.45 210.07,8.88 210.02,8.93 210.02,12.17 210.12,12.27 210.8,12.27 210.87,12.19 210.87,8.95 210.83,8.91 210.83,6.25 210.14,5.55 205.5,5.55 205.18,5.23 205.18,0.79 204.67,0.28 197.82,0.28 197.69,0.41 197.69,5.68 197.69,5.68 197.69,12.16 197.8,12.27 204.23,12.27 204.83,11.68 204.83,7.38 205.17,7.03 206.39,7.03 206.73,7.37 206.73,9.35 206.52,9.57 206.52,12.16 206.63,12.27 206.78,12.27
GND on BOTTOM (solid shape): 124.94,106.95 124.94,106.7 124.88,106.64 124.84,106.56 124.83,106.55 124.67,106.38 124.67,105.62 124.86,105.43 124.86,105.18 124.66,104.99 124.09,104.99 123.88,105.21 123.88,106.49 123.82,106.55 123.81,106.57 123.77,106.64 123.7,106.7 123.67,106.72 123.67,106.91 123.81,107.05 124.08,107.05 124.14,106.98 124.2,106.94 124.39,106.92 124.54,107.03 124.59,107.08 124.82,107.08
GND on BOTTOM (solid shape): 181.62,53.82 181.87,53.82 181.87,53.81 181.93,53.76 181.93,52.94 181.79,52.81 181.43,52.81 181.36,52.81 181.35,52.8 181.11,52.45 181.46,52.2 181.46,52.1 181.49,52.01 181.35,51.87 180.82,51.87 180.8,51.88 180.63,52.05 180.63,52.23 180.5,52.35 179.76,52.35 179.69,52.42 179.69,52.67 180.85,53.83 181.61,53.83
GND on BOTTOM (solid shape): 316.9,36.29 316.75,36.07 316.7,35.8 316.7,30.7 316.46,30.14 315.9,29.9 311.53,29.9 311.01,30.42 310.8,31.13 310.8,32.78 310.8,33.45 310.8,34.15 310.8,34.45 310.8,35.25 310.8,36.8 316.9,36.8
GND on BOTTOM (solid shape): 125.46,92.29 125.46,92.06 125.26,91.85 125.24,91.85 125.18,91.84 125.12,91.81 125.11,91.81 125.04,91.81 125.02,91.78 125.02,91.68 125.02,91.68 125,91.6 125.02,91.52 125.02,91.51 125.02,91.46 125.04,91.44 125.04,91.2 124.94,91.09 124.75,91.09 124.72,91.06 124.71,91.06 124.57,90.98 124.5,90.85 124.49,90.83 124.45,90.79 124.24,90.79 124.15,90.88 124.15,91.1 124.16,91.11 124.2,91.27 124.16,91.43 124.15,91.44 124.15,91.64 124.71,92.2 124.9,92.2 125.09,92.39 125.36,92.39
GND on BOTTOM (solid shape): 160.81,33.57 160.85,33.56 160.87,33.52 160.89,33.48 161.17,33.25 161.48,33.43 161.49,33.43 161.62,33.31 161.62,32.47 161.32,32.18 160.76,32.18 160.68,32.26 160.31,32.26 160.3,32.24 160.18,32.12 160.08,32.12 160.01,32.18 160.01,32.4 160.02,32.44 160.04,32.47 160.15,32.45 160.26,32.48 160.33,32.48 160.44,32.59 160.44,33.33 160.65,33.53 160.67,33.53 160.72,33.54 160.77,33.55
GND on BOTTOM (solid shape): 195.8,95.93 195.88,95.88 195.95,95.81 196.05,95.75 196.05,95.75 196.2,95.65 196.22,95.63 196.23,95.62 196.29,95.53 196.37,95.47 196.38,95.47 196.52,95.33 196.53,95.31 196.59,95.17 196.7,95.07 196.7,93.77 196.91,93.57 196.91,93.56 196.96,93.47 197.03,93.4 197.03,93.22 196.73,92.92 196.73,92.2 196.58,92.05 196.4,92.05 196.28,92.17 196.28,94.97 196.08,95.17 196.08,95.18 196.01,95.26 195.93,95.32 195.92,95.33 195.78,95.47 195.77,95.49 195.73,95.59 195.66,95.68 195.63,95.75 195.66,95.82 195.69,95.85 195.72,95.88
GND on BOTTOM (solid shape): 196,102.87 196,101.97 195.85,101.82 195.85,101.6 196,101.45 196,100.07 196.21,99.87 196.21,99.86 196.29,99.73 196.41,99.66 196.42,99.66 196.52,99.56 196.52,99.54 196.57,99.41 196.66,99.3 196.69,99.23 196.67,99.16 196.64,99.12 196.61,99.08 196.6,99.05 196.45,99.05 196.44,99.08 196.36,99.18 196.25,99.25 196.25,99.25 196.11,99.34 196.08,99.38 196.01,99.46 195.93,99.52 195.92,99.53 195.78,99.67 195.77,99.69 195.7,99.84 195.58,99.94 195.58,101.27 195.38,101.47 195.32,101.56 195.25,101.61 195.25,101.75 195.62,102.12 195.62,102.87 195.73,102.97 195.9,102.97
GND on BOTTOM (solid shape): 196.6,98.74 196.64,98.67 196.7,98.61 196.7,97.79 196.64,97.73 196.6,97.65 196.6,97.65 196.38,97.43 196.37,97.42 196.29,97.36 196.23,97.28 196.22,97.27 196,97.05 196,96.43 195.94,96.38 195.88,96.31 195.8,96.27 195.72,96.31 195.62,96.42 195.49,96.47 195.47,96.48 195.38,96.57 195.38,96.58 195.31,96.66 195.23,96.72 195.2,96.75 195.2,96.85 195.23,96.87 195.31,96.93 195.38,97.02 195.38,97.03 195.47,97.12 195.49,97.13 195.67,97.23 195.77,97.41 195.78,97.43 195.92,97.57 195.93,97.57 196.01,97.63 196.08,97.72 196.08,97.73 196.32,97.97 196.32,98.59 196.4,98.66 196.45,98.74 196.46,98.77 196.59,98.77
