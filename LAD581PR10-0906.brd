# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N121164389: length 16.9
  IN5 w0.097: v2(107.4,107.42) 107.4,106.52 106.94,106.06 104.71,106.06 103.52,107.25 103.52,109.64 102.34,110.82 100.82,110.82 v2(98.82,112.82)
  BOTTOM w0.076: v2(107.4,107.42) 107.65,107.16 CPU1.BH31
  BOTTOM w0.114: RH153.2 97.21,112.8 97.6,113.19 v1(97.99,113.19) 98.44,113.19 v2(98.82,112.82)
N121358327: length 9.9
  TOP w0.089: v2(139.26,92.97) 139.63,93.34 142.61,93.34
  TOP w0.102: RH154.2 144.14,93.14 143.99,93.3 143.99,94.26 143.86,94.39 v1(143.78,94.39) 143.69,94.39 143.58,94.29 143.58,93.5 143.48,93.4 143.28,93.4 143.18,93.5 143.18,94.29 143.08,94.39 142.87,94.39 142.77,94.29 142.77,93.5 142.61,93.34
  BOTTOM w0.076: v2(139.26,92.97) 138.89,93.34 CPU1.H13
N121386646: length 7.8
  BOTTOM w0.076: CPU1.BR30 103.21,106.78 101.56,106.78 101.47,106.69 v1(100.9,106.69) 100.9,106.69
  BOTTOM w0.114: RH158.2 100.36,107.17 100.27,107.08 99.52,107.08 99.22,106.78 99.22,106.24 99.35,106.11 99.58,106.11 99.71,106.24 99.71,106.45 99.84,106.58 100.15,106.58 100.28,106.45 100.28,106.2 100.37,106.11 100.65,106.11 100.78,106.23 100.78,106.56 100.9,106.69
N121386855: length 7.2
  BOTTOM w0.114: RH155.2 98.9,109.05 100.65,109.05 101.11,108.6 101.11,108.43 v1(101.39,108.15) 101.91,107.63 103.79,107.63 CPU1.BP31
N121507165: length 5.4
  BOTTOM w0.076: CPU1.BR25 103.37,102.56 103.02,102.21 101.95,102.21 100.91,101.17 100.91,100.67 100.35,100.12 RH57.2
  BOTTOM w0.089: RH57.2 100.35,99.23 v1(100.27,99.15)
N121507167: length 4.4
  BOTTOM w0.076: RH58.2 101.13,102.65 101.33,102.65 101.65,102.97 103.66,102.97 104.07,102.56 CPU1.BP25
N121507169: length 5.8
  BOTTOM w0.089: CPU1.BT29 101.55,105.71 v1(101.3,105.46) 100.88,105.46 100.54,105.13 99.92,105.13
  BOTTOM w0.114: RH166.2 98.13,105.99 99,105.13 99.92,105.13
N122563835: length 6
  BOTTOM w0.114: CPU1.BR33 103.17,108.38 101.61,108.38 100.58,109.41 v1(99.09,109.41) 98.24,109.41 RH519.2
N124752685: length 1.8
  TOP w0.114: v1(124.78,45.29) RH211.1 CH101.2
N124753277: length 1.8
  TOP w0.114: RH212.1 CH100.2 v1(123.91,26.56)
N198830997: length 2.7
  BOTTOM w0.114: v1(161.98,102.69) RV23.2 161.25,104.44 UV21.48
N212152397: length 7.7
  TOP w0.114: v3(255.98,54.13) 256.36,54.51 PR2.2 v2(257.25,55.38)
  BOTTOM w0.114: v2(257.25,55.38) 258.28,54.36 JRTC1.1
N213961754: length 4.4
  TOP w0.114: v1(53.1,9.42) 53.35,9.17 PC14.2
  TOP w0.254: PC14.2 54.31,9.12 PR28.2 55.59,7.83 PQ8.2
N249440990: length 2.3
  BOTTOM w0.076: UT4.G10 128.3,151.83 128.94,151.83 129.05,151.73 129.17,151.73
  BOTTOM w0.114: 129.17,151.73 129.55,151.73 129.68,151.6 T122.1
N249441180: length 2.4
  BOTTOM w0.076: UT4.D10 128.05,150.16 128.22,150.33 128.66,150.33 128.66,150.33 128.73,150.33 129.17,149.89
  BOTTOM w0.114: 129.17,149.89 129.17,149.85 T114.1
N249443250: length 1.3
  TOP w0.114: T71.1 v2(125.81,152.55)
  BOTTOM w0.089: v2(125.81,152.55) 125.81,152.33 UT4.H6
N249443770: length 4.1
  BOTTOM w0.076: 123.8,148.2 123.8,148.83 UT4.B2
  BOTTOM w0.089: 121.7,147.36 122.26,147.36 122.68,147.79 123.39,147.79 123.8,148.2
  BOTTOM w0.114: T64.1 121.7,147.36
N257291080: length 1.5
  BOTTOM w0.203: C2506.1 59.83,60 U17.12
N257291250: length 1.5
  BOTTOM w0.203: C2507.1 59.83,60.8 U17.10
N2494451224: length 2.6
  BOTTOM w0.076: T65.1 122.19,148.37 123.15,149.33 123.8,149.33 UT4.C2
N2494451226: length 1.5
  BOTTOM w0.089: UT4.G11 128.87,151.58 128.98,151.47 129.17,151.47
  BOTTOM w0.114: 129.17,151.47 129.3,151.47 129.62,151.15 T120.1
N2494451228: length 2.4
  BOTTOM w0.076: UT4.E10 128.3,150.83 128.66,150.83 128.71,150.77 128.98,150.77
  BOTTOM w0.114: 128.98,150.77 129.49,150.27 129.68,150.27 T121.1
N2494451230: length 1.1
  TOP w0.114: T70.1 126.38,150.13 v2(126.38,149.63)
  BOTTOM w0.089: UT4.D7 126.55,149.8 v2(126.38,149.63)
N2494451263: length 1.3
  TOP w0.114: v2(124.6,150.87) 125.07,150.41 T62.1
  BOTTOM w0.089: UT4.F4 124.78,151.08 124.6,150.9 v2(124.6,150.87)
N2494451264: length 1.1
  TOP w0.114: v2(124.6,151.45) 124.77,151.45 T63.1
  BOTTOM w0.089: v2(124.6,151.45) 124.6,151.45 124.73,151.58 UT4.G4

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 68.85,48.88 69.86,47.86 69.86,43.92 69.77,43.83 68.92,43.83 68.84,43.91 68.84,45.11 68.71,45.24 64.46,45.24 64.44,45.26 64.44,46.56 64.66,46.78 65.8,46.78 65.96,46.94 66.32,47.13 66.12,47.48 66.12,49.83 66.56,50.27 68.85,50.27
3/5V_B+ on TOP (solid shape): 49.99,35.67 49.99,31.95 49.78,31.75 49.09,31.75 48.84,31.5 48.84,26.26 48.57,25.99 48.57,25.67 47.49,24.6 44.36,24.6 43.83,25.13 43.83,26.46 44.84,27.48 44.84,28.3 45.29,28.75 45.29,32.47 45.42,32.59 46.53,32.59 46.81,32.87 46.81,34.08 46.62,34.27 46.62,35.65 46.66,35.69 46.84,35.69 46.87,35.73 46.87,36.01 46.96,36.09 49.56,36.09
3/5V_B+ on IN1 (solid shape): outline of 309 points within 35.51,24.33 49.22,30.7
3VS on BOTTOM (solid shape): 57.48,63.91 58.88,63.91 58.88,64.48 59.55,64.48 60.07,63.96 60.07,61.52 59.91,61.36 59.32,61.36 59.06,61.1 58.17,61.1 58.11,61.17 58.11,61.74 57.73,62.12 57.28,62.12 57.04,62.36 57.04,64.41 57.1,64.48 57.48,64.48
5VS on BOTTOM (solid shape): 59.38,59.39 60.16,59.39 60.24,59.3 60.24,58.68 60.2,58.63 59.8,58.63 59.41,58.24 59.41,56.21 58.88,56.21 58.88,55.71 59.41,55.71 59.41,55.41 58.88,55.41 58.88,54.91 59.41,54.91 59.41,54.38 59.13,54.1 57.93,54.1 57.69,54.34 57.69,54.98 57.09,55.58 57.09,56.41 57.63,56.41 57.64,56.36 57.65,56.31 57.67,56.26 57.7,56.21 57.73,56.17 57.77,56.13 57.81,56.1 57.86,56.08 57.91,56.06 57.96,56.06 58.02,56.06 58.07,56.06 58.12,56.08 58.17,56.1 58.21,56.13 58.25,56.17 58.28,56.21 58.31,56.26 58.33,56.31 58.34,56.36 58.35,56.41 58.34,56.47 58.33,56.52 58.31,56.57 58.28,56.61 58.25,56.66 58.21,56.69 58.17,56.72 58.12,56.74 58.07,56.76 58.02,56.77 57.96,56.77 57.91,56.76 57.86,56.74 57.81,56.72 57.77,56.69 57.73,56.66 57.7,56.61 57.67,56.57 57.65,56.52 57.64,56.47 57.63,56.41 57.09,56.41 57.09,58.05 58.11,59.07 58.11,59.64 58.17,59.7 59.06,59.7
+0.6VS on TOP (solid shape): 150.82,31.16 150.82,25.32 150.57,25.06 149.68,25.06 149.43,25.32 149.43,31.03 149.81,31.41 150.57,31.41
+0.6VS on TOP (solid shape): 148.79,42.84 148.79,40.68 148.92,40.56 148.92,38.02 148.77,37.87 147.97,37.87 147.78,38.06 147.78,42.72 148.03,42.97 148.67,42.97
+0.6VS on TOP (solid shape): 73.22,59.38 73.22,57.79 69.58,54.14 69.58,53.4 69.04,52.86 68.59,52.86 68.57,52.89 68.57,53.33 68.56,53.34 68.02,53.34 68.01,53.35 68.01,53.51 68.02,53.52 68.56,53.52 68.57,53.53 68.57,54.7 72.09,58.22 72.09,59.43 72.2,59.54 73.07,59.54
+0.6VS on IN1 (solid shape): 74.51,59.36 74.51,58.49 74.47,58.45 72.25,58.45 72.08,58.62 72.08,59.34 72.19,59.46 74.42,59.46
+0.6VS on IN1 (solid shape): 151.22,30.68 151.22,30.23 150.01,29.01 149.53,29.01 149.16,29.38 149.16,29.78 150.49,31.11 150.79,31.11
+0.6VS on IN3 (solid shape): 148.88,40.81 148.88,39.55 148.7,39.37 148.05,39.37 147.5,39.92 147.5,41.07 147.81,41.38 148.31,41.38
+0.6VS on IN3 (solid shape): 151.21,30.68 151.21,30.08 149.99,28.85 149.23,28.85 149.19,28.89 149.19,29.73 150.58,31.12 150.77,31.12
+0.6VS on IN3 (solid shape): 74.56,58.13 74.56,57.63 74.32,57.38 73.85,57.38 73.24,57.99 72.29,57.99 72.06,58.22 72.06,59.02 72.51,59.48 73.22,59.48
+0.6VS on IN5 (solid shape): 151.02,31.2 151.02,29.49 150.89,29.36 148.22,29.36 147.91,29.68 147.91,30.38 148.03,30.5 148.77,30.5 149.6,31.33 150.89,31.33
+0.6VS on IN5 (solid shape): 149.05,40.56 149.05,39.41 149.17,39.29 149.43,39.29 149.55,39.16 149.55,38.27 149.43,38.14 148.41,38.14 148.03,38.52 148.03,40.56 148.16,40.68 148.92,40.68
+0.6VSP on TOP (solid shape): 68.42,53.93 68.42,53.68 68.4,53.67 67.86,53.67 67.86,53.67 67.86,53.19 67.86,53.18 68.42,53.18 68.42,53.18 68.42,52.9 67.95,52.43 66.38,52.43 65.61,51.66 65.61,51.32 65.51,51.22 64.08,51.22 63.92,51.39 62.47,51.39 62.41,51.44 62.41,51.58 62.46,51.64 62.93,51.64 63.12,51.83 63.12,52.59 62.81,52.91 62.04,52.91 61.81,52.68 61.81,51.89 61.75,51.83 61.66,51.83 61.6,51.89 61.6,52.78 62.17,53.35 62.3,53.35 62.42,53.23 63.51,53.23 64.06,52.67 65.42,52.67 65.86,53.12 65.86,53.64 65.93,53.7 67,53.7 67.26,53.95 68.4,53.95
+0.6VSP on BOTTOM (solid shape): 62.47,53.18 62.47,52.09 62.97,51.59 64.04,51.59 64.24,51.79 64.24,52.49 64.41,52.66 65.26,52.66 65.41,52.51 65.41,51.38 65.21,51.18 64.78,51.18 64.3,50.7 62.56,50.7 61.67,51.59 61.67,52.82 62.17,53.33 62.33,53.33
+0.9V_CIO on TOP (solid shape): 148.33,154.74 148.52,154.64 148.72,154.74 148.98,154.74 149.03,154.69 149.1,154.65 149.15,154.64 149.29,154.5 149.29,154.15 149.18,154.05 148.47,154.05 148.35,153.92 147.9,153.92 147.74,153.75 147.71,153.73 147.65,153.66 147.43,153.66 147.4,153.72 147.36,153.75 147.32,153.78 147.26,153.8 147.23,153.82 147.22,153.99 147.14,154.12 147.12,154.14 147.12,154.19 147.14,154.24 147.2,154.3 147.32,154.3 147.34,154.29 147.55,154.21 147.76,154.29 147.78,154.3 148.22,154.74
+0.9V_CIO on BOTTOM (solid shape): 149.1,154.64 149.1,154.45 149.17,154.38 149.61,154.38 149.67,154.32 149.67,153.75 149.55,153.62 148.02,153.62 147.83,153.43 147.83,153.16 147.75,153.08 147.3,153.08 147.26,153.12 147.26,153.5 147.32,153.56 147.32,153.99 147.45,154.13 147.77,154.13 148.02,154.38 148.02,154.7 148.09,154.76 148.98,154.76
+0.9V_DP on TOP (solid shape): 147.33,156.27 147.33,155.19 147.24,155.1 147.22,155.1 147.09,155.06 147.01,154.95 147,154.93 146.83,154.93 146.74,155.03 146.71,155.05 146.39,155.37 146.39,155.51 146.58,155.71 146.58,155.98 146.43,156.13 146.43,156.22 146.49,156.26 146.52,156.3 146.66,156.45 146.66,156.56 146.82,156.72 146.88,156.72
+0.9V_DP on TOP (solid shape): 149.61,153.47 149.62,153.47 149.66,153.41 149.72,153.36 149.73,153.36 149.77,153.32 149.77,153.16 149.94,152.99 149.94,152.85 149.9,152.81 149.87,152.78 149.78,152.78 149.72,152.84 149.63,152.92 149.5,152.92 149.38,152.92 149.35,152.89 149.25,152.81 149.23,152.82 149.12,152.82 148.98,152.95 148.73,152.95 148.6,152.82 148.48,152.82 148.46,152.84 148.46,152.94 148.44,152.97 148.45,153.01 148.54,153.29 148.37,153.53 148.35,153.54 148.35,153.66 148.47,153.79 149.3,153.79
+0.9V_DP on BOTTOM (solid shape): 147.14,156.48 147.14,156.17 147.33,155.98 147.78,155.98 147.78,155.56 147.74,155.52 147.26,155.52 147.17,155.44 147.17,155.05 147.09,154.96 146.76,154.96 146.66,155.05 146.66,155.57 146.57,155.66 146.57,155.68 146.6,155.84 146.57,155.99 146.57,156 146.57,156.55 146.62,156.61 147.02,156.61
+0.9V_DP on BOTTOM (solid shape): 156.16,151.85 156.16,150.01 155.89,149.74 155.86,149.72 155.82,149.69 155.65,149.69 155.59,149.76 155.4,149.76 155.21,149.76 154.95,150.01 154.95,150.98 155.03,151.2 154.95,151.42 154.95,151.66 155.27,151.98 156.03,151.98
+0.9V_DP on IN2 (solid shape): outline of 1045 points within 146.57,149.69 156.22,156.17
+0.9V_DP on IN4 (solid shape): outline of 111 points within 148.25,152.96 149.88,156.13
+0.9V_LVR_OUT on IN4 (solid shape): outline of 800 points within 147.17,156.27 159.3,160.84
+0.9V_PCIE on TOP (solid shape): 151.86,156.27 152.1,156.16 152.34,156.27 152.51,156.27 152.54,156.23 152.54,156.13 152.48,156.07 152.43,156 152.34,155.9 152.34,155.77 152.18,155.61 152.18,155.42 152.18,155.41 152.21,155.4 152.33,155.28 152.33,155.15 152.33,155.12 152.57,154.89 152.57,154.82 152.52,154.79 152.48,154.74 151.71,154.74 151.66,154.8 151.14,155.32 150.46,155.32 150.44,155.34 150.16,155.52 149.86,155.36 149.8,155.35 149.75,155.38 149.68,155.44 149.68,155.84 149.71,155.91 149.79,155.94 149.9,155.95 149.99,156.01 150.3,156.01 150.47,155.94 150.64,156.01 150.7,156.01 150.76,156.08 150.84,156.11 150.92,156.07 151.06,155.95 151.24,155.97 151.27,155.99 151.29,156.01 151.44,156.16 151.46,156.16 151.59,156.19 151.69,156.27
+0.9V_PCIE on BOTTOM (solid shape): 151.4,156.09 152.18,156.09 152.39,155.87 152.39,155.85 152.71,155.49 153.1,155.77 153.11,155.82 153.56,155.82 153.62,155.75 153.62,154.31 153.58,154.27 152.86,154.27 152.54,154.58 151.81,154.58 151.8,154.62 151.63,154.85 151.34,154.87 151.31,154.86 150.6,155.57 150.15,155.57 150.09,155.57 150.02,155.55 149.99,155.54 149.87,155.66 149.87,155.72 149.88,155.72 149.88,156.05 149.94,156.11 150.31,156.11 150.31,156.11 151.38,156.11
+0.9V_PCIE on IN4 (solid shape): outline of 874 points within 149.79,147.08 158,156.3
+0.9V_SVR on TOP (solid shape): 148.4,156.59 148.4,156.39 148.38,156.37 148.37,156.37 148.25,156.25 148.25,156.06 148.41,155.9 148.41,155.72 148.32,155.62 148.3,155.49 148.3,155.46 148.22,155.38 147.78,155.38 147.71,155.44 147.71,156.9 147.78,156.97 148.02,156.97
+0.9V_SVR on TOP (solid shape): 149.55,159.33 149.74,159.14 149.74,159.02 149.87,158.89 149.92,158.83 149.99,158.79 150.03,158.75 150.15,158.75 150.63,158.27 150.63,158.05 150.53,157.94 148.54,157.94 148.41,158.07 148.41,158.19 148.51,158.32 148.53,158.48 148.52,158.5 148.56,158.54 148.6,158.55 148.63,158.57 148.71,158.64 148.75,158.75 148.75,158.77 148.92,158.93 149.05,158.93 149.44,159.33
+0.9V_SVR on BOTTOM (solid shape): 148.41,156.49 148.41,155.73 148.29,155.6 148.03,155.6 147.91,155.73 147.91,156.04 147.78,156.17 147.4,156.17 147.33,156.23 147.33,156.55 147.4,156.62 148.29,156.62
+0.9V_SVR on BOTTOM (solid shape): 140.17,162.57 140.22,162.56 140.28,162.55 140.51,162.55 140.57,162.56 140.63,162.57 140.8,162.57 140.89,162.48 140.89,162.06 140.83,161.99 139.78,161.99 139.38,161.59 139.38,158.12 139.22,157.96 137.07,157.96 136.95,158.02 136.81,158.04 136.57,158.28 136.57,158.77 136.73,159.07 136.57,159.36 136.57,161.4 137.49,162.32 138.15,162.32 138.4,162.57
+0.9V_SVR on BOTTOM (solid shape): 150.38,159.85 150.38,159.4 150.3,159.4 150.29,159.4 149.79,159.08 150.29,158.76 150.3,158.76 150.82,158.76 150.83,158.77 150.89,158.77 150.95,158.71 150.95,158.14 150.83,158.01 150.26,158.01 149.81,157.57 149.37,157.57 149.3,157.63 149.3,158.2 149.24,158.27 148.79,158.27 148.6,158.46 148.6,159.09 148.55,159.15 148.55,159.16 148.45,159.35 148.27,159.44 148.25,159.45 148.16,159.54 148.16,159.85 148.22,159.92 150.32,159.92
+0.9V_SVR on IN1 (solid shape): outline of 949 points within 137.66,155.45 150.43,165.7
+0.9V_SVR on IN2 (solid shape): outline of 1037 points within 138.33,155.62 150.8,165.8
+1.0VS_VGAP on TOP (solid shape): 170.96,153.96 170.96,153.29 170.72,153.06 167.91,153.06 167.72,153.25 167.72,153.82 167.78,153.88 169.76,153.88 170.18,153.88 170.19,153.89 170.33,153.89 170.48,154.04 170.87,154.04
+1.0VS_VGAP on BOTTOM (solid shape): outline of 182 points within 170.35,150.75 177.69,154.44
+1.2V_DDR on TOP (solid shape): 113.09,53.63 98.09,53.63 98.09,63.63 113.09,63.63
+1.2V_DDR on TOP (solid shape): 130.66,56.04 122.66,56.04 122.66,64.04 130.66,64.04
+1.2V_DDR on TOP (solid shape): 142.75,56.07 134.75,56.07 134.75,64.07 142.75,64.07
+1.2V_DDR on TOP (solid shape): outline of 30434 points within 79.29,23.26 144.53,93.86
+1.2V_DDR on BOTTOM (solid shape): 99.84,89.61 99.84,87.02 99.63,86.81 98.95,86.81 98.78,86.98 98.78,88.24 98.94,88.4 98.94,89.63 99.02,89.71 99.74,89.71
+1.2V_DDR on BOTTOM (solid shape): 80.7,31.65 81.29,31.65 81.68,31.27 81.68,28.15 80.79,27.27 80.41,27.27 80.4,27.26 75.21,27.26 72.26,30.2 65.83,30.2 64.96,31.07 64.96,32.17 64.43,32.7 63.9,32.7 63.77,32.83 63.77,33.63 63.88,33.74 64.43,33.74 64.44,33.73 64.44,33.19 64.45,33.18 65.19,33.18 65.19,33.18 65.19,33.73 65.2,33.74 65.63,33.74 65.62,33.74 65.62,33.2 66.39,33.2 66.39,33.73 66.4,33.75 69.09,33.75 69.1,33.74 69.11,33.74 69.63,33.74 69.63,33.2 69.64,33.19 70.36,33.19 70.39,33.22 70.39,33.73 70.4,33.74 70.84,33.74 70.84,33.2 70.84,33.2 71.61,33.2 71.59,33.22 71.59,33.74 72.12,33.74 72.14,33.76 72.19,33.76 72.22,33.79 73.94,33.79 73.95,33.8 78.55,33.8
+1.2V_DDR on BOTTOM (solid shape): outline of 84 points within 108.73,48.97 125.3,53.97
+1.2V_DDR on IN3 (solid shape): outline of 34338 points within 78.61,26.33 144.73,93.51
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 100.89,93.85 100.89,93.45 100.76,93.32 100.12,93.32 99.77,92.96 99.77,91.21 99.62,91.06 99.11,91.06 98.98,91.19 98.98,93.85 99.21,94.08 100.66,94.08
+1.2V_VCCPLL_OC on IN5 (solid shape): outline of 1250 points within 107.56,90.98 140.23,95.04
+1.2VP on BOTTOM (solid shape): outline of 128 points within 63.83,33.34 73.82,48.25
+1.8VS on TOP (solid shape): 36.27,39.71 36.27,39.19 36.15,39.06 34.77,39.06 34.71,39.12 34.71,39.72 34.83,39.84 36.15,39.84
+1.8VS on TOP (solid shape): 157.88,66.25 157.88,65.56 157.68,65.37 156.61,65.37 156.48,65.49 156.48,66.38 156.61,66.51 157.62,66.51
+1.8VS on TOP (solid shape): 196.9,69.78 196.9,68.83 196.77,68.7 195.31,68.7 195.05,68.95 195.05,69.59 195.37,69.91 196.77,69.91
+1.8VS on TOP (solid shape): 26.89,25.78 26.89,25.44 26.83,25.38 26.42,25.38 26.2,25.16 26.2,24.37 26.17,24.34 26.05,24.34 26,24.39 26,25.26 26.23,25.49 26.25,25.49 26.42,25.66 26.42,25.76 26.57,25.91 26.77,25.91
+1.8VS on BOTTOM (solid shape): 207.94,28.3 207.94,27.37 207.16,26.59 205.95,26.59 205.51,27.04 205.51,27.85 205.34,28.02 205.34,28.59 205.39,28.63 207.61,28.63
+1.8VS on BOTTOM (solid shape): 197.19,71.74 197.19,70.65 196.99,70.45 196.99,68.46 196.47,67.94 195.67,67.94 195.59,68.02 195.59,69.56 195.28,69.87 195.28,70.64 195.34,70.7 195.85,70.7 195.95,70.8 195.95,71.67 196.09,71.8 197.13,71.8
+1.8VS on BOTTOM (solid shape): 26.61,25.92 26.72,25.92 26.89,25.75 26.89,25.46 27.07,25.29 27.1,25.29 27.12,25.27 27.43,25.27 27.62,25.46 27.62,25.78 27.76,25.92 27.99,25.92 28.08,25.83 28.08,24.79 27.9,24.61 25.48,24.61 25.41,24.68 25.41,25.25 25.6,25.44 25.6,25.76 25.76,25.92 26.61,25.92
+1.8VS on BOTTOM (solid shape): 235.52,145.95 235.52,145.43 236.02,145.43 236.02,145.95 236.32,145.95 236.32,145.43 236.82,145.43 236.82,145.95 238.26,145.95 238.68,145.53 238.68,144.05 238.36,143.73 235.11,143.73 234.91,143.93 234.91,144.48 234.9,144.49 234.9,145.76 235.09,145.95
+1.8VS on BOTTOM (solid shape): 29.73,29.68 29.73,28.6 29.58,28.45 29.24,28.45 29.24,28.45 29.15,28.45 28.75,28.05 28.44,28.05 28.13,27.75 27.47,27.75 27.27,27.95 27.27,28.12 26.95,28.44 26.95,28.51 27.47,29.03 28.58,29.03 28.61,29.06 28.75,29.19 28.75,29.81 28.79,29.86 29.55,29.86
+1.8VS on IN2 (solid shape): 247.45,53 247.45,50.25 246.92,49.72 245.52,49.72 245,50.24 245,53 245.2,53.2 247.25,53.2
+1.8VS on IN2 (solid shape): 238.84,145.37 239.67,145.37 239.84,145.2 239.84,143.6 239.71,143.47 236.04,143.47 235.49,144.02 235.49,145.15 235.71,145.38 238.84,145.38
+1.8VS on IN3 (solid shape): 30.43,29.17 30.43,28.73 30.11,28.41 28.72,28.41 28.53,28.6 28.53,29.23 28.78,29.49 30.11,29.49
+1.8VS on IN3 (solid shape): 157.24,66.31 157.24,64.41 157.05,64.22 156.41,64.22 156.22,64.41 156.22,66.32 156.41,66.51 157.04,66.51
+1.8VS on IN3 (solid shape): 220.09,29.89 220.09,28.22 219.58,27.71 218.9,27.71 218.24,28.37 218.24,29.96 218.54,30.26 219.73,30.26
+1.8VS on IN3 (solid shape): 247.25,53.15 247.25,49.88 246.94,49.58 243.46,49.58 243.04,50 243.04,52.96 243.47,53.39 247,53.39
+1.8VS on IN3 (solid shape): 209.87,28.21 209.87,27.44 209.7,27.27 207.94,27.27 207.38,26.71 207.33,26.71 206.69,27.36 206.69,27.86 207.38,28.56 209.52,28.56
+1.8VS on IN3 (solid shape): 238.01,145.05 239.02,145.05 239.02,145.05 239.63,145.05 239.78,144.9 239.78,143.67 239.53,143.42 235.78,143.42 235.54,143.66 235.54,144.87 235.73,145.06 238,145.06
+1.8VS on IN3 (solid shape): outline of 565 points within 188.56,53.1 196.99,70.78
+1.8VSP on BOTTOM (solid shape): 235.44,152.32 235.44,148.65 235.59,148.5 236.24,148.5 236.35,148.39 236.35,147.65 237.31,146.69 237.31,146.26 237.19,146.14 236.7,146.14 236.7,146.07 236.7,146.07 236.7,145.56 236.45,145.56 236.45,146.07 236.42,146.07 236.42,146.08 235.92,146.08 235.92,146.07 235.9,146.07 235.9,145.56 235.65,145.56 235.65,146.14 234.36,146.14 233.98,146.52 233.98,152.24 234.17,152.42 235.34,152.42
+1.35VS_B+ on TOP (solid shape): outline of 104 points within 241.82,52.81 249.79,71.97
+1.35VS_B+ on BOTTOM (solid shape): 246.01,59.14 246.01,56.41 245.44,55.84 245.44,54.51 245.19,54.25 244.36,54.25 244.17,54.44 244.17,55.9 244.49,56.22 244.49,59.33 244.55,59.4 245.76,59.4
+1.35VS_VGA on TOP (solid shape): outline of 45787 points within 179.21,69.37 244.36,143.15
+1.35VS_VGA on BOTTOM (solid shape): 236.49,130.39 236.49,128.8 235.98,128.29 232.3,128.29 232.17,128.42 232.17,130.58 232.3,130.71 236.17,130.71
+1.35VS_VGA on BOTTOM (solid shape): 181.36,145.09 181.36,144.19 181.27,144.1 181.27,143.06 181.36,142.97 181.36,142.73 181.22,142.59 180.97,142.59 180.63,142.92 180.63,145.1 180.68,145.15 181.31,145.15
+1.35VS_VGA on BOTTOM (solid shape): 182.93,135.64 182.93,135.55 182.61,135.23 182.61,135.1 183.31,134.4 183.31,134.32 183.2,134.21 183.07,134.21 182.2,135.08 182.2,135.25 182.72,135.77 182.8,135.77
+1.35VS_VGA on BOTTOM (solid shape): 185.41,141.73 185.41,141.3 185.34,141.24 184.73,141.24 184.13,140.64 183.87,140.64 183.79,140.72 183.79,140.84 184.77,141.81 184.92,141.81 184.92,141.82 185.32,141.82
+1.35VS_VGA on BOTTOM (solid shape): 230.37,130.38 230.37,129.66 230.31,129.61 228.32,129.61 227.86,130.07 225.91,130.07 225.66,130.32 225.66,130.5 225.77,130.61 226.86,130.61 226.93,130.69 230.06,130.69
+1.35VS_VGA on BOTTOM (solid shape): 232.81,118.46 232.81,118.29 232.52,118.01 232.52,117.91 233.61,116.81 233.61,116.68 233.56,116.63 233.39,116.63 232.14,117.88 232.14,118.04 232.62,118.52 232.74,118.52
+1.35VS_VGA on BOTTOM (solid shape): 231.64,96.85 231.64,96.72 230.57,95.65 230.57,95.49 230.81,95.24 230.81,95.1 230.73,95.01 230.72,95.01 230.51,95.01 230.05,95.47 230.05,95.64 231.35,96.93 231.55,96.93
+1.35VS_VGA on BOTTOM (solid shape): 183.28,137.66 183.28,137.49 182.65,136.86 182.65,136.73 182.96,136.42 182.96,136.31 182.88,136.22 182.66,136.22 182.19,136.69 182.19,136.85 183,137.66 183,137.68 183.06,137.74 183.21,137.74
+1.35VS_VGA on BOTTOM (solid shape): 194.43,130.68 194.43,130.01 194.36,129.95 192.14,129.95 192.11,129.99 191.3,129.99 190.99,130.29 190.99,130.47 191.08,130.55 191.2,130.55 191.38,130.37 193.18,130.37 193.52,130.7 194.4,130.7
+1.35VS_VGA on BOTTOM (solid shape): 217.19,133.65 217.19,133.5 217.1,133.41 216.94,133.41 216.27,134.08 216.17,134.08 215.51,133.42 215.51,133.42 215.1,133 214.95,133 214.87,133.08 214.87,134.05 215.36,134.54 216.3,134.54
+1.35VS_VGA on BOTTOM (solid shape): 231.49,123.18 231.49,121.95 232.54,120.9 232.54,120.3 232.79,120.04 232.79,119.87 232.76,119.83 232.49,119.83 232,120.32 232,120.69 230.82,121.87 230.82,123.17 230.89,123.24 231.43,123.24
+1.35VS_VGA on BOTTOM (solid shape): 236.71,75.24 236.77,75.24 237.63,74.38 237.63,74.16 237.51,74.04 236.61,74.04 236.11,74.54 236.11,74.84 236.25,74.98 236.25,75.27 236.11,75.42 236.11,75.61 236.18,75.68 236.28,75.68
+1.35VS_VGA on BOTTOM (solid shape): 241.21,118.05 241.21,117.88 240.07,116.74 240.07,116.16 239.98,116.06 239.78,116.06 239.71,116.14 239.71,116.81 240.8,117.9 240.8,118.02 240.53,118.29 240.53,118.44 240.59,118.5 240.76,118.5
+1.35VS_VGA on BOTTOM (solid shape): 242.71,123.18 242.71,122.14 242.15,121.58 242.15,120.3 242.43,120.02 242.43,119.91 242.35,119.83 242.08,119.83 241.61,120.3 241.61,121.89 241.91,122.19 241.91,123.1 242.06,123.25 242.64,123.25
+1.35VS_VGA on BOTTOM (solid shape): 178.73,142.31 180.38,142.31 180.65,142.04 180.65,141.91 180.91,141.64 180.91,141.45 180.9,141.44 180.62,141.44 180.34,141.72 178.64,141.72 178.52,141.61 177.73,141.61 177.58,141.76 177.58,142.29 177.71,142.41 178.62,142.41
+1.35VS_VGA on BOTTOM (solid shape): 195.68,133.52 195.68,132.52 195.91,132.28 198.8,132.28 198.92,132.16 199.48,132.16 199.57,132.07 199.57,131.79 199.17,131.39 198.8,131.39 198.58,131.61 195.3,131.61 195,131.91 195,133.55 195.04,133.59 195.6,133.59
+1.35VS_VGA on BOTTOM (solid shape): 199.58,130.46 199.58,130.31 199.26,129.99 199.26,129.87 199.05,129.65 198.12,129.65 197.31,128.85 196.07,128.85 195.96,128.96 195.96,129.43 196.08,129.55 197.24,129.55 197.87,130.18 199.01,130.18 199.38,130.56 199.48,130.56
+1.35VS_VGA on BOTTOM (solid shape): 202.76,131.26 202.76,131.1 202.69,131.03 202.55,131.03 201.86,131.72 201.78,131.72 201.52,131.46 201.28,131.46 200.88,131.86 200.88,132.08 200.91,132.12 201.07,132.12 201.37,131.81 201.45,131.81 201.78,132.14 201.88,132.14
+1.35VS_VGA on BOTTOM (solid shape): 216.06,137.97 216.3,137.97 216.51,138.18 216.51,138.19 216.86,138.55 217.09,138.55 217.2,138.44 217.2,138.32 216.74,137.86 216.74,137.76 216.4,137.42 215.1,137.42 214.72,137.79 214.72,138.83 214.88,138.98 215.05,138.98
+1.35VS_VGA on BOTTOM (solid shape): 228.13,141.89 229.04,141.89 229.08,141.85 229.08,141.21 229.03,141.16 227.8,141.16 227.28,141.69 226.19,141.69 225.94,141.44 225.73,141.44 225.66,141.52 225.66,141.65 225.74,141.74 225.74,141.75 226.24,142.24 227.78,142.24
+1.35VS_VGA on BOTTOM (solid shape): 229.12,138.78 229.12,138.14 229.03,138.06 228.15,138.06 227.71,138.5 226.19,138.5 225.93,138.24 225.7,138.24 225.66,138.28 225.66,138.46 225.98,138.78 225.98,138.87 226.13,139.01 226.23,139.01 226.27,139.06 228.84,139.06
+1.35VS_VGA on BOTTOM (solid shape): 239.05,93.37 239.12,93.37 239.28,93.21 239.28,92.25 240.23,91.29 240.23,90.31 240.17,90.25 239.65,90.25 239.55,90.35 239.55,91.18 238.76,91.97 238.76,93.21 238.5,93.47 238.5,93.64 238.58,93.72 238.71,93.72
+1.35VS_VGA on BOTTOM (solid shape): 181.07,134.25 181.22,134.25 181.44,134.47 181.71,134.47 182.5,133.69 182.5,133.5 182.41,133.41 182.29,133.41 181.59,134.11 181.48,134.11 180.57,133.19 180.57,133.13 180.42,132.98 180.28,132.98 180.14,133.12 180.14,134.02 180.66,134.54 180.79,134.54
+1.35VS_VGA on BOTTOM (solid shape): 208.36,138.45 208.36,138.29 207.72,137.65 207.72,137.49 208.17,137.04 208.17,137.04 208.37,136.85 208.37,136.66 207.9,136.2 207.74,136.2 207.63,136.3 207.63,136.51 207.87,136.75 207.87,136.88 207.26,137.5 207.26,137.63 208.18,138.55 208.27,138.55
+1.35VS_VGA on BOTTOM (solid shape): 228.85,88.04 228.85,87.28 228.78,87.22 228.78,85.77 228.91,85.64 228.91,85.48 229.19,85.2 229.19,85.01 229.17,84.99 228.8,84.99 228.19,85.6 228.18,85.64 228.16,85.67 228.16,88.07 228.21,88.12 228.77,88.12
+1.35VS_VGA on BOTTOM (solid shape): 232.04,77.61 232.04,77.37 231.97,77.3 231.78,77.3 231.48,77.6 231.37,77.6 231.17,77.4 231.17,76.6 230.74,76.17 230.58,76.17 230.5,76.25 230.5,76.38 230.92,76.8 230.92,77.59 231.35,78.02 231.35,78.04 231.62,78.04
+1.35VS_VGA on BOTTOM (solid shape): 214.52,140.61 215.1,140.61 215.61,140.1 215.61,139.88 215.53,139.8 215.3,139.8 214.99,140.11 213.65,140.11 213.32,140.44 211.42,140.44 211.06,140.08 210.16,140.08 209.88,139.81 209.74,139.81 209.64,139.91 209.64,140.06 209.69,140.11 209.69,140.17 210.77,141.25 213.88,141.25
+1.35VS_VGA on BOTTOM (solid shape): 223.71,131.89 223.92,131.89 224.15,132.12 224.38,132.12 224.76,131.73 224.76,131.42 224.75,131.41 224.54,131.41 224.28,131.67 224.26,131.69 224.2,131.69 223.99,131.48 223.99,131.47 223.97,131.44 223.69,131.44 222.45,132.69 222.45,132.83 222.55,132.94 222.66,132.94
+1.35VS_VGA on BOTTOM (solid shape): 217.99,137.68 217.99,137.46 217.55,137.02 217.55,135.5 217.24,135.19 217.24,135.16 217.97,134.43 217.97,134.31 217.92,134.26 217.71,134.26 216.88,135.1 216.88,135.21 217.29,135.63 217.29,136.29 217.25,136.33 217.24,136.33 216.87,136.7 216.87,136.98 217.67,137.77 217.9,137.77
+1.35VS_VGA on BOTTOM (solid shape): 229.59,102.06 229.59,101.71 229.55,101.55 229.59,101.39 229.59,101.26 230.01,100.85 230.01,100.66 229.94,100.59 229.77,100.59 229.32,101.05 229.32,101.83 228.89,102.25 228.89,102.44 228.98,102.53 229.13,102.53
+1.35VS_VGA on BOTTOM (solid shape): 233.19,75.68 233.19,75.42 233.17,75.4 233.17,74.59 232.71,74.12 231.79,74.12 231.68,74.22 231.68,74.4 232.6,75.31 232.6,75.7 232.38,75.92 232.13,75.92 231.92,75.72 231.77,75.72 231.63,75.85 231.63,76 231.71,76.08 231.76,76.08 232.15,76.48 232.4,76.48
+1.35VS_VGA on BOTTOM (solid shape): 234.12,123.15 234.12,121.32 235.53,119.91 235.53,119.39 234.55,118.42 234.55,118.32 235.19,117.67 235.19,117.49 235.12,117.42 234.96,117.42 234.15,118.23 234.15,118.49 234.77,119.1 234.79,119.1 234.79,119.23 233.61,120.41 233.61,122.06 233.31,122.36 233.31,123.13 233.39,123.21 234.05,123.21
+1.35VS_VGA on BOTTOM (solid shape): 210.4,131.61 210.4,130.7 209.92,130.21 209.75,130.21 209.66,130.31 209.66,130.46 210.05,130.86 210.05,131 210.11,131.18 210.05,131.35 210.05,131.46 209.64,131.88 209.64,132.02 209.77,132.15 209.86,132.15
+1.35VS_VGA on BOTTOM (solid shape): 180.91,138.42 180.91,138.35 180.6,138.04 180.6,137.91 180.83,137.69 180.87,137.65 181.41,137.65 181.65,137.89 181.65,138.02 181.84,138.21 181.94,138.21 182.28,138.55 182.44,138.55 182.52,138.47 182.52,138.33 181.58,137.39 180.65,137.39 180.16,137.89 180.16,138.07 180.63,138.55 180.78,138.55
+1.35VS_VGA on BOTTOM (solid shape): 212.59,138.45 213.09,138.45 213.18,138.37 213.18,137.8 212.93,137.54 212.12,137.54 211.96,137.71 211.7,137.71 211.69,137.7 211.01,137.7 210.8,137.91 210.51,137.91 210.44,137.9 210.37,137.89 209.97,137.89 209.63,138.24 209.63,138.53 210.12,139.02 210.22,139.02 210.22,139.03 212.02,139.03
+1.35VS_VGA on BOTTOM (solid shape): 215.59,132.05 215.59,131.89 215.18,131.48 215.18,131.36 215.11,131.18 215.18,130.99 215.18,130.88 215.59,130.47 215.59,130.29 215.5,130.2 215.26,130.2 214.88,130.58 214.88,131.71 215.24,132.07 215.24,132.07 215.31,132.14 215.5,132.14
+1.35VS_VGA on BOTTOM (solid shape): 232.57,103.9 232.74,103.9 232.92,104.07 232.92,104.08 232.96,104.12 233.08,104.12 233.19,104.02 233.19,103.87 232.92,103.6 232.92,103.47 233.17,103.22 233.17,103.06 232.86,102.75 232.86,102.66 232.39,102.19 232.14,102.19 232.1,102.24 232.1,102.48 232.71,103.09 232.71,103.26 231.64,104.33 231.64,104.43 231.78,104.57 231.9,104.57
+1.35VS_VGA on BOTTOM (solid shape): 194.4,142.07 194.4,141.43 194.29,141.33 194.07,141.33 194.06,141.34 193.38,141.34 192.12,140.08 191.49,140.08 191.22,139.81 191.06,139.81 190.96,139.91 190.96,140.05 191.04,140.12 191.04,140.21 191.49,140.66 191.74,140.66 192.09,141.01 192.09,141.42 192.01,141.51 191.33,141.51 191.22,141.4 191.06,141.4 191.01,141.44 191.01,141.77 191.38,142.14 194.33,142.14
+1.35VS_VGA on BOTTOM (solid shape): 209.97,134.46 209.97,134.32 209.65,134 209.65,133.95 210.19,133.41 210.26,133.41 210.41,133.25 210.41,133.1 210.28,132.97 210.19,132.97 209.05,134.11 208.97,134.11 208.47,133.61 208.47,133.57 208.77,133.27 208.77,133.1 208.67,133 208.53,133 208.06,133.47 208.06,133.7 208.88,134.52 209.08,134.52 209.32,134.28 209.48,134.28 209.75,134.54 209.89,134.54
+1.35VS_VGA on BOTTOM (solid shape): 225.31,71.72 231.88,71.72 232.09,71.5 232.09,69.99 231.28,69.18 230.33,69.18 230.17,69.18 230.16,69.19 230.16,69.75 228.3,69.75 228.21,69.75 228.21,69.18 225.06,69.18 225.06,69.18 224.89,69.18 224.89,69.18 224.89,69.75 223.03,69.75 222.94,69.75 222.94,69.18 222.14,69.18 221.76,69.56 221.76,71.97 222.14,72.35 224.68,72.35
+1.35VS_VGA on BOTTOM (solid shape): 224.81,138.82 224.81,138.75 224.48,138.42 224.48,138.32 225.17,137.62 225.67,137.62 226.18,138.14 226.3,138.14 226.41,138.02 226.41,137.88 225.87,137.33 224.96,137.33 223.85,136.23 223.77,136.23 223.63,136.37 223.63,136.47 224.63,137.46 224.63,137.74 224.26,138.11 224.17,138.11 223.48,137.43 223.27,137.43 222.82,137.88 222.82,138.11 222.9,138.18 223.03,138.18 223.34,137.87 223.48,137.87 224.55,138.95 224.69,138.95
+1.35VS_VGA on BOTTOM (solid shape): 235.82,111.42 235.93,111.42 236.21,111.7 237.14,111.7 237.4,111.45 237.48,111.45 238.13,112.1 238.4,112.1 239.23,111.28 239.23,111.08 239.17,111.03 239.04,111.03 239.04,111.03 238.95,111.03 238.34,111.64 238.2,111.64 237.6,111.04 237.4,111.04 236.98,111.45 236.33,111.45 235.93,111.05 235.81,111.05 234.92,111.93 234.92,112.04 234.99,112.11 235.12,112.11
+1.35VS_VGA on BOTTOM (solid shape): 236.81,96.51 236.81,96.27 236.53,95.99 236.53,95.93 237.64,94.82 237.64,94.68 237.55,94.58 237.36,94.58 237.16,94.78 236.89,94.78 236.29,94.18 236.29,93.73 236.46,93.56 236.83,93.56 236.98,93.72 237.2,93.72 237.63,93.28 237.63,93.05 237.51,92.93 236.61,92.93 235.97,93.56 235.97,94.39 234.89,95.47 234.89,95.64 234.99,95.74 235.16,95.74 235.61,95.28 235.61,95.17 236.12,94.66 236.31,94.66 236.77,95.12 236.77,95.19 236.11,95.85 236.11,96.05 236.62,96.55 236.76,96.55
+1.35VS_VGA on BOTTOM (solid shape): 201.17,135.27 201.17,135.1 200.76,134.68 200.75,134.68 200.53,134.46 200.53,134.3 200.95,133.88 201.08,133.88 201.76,134.56 201.91,134.56 201.98,134.49 201.98,134.24 201.17,133.43 200.95,133.43 200.27,134.11 200.18,134.11 199.47,133.4 199.37,133.4 199.26,133.52 199.26,133.64 199.43,133.82 199.44,133.82 199.55,133.93 199.55,134.02 199.26,134.32 199.26,134.44 199.36,134.54 199.46,134.54 199.75,134.25 199.88,134.25 200.35,134.73 200.35,134.84 200.51,135 200.61,135 200.94,135.33 200.96,135.35 201.09,135.35
+1.35VS_VGA on BOTTOM (solid shape): 189.73,141.69 189.73,141.43 189.31,141.01 189.31,140.97 189.24,140.78 189.31,140.59 189.31,140.44 189.71,140.04 189.71,139.91 189.62,139.82 189.44,139.82 189.19,140.06 189.07,140.06 188.8,139.8 188.65,139.8 188.56,139.88 188.56,140.11 188.96,140.5 188.96,140.57 189.04,140.78 188.96,140.98 188.96,141.22 189.5,141.75 189.67,141.75
+1.35VS_VGA on BOTTOM (solid shape): 190.16,138.93 190.16,138.68 189.87,138.39 189.87,138.3 190.59,137.59 190.94,137.59 191.24,137.9 191.24,138.03 190.99,138.28 190.99,138.5 191.19,138.7 191.23,138.7 191.29,138.76 191.29,138.91 191.39,139.01 191.7,139.01 193.29,137.42 193.77,137.42 193.86,137.33 193.86,136.87 193.72,136.73 192.99,136.73 192.01,137.71 191.61,137.71 191.14,137.24 190.23,137.24 189.42,136.44 189.42,136.32 189.25,136.15 189.06,136.15 188.92,136.29 188.92,136.48 189.02,136.58 189.09,136.58 189.95,137.45 189.95,137.68 189.39,138.24 189.39,138.55 189.86,139.02 190.07,139.02
+1.35VS_VGA on BOTTOM (solid shape): 231.3,88.12 231.3,87.15 232.11,86.33 232.11,86.15 232.59,85.67 232.73,85.67 233.19,85.22 233.19,85.01 233.11,84.93 233.11,84.44 233.15,84.4 233.9,83.65 233.91,83.65 233.99,83.57 233.99,83.43 233.93,83.37 233.75,83.37 233.08,84.04 233.01,84.04 232.53,83.55 232.53,83.44 233.04,82.93 233.05,82.93 233.21,82.76 233.21,82.64 233.13,82.56 232.88,82.56 232.11,83.32 232.11,83.63 232.7,84.22 232.7,84.33 231.56,85.47 231.56,86.01 230.59,86.98 230.59,88.07 230.7,88.18 231.24,88.18
+1.35VS_VGA on BOTTOM (solid shape): 190.21,109.2 190.34,109.1 190.49,109.07 190.51,109.07 190.61,108.97 190.64,108.9 190.67,108.85 190.67,108.68 190.61,108.6 190.52,108.33 190.64,108.07 190.68,107.99 190.65,107.92 190.6,107.87 190.45,107.87 189.35,108.97 189.35,109.12 189.43,109.2
+1.35VS_VGA on BOTTOM (solid shape): 234.3,102.1 234.49,102.1 234.65,102.05 234.8,102.1 234.99,102.1 235.39,102.49 235.55,102.49 236.4,101.64 236.4,101.48 236.31,101.39 236.18,101.39 235.49,102.08 235.42,102.08 235.15,101.81 234.8,101.81 234.65,101.85 234.49,101.81 234.15,101.81 233.91,102.05 233.83,102.05 233.16,101.38 232.96,101.38 232.87,101.47 232.87,101.61 233.21,101.96 233.21,102.02 233.7,102.5 233.82,102.5 233.82,102.51 233.89,102.51
+1.35VS_VGA on BOTTOM (solid shape): 237.66,75.99 237.66,75.82 237.55,75.71 237.4,75.71 236.48,76.63 236.07,76.63 235.58,76.14 235.38,76.14 234.97,76.56 234.81,76.56 234.65,76.61 234.48,76.56 234.39,76.46 234.23,76.46 233.95,76.18 233.68,76.18 232.89,76.97 232.89,77.18 232.96,77.26 233.1,77.26 233.63,76.73 233.85,76.73 234.05,76.94 234.4,76.94 234.48,76.86 234.65,76.81 234.81,76.86 234.89,76.93 235.12,76.93 235.32,76.73 235.56,76.73 236.08,77.26 236.38,77.26
+1.35VS_VGA on BOTTOM (solid shape): 190.53,134.46 190.96,134.46 191.05,134.54 191.25,134.54 191.77,134.02 191.77,132.93 191.89,132.81 193.08,132.81 193.36,133.09 193.36,133.48 193.51,133.63 194.39,133.63 194.44,133.58 194.44,133 194.34,132.89 193.93,132.89 193.33,132.3 191.52,132.3 191.41,132.41 191.41,132.66 191.46,132.71 191.46,132.94 191.03,133.37 191.03,133.67 191.07,133.7 191.07,134.22 190.99,134.3 190.49,134.3 189.89,133.7 189.89,133.55 190.15,133.29 190.15,133.07 190.05,132.97 189.88,132.97 189.74,133.1 189.74,133.15 188.61,134.28 188.61,134.49 188.65,134.54 188.86,134.54 189.44,133.96 189.7,133.96 190.05,134.31 190.05,134.47 189.35,135.17 189.35,135.28 189.43,135.36 189.63,135.36
+1.35VS_VGA on BOTTOM (solid shape): 207.52,89.9 207.72,89.71 207.72,89.69 207.78,89.54 207.9,89.42 207.9,88.72 207.87,88.71 207.72,88.61 207.58,88.33 207.53,88.3 207.5,88.28 207.34,88.28 207.25,88.34 207.11,88.42 206.95,88.43 206.77,88.61 206.77,89.51 207.02,89.77 207.14,89.8 207.34,89.92 207.5,89.92
+1.35VS_VGA on BOTTOM (solid shape): 199.59,140.06 199.59,139.93 199.27,139.6 199.27,139.44 199.19,139.36 199.15,139.32 199.15,138.83 199.57,138.41 199.57,138.28 199.3,138.01 199.3,137.95 199.58,137.66 199.62,137.63 199.99,137.63 200.63,138.27 200.63,138.44 200.41,138.66 200.41,138.9 200.51,138.99 200.67,138.99 201.68,137.98 201.92,137.98 202.11,138.18 202.33,138.18 202.44,138.07 202.44,137.86 202,137.42 201.7,137.42 201.03,138.08 200.94,138.08 200.59,137.73 200.59,137.45 201.61,136.43 201.61,136.24 201.53,136.16 201.33,136.16 200.22,137.27 199.22,137.27 198.61,137.88 198.61,138.77 198.3,139.08 196.33,139.08 196.2,139.21 196.2,139.76 196.31,139.87 199.06,139.87 199.32,140.13 199.51,140.13
+1.35VS_VGA on BOTTOM (solid shape): 237.54,88.11 237.54,87.04 238.51,86.07 238.51,85.45 238.8,85.16 238.8,84.99 238.76,84.95 238.55,84.95 238.1,85.4 237.58,85.4 237.11,84.92 236.99,84.92 236.88,85.03 236.88,85.19 236.85,85.21 236.59,85.21 236.3,84.92 236.3,84.48 236.47,84.3 236.58,84.3 236.88,84 236.88,83.91 237.22,83.57 237.22,83.42 237.2,83.42 236.63,82.84 236.63,82.63 236.83,82.43 236.83,82.2 236.73,82.1 236.56,82.1 236.09,82.57 236.09,82.85 236.63,83.39 236.63,83.62 236.31,83.94 236.19,83.94 235.11,82.86 234.97,82.86 234.82,83.01 234.82,83.11 235.93,84.22 235.93,85 236.65,85.72 236.92,85.72 237.14,85.94 237.14,86.45 236.79,86.79 236.79,88.07 236.91,88.18 237.47,88.18
+1.35VS_VGA on BOTTOM (solid shape): 233.2,96.06 233.2,95.82 232.74,95.36 232.74,94.94 232.91,94.77 233.15,94.77 233.7,95.32 233.93,95.32 233.99,95.26 233.99,95.08 233.89,94.99 233.8,94.99 233.59,94.78 233.59,94.66 233.11,94.18 233.11,93.72 233.22,93.61 233.22,93.31 233,93.09 233,92.35 233.02,92.34 233.02,90.9 232.92,90.8 232.35,90.8 231.94,90.39 231.94,89.31 231.77,89.15 231.35,89.15 231.2,89.3 231.2,92.18 231.36,92.34 231.36,92.85 231.73,93.22 231.78,93.22 232.07,93.51 232.07,93.63 232.16,93.72 232.31,93.72 232.45,93.58 232.87,93.58 232.97,93.69 232.97,94.17 232.3,94.83 232.22,94.83 231.91,94.52 231.77,94.52 231.65,94.64 231.65,94.8 232.91,96.06 232.95,96.11 233.15,96.11
+1.35VS_VGA on BOTTOM (solid shape): 225.13,134.46 225.24,134.46 225.41,134.42 225.58,134.46 225.67,134.46 225.77,134.56 226.54,134.56 226.62,134.47 226.62,133.41 226.58,133.36 225.8,133.36 225.7,133.47 225.7,133.67 225.76,133.73 225.76,133.89 225.77,133.98 225.76,134.06 225.76,134.2 225.66,134.29 225.58,134.29 225.41,134.33 225.25,134.29 225.14,134.29 224.54,133.69 224.54,133.52 224.77,133.28 224.77,133.1 224.65,132.97 224.53,132.97 223.23,134.27 223.23,134.48 223.33,134.58 223.45,134.58 224.12,133.9 224.29,133.9 224.71,134.32 224.71,134.47 224.05,135.14 224.05,135.26 224.1,135.32 224.28,135.32
+1.35VS_VGA on BOTTOM (solid shape): 239.95,123.13 239.95,120.88 240.22,120.61 240.33,120.61 240.83,120.11 240.83,119.89 240.78,119.84 240.54,119.84 240.1,120.29 239.72,120.29 239.27,119.84 238.94,119.84 238.77,120.01 238.54,120.01 238.35,119.82 238.35,119.3 238.37,119.29 238.37,119.26 239.2,118.43 239.19,118.42 239.19,118.3 238.51,117.61 238.51,117.53 238.87,117.17 238.87,117.04 238.76,116.93 238.67,116.93 238.15,117.45 238.15,117.66 238.78,118.29 238.78,118.44 238.37,118.86 238.23,118.86 237.62,118.24 237.37,118.24 236.99,118.62 236.85,118.62 236.68,118.67 236.51,118.62 236.38,118.62 235.99,118.23 235.76,118.23 235.72,118.26 235.72,118.41 235.83,118.52 235.86,118.52 236.22,118.89 237.15,118.89 237.43,118.6 237.52,118.6 238.02,119.1 238.02,119.94 238.38,120.3 238.38,121.84 238.19,122.04 238.19,122.56 238.26,122.63 238.98,122.63 239.09,122.75 239.09,123.2 239.18,123.29 239.79,123.29
+1.35VS_VGA on BOTTOM (solid shape): 204.86,109.27 205.01,109.11 205.23,109.07 205.25,109.07 205.3,109.03 205.3,108.99 205.3,108.59 205.22,108.35 205.3,108.11 205.3,107.92 205.2,107.82 203.42,107.82 203.42,107.88 203.43,107.93 203.44,107.96 203.48,107.97 203.84,108.18 203.79,108.6 203.73,108.68 203.73,108.85 203.76,108.9 203.79,108.97 203.89,109.07 203.91,109.07 204.1,109.13 204.24,109.27
+1.35VS_VGA on BOTTOM (solid shape): 206.71,106.7 206.96,106.57 207.23,106.64 207.32,106.7 207.53,106.7 207.58,106.67 207.64,106.65 207.7,106.62 207.72,106.55 207.76,106.36 207.9,106.22 207.9,105.52 207.88,105.51 207.7,105.39 207.62,105.18 207.62,105.17 207.58,105.13 207.53,105.1 207.5,105.08 207.34,105.08 207.21,105.17 207.17,105.24 207.2,105.32 207.21,105.33 207.22,105.76 206.78,105.76 206.76,105.74 206.51,105.66 206.45,105.66 206.45,106.6 206.55,106.7
+1.35VS_VGA on BOTTOM (solid shape): outline of 100 points within 200.86,138.55 206.8,141.48
+1.35VS_VGA on BOTTOM (solid shape): 204.46,86.89 205.06,86.89 205.22,86.72 205.23,86.55 205.31,86.4 205.37,86.31 205.37,86.15 205.34,86.11 205.32,86.06 205.17,85.92 205.17,85.82 204.17,85.82 204.05,85.9 203.91,85.93 203.89,85.93 203.79,86.03 203.76,86.1 203.73,86.15 203.73,86.31 203.79,86.4 203.5,87.03 203.21,86.4 203.27,86.31 203.27,86.15 203.26,86.13 202.95,85.82 202.07,85.82 201.97,85.89 201.86,85.93 201.84,85.93 201.65,86.13 201.63,86.15 201.63,86.31 201.72,86.43 201.79,86.48 201.87,86.45 201.89,86.43 202.12,86.35 202.34,86.46 202.49,86.61 202.49,86.87 202.87,87.25 204.1,87.25
+1.35VS_VGA on BOTTOM (solid shape): 196.2,87.03 196.2,86.64 196.39,86.37 196.72,86.43 196.73,86.45 196.81,86.48 196.88,86.43 196.97,86.31 196.97,86.15 196.95,86.12 196.92,86.07 196.78,85.93 196.77,85.93 196.59,85.87 196.46,85.72 195.75,85.72 195.35,86.13 195.33,86.15 195.33,86.31 195.39,86.4 195.1,87.03 194.81,86.4 194.87,86.31 194.87,86.17 194.71,86.01 194.57,85.91 194.46,85.84 194.37,85.75 193.73,85.75 193.61,85.87 193.46,85.93 193.44,85.93 193.24,86.13 193.23,86.15 193.23,86.31 193.29,86.4 193.38,86.69 193.23,86.96 193.23,87.1 193.35,87.22 196,87.22
+1.35VS_VGA on BOTTOM (solid shape): outline of 130 points within 218.03,138.57 224.37,141.74
+1.35VS_VGA on BOTTOM (solid shape): 201.2,87.14 201.2,86.97 201.02,86.71 201.11,86.4 201.17,86.31 201.17,86.15 201.16,86.13 200.83,85.8 199.99,85.8 199.86,85.9 199.71,85.93 199.69,85.93 199.59,86.03 199.56,86.1 199.53,86.15 199.53,86.31 199.59,86.4 199.3,87.03 199.01,86.4 199.07,86.31 199.07,86.15 199.05,86.12 199.02,86.08 198.73,85.92 198.64,85.78 198.63,85.75 197.93,85.75 197.79,85.88 197.61,85.93 197.59,85.93 197.49,86.03 197.46,86.1 197.43,86.15 197.43,86.31 197.49,86.4 197.54,86.82 197.18,87.03 197.14,87.04 197.13,87.07 197.11,87.12 197.13,87.21 197.21,87.25 201.09,87.25
+1.35VS_VGA on BOTTOM (solid shape): outline of 181 points within 236.05,94.97 243.43,110.52
+1.35VS_VGA on BOTTOM (solid shape): 192.25,109.29 192.39,109.13 192.59,109.07 192.61,109.07 192.71,108.97 192.74,108.9 192.77,108.85 192.77,108.68 192.71,108.6 193,107.97 193.29,108.6 193.23,108.68 193.23,108.85 193.27,108.91 193.3,108.99 193.3,109 193.34,109.04 193.46,109.07 193.61,109.13 193.73,109.25 194.42,109.25 194.55,109.12 194.72,109.07 194.73,109.07 194.8,109 194.8,108.99 194.83,108.91 194.87,108.85 194.87,108.68 194.81,108.6 195.1,107.97 195.39,108.6 195.33,108.68 195.33,108.85 195.36,108.89 195.38,108.94 195.39,108.95 195.66,109.09 195.75,109.22 196.57,109.22 196.64,109.14 196.74,109.07 196.89,108.96 196.94,108.89 196.97,108.85 196.97,108.68 196.88,108.56 196.81,108.52 196.73,108.55 196.72,108.56 196.29,108.56 196.29,108.13 196.31,108.11 196.39,107.88 196.39,107.82 192.35,107.82 191.9,108.27 191.9,108.35 191.72,108.63 191.39,108.57 191.32,108.54 191.25,108.57 191.15,108.67 191.15,108.88 191.18,108.93 191.58,109.32 192.24,109.32
+1.35VS_VGA on BOTTOM (solid shape): 206.45,104.83 206.49,104.9 206.57,104.92 206.61,104.91 206.62,104.87 206.83,104.51 207.25,104.56 207.34,104.62 207.5,104.62 207.55,104.59 207.62,104.56 207.72,104.46 207.72,104.44 207.76,104.27 207.88,104.14 207.88,103.41 207.85,103.4 207.69,103.27 207.62,103.08 207.62,103.07 207.58,103.03 207.53,103 207.5,102.98 207.35,102.98 207.23,103.05 206.62,102.75 207.23,102.44 207.35,102.52 207.5,102.52 207.52,102.5 207.72,102.31 207.72,102.29 207.77,102.15 207.88,102.04 207.88,101.36 207.77,101.24 207.72,101.08 207.72,101.07 207.58,100.93 207.53,100.9 207.5,100.88 207.34,100.88 207.25,100.94 206.62,100.65 207.25,100.36 207.34,100.42 207.5,100.42 207.52,100.4 207.72,100.21 207.72,100.19 207.78,100.04 207.9,99.92 207.9,99.28 207.77,99.15 207.72,98.98 207.72,98.97 207.58,98.83 207.53,98.8 207.5,98.78 207.34,98.78 207.21,98.87 207.17,98.94 207.2,99.02 207.21,99.03 207.22,99.46 206.78,99.46 206.76,99.44 206.51,99.36 206.45,99.36
+1.35VS_VGA on BOTTOM (solid shape): 200.66,109.27 200.8,109.12 200.99,109.07 201.01,109.07 201.11,108.97 201.14,108.9 201.17,108.85 201.17,108.68 201.11,108.6 201.4,107.97 201.69,108.6 201.63,108.68 201.63,108.85 201.65,108.88 201.68,108.92 201.98,109.08 202.07,109.24 202.08,109.27 202.76,109.27 202.9,109.13 203.09,109.07 203.11,109.07 203.21,108.97 203.24,108.9 203.27,108.85 203.27,108.68 203.18,108.56 203.11,108.52 203.03,108.55 203.02,108.56 202.59,108.56 202.59,108.13 202.61,108.11 202.69,107.88 202.69,107.82 197.12,107.82 197.12,107.88 197.13,107.93 197.14,107.96 197.18,107.97 197.54,108.18 197.49,108.6 197.43,108.68 197.43,108.85 197.46,108.9 197.49,108.97 197.59,109.07 197.61,109.07 197.8,109.13 197.94,109.27 198.56,109.27 198.71,109.12 198.91,109.07 198.93,109.07 199,109 199,108.99 199.03,108.91 199.07,108.85 199.07,108.68 199.01,108.6 199.3,107.97 199.59,108.6 199.53,108.68 199.53,108.85 199.56,108.89 199.58,108.94 199.77,109.12 199.77,109.17 199.9,109.3 200.65,109.3
+1.35VS_VGA on BOTTOM (solid shape): outline of 82 points within 206.4,90.38 207.9,98.62
+1.35VS_VGA on IN1 (solid shape): outline of 1199 points within 190.25,98.75 208.3,109.65
+1.35VS_VGA on IN5 (solid shape): outline of 1567 points within 189.94,87.06 208.29,109.31
+1.35VS_VGAP on BOTTOM (solid shape): 235.41,70.33 235.41,59.65 235.22,59.46 232.55,59.46 232.17,59.84 232.17,63.4 231.09,64.48 222.58,64.48 222.33,64.73 222.33,68.79 222.52,68.99 231.34,68.99 233.12,70.76 234.98,70.76
+1V8_AON on TOP (solid shape): 184.47,88.73 185.1,88.73 185.4,88.73 185.41,88.73 185.94,88.73 186.26,88.42 186.26,87.53 186.07,87.34 186.07,87.24 186.07,87.24 186.07,86.89 185.94,86.77 185.94,85.56 186.2,85.3 186.64,85.3 186.7,85.24 186.7,84.52 186.4,84.22 185.58,84.22 185.2,84.61 184.83,84.61 184.7,84.73 183.02,84.73 182.89,84.61 182.2,84.61 182.13,84.67 182.13,85.18 182.19,85.23 182.24,85.23 182.28,85.24 182.77,85.24 182.86,85.33 182.9,85.33 183.75,85.33 184.16,85.74 185.39,85.74 185.5,85.85 185.5,87.8 185.48,88.31 184.99,88.14 184.98,88.1 184.23,88.1 183.97,88.35 183.97,88.48 184.23,88.73 184.46,88.73
+1V8_AON on BOTTOM (solid shape): 169.17,85.09 169.6,84.66 171.5,84.66 171.58,84.58 171.58,84.13 171.48,84.03 169.99,84.03 168.92,82.96 167.4,82.96 167.04,83.32 167.04,85.97 167.28,86.2 169.17,86.2
+1V8_AON on BOTTOM (solid shape): 196.55,74.07 196.55,73.77 197.35,72.97 197.35,72.03 197.28,71.97 195.34,71.97 195.28,72.03 195.28,72.92 195.47,73.11 195.47,73.94 195.72,74.19 196.42,74.19
+1V8_AON on BOTTOM (solid shape): 193.21,71.63 193.21,70.78 193.28,70.7 193.82,70.7 193.88,70.64 193.88,69.68 193.63,69.43 193.63,68.73 193.44,68.54 192.23,68.54 191.9,68.87 191.9,68.96 191.85,68.96 191.85,70.27 192,70.42 192,71.55 192.18,71.73 193.1,71.73
+1V8_AON on IN2 (solid shape): outline of 1883 points within 177.75,57.68 197.63,76.19
+1V8_AON on IN3 (solid shape): outline of 355 points within 184.55,79.22 188.1,88.73
+1V8_MAIN on TOP (solid shape): 178.72,92.26 178.72,90.63 178.61,90.52 177.34,90.52 177.29,90.58 177.29,91.4 177.34,91.45 177.89,91.45 178.18,91.74 178.18,91.95 177.95,92.18 177.67,92.18 177.54,92.32 177.54,92.51 177.7,92.67 178.31,92.67
+1V8_MAIN on TOP (solid shape): outline of 194 points within 183.95,96.11 187.31,101.93
+1V8_MAIN on TOP (solid shape): outline of 460 points within 186.85,80.73 193.68,88.7
+1V8_MAIN on BOTTOM (solid shape): 191.66,75.27 191.66,74.85 192.06,74.45 192.97,74.45 193.16,74.26 193.25,74.13 193.38,74.05 193.52,73.9 193.52,73.09 193.88,72.73 193.88,72.03 193.82,71.97 192.24,71.97 192.2,71.93 189.66,71.93 189.64,71.96 189.64,72.57 189.71,72.64 190.21,72.64 190.46,72.9 190.46,74.34 190.17,74.64 188.99,74.64 188.96,74.67 188.96,75.31 189.05,75.4 191.53,75.4
+1V8_MAIN on BOTTOM (solid shape): 185.89,101.36 185.89,100.66 185.85,100.58 185.76,100.57 185.72,100.58 185.69,100.59 185.68,100.63 185.48,100.99 185.07,100.95 184.95,100.88 184.8,100.88 184.74,100.92 184.66,100.95 184.61,100.98 184.58,101.05 184.54,101.23 184.41,101.37 184.41,101.61 184.47,101.67 185.58,101.67
+1V8_MAIN on BOTTOM (solid shape): 192.8,87.07 192.8,86.98 192.62,86.71 192.71,86.4 192.71,86.4 192.71,86.06 192.63,85.98 192.62,85.98 192.44,85.91 192.32,85.78 192.31,85.75 191.63,85.75 191.51,85.87 191.36,85.93 191.34,85.93 191.15,86.13 191.13,86.15 191.13,86.3 191.21,86.42 190.9,87.03 190.59,86.42 190.67,86.3 190.67,86.15 190.65,86.12 190.62,86.07 190.52,85.97 190.51,85.97 190.37,85.89 190.28,85.77 190.15,85.77 190.03,85.9 189.75,85.9 189.62,85.77 189.4,85.77 189.05,86.13 189.03,86.15 189.03,86.3 189.11,86.42 188.8,87.03 188.5,86.42 188.57,86.3 188.57,86.15 188.55,86.12 188.52,86.07 188.38,85.93 188.37,85.93 188.24,85.9 188.13,85.82 187.37,85.82 187.3,85.88 187.21,85.92 186.85,86.27 186.85,87.05 187.03,87.22 192.65,87.22
+1V8_MAIN on IN1 (solid shape): outline of 3342 points within 180.16,72.41 192.86,101.5
+1V8_MAIN on IN4 (solid shape): outline of 5952 points within 170.73,70.38 186.26,104.6
+1V_MPHY on TOP (solid shape): outline of 3579 points within 155.87,29.06 169.99,44.97
+1V_MPHY on BOTTOM (solid shape): 160.88,31.93 160.88,31.79 160.76,31.68 160.5,31.68 160.35,31.53 159.98,31.53 159.26,30.81 159.26,29.8 159.46,29.61 160.03,29.61 160.8,30.37 160.8,31.02 160.94,31.16 160.94,31.39 161.04,31.49 161.14,31.49 161.18,31.48 161.22,31.48 161.38,31.32 161.38,31.15 161.2,30.92 161.3,30.65 161.3,29.69 160.35,28.75 158.05,28.75 157.55,29.25 157.55,29.27 157.16,29.66 157.16,30.64 157.6,31.08 158.56,31.08 159.52,32.03 159.91,32.03 160.17,31.93 160.4,32.09 160.72,32.09
