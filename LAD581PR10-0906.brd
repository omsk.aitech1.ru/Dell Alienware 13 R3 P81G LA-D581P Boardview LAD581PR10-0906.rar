# Allegro board LAD581PR10-0906.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1V_PCH on TOP (solid shape): outline of 2310 points within 155.36,42.16 168.56,55.46
+1V_PCH on BOTTOM (solid shape): 175.84,50.3 175.84,50.06 175.71,49.93 175.32,49.93 174.8,50.45 174.19,50.45 174.1,50.36 173.74,50.36 173.64,50.45 173.64,50.66 173.72,50.74 175.41,50.74
+1V_PCH on IN3 (solid shape): outline of 2275 points within 163.64,41.31 176.45,57.67
+1V_PCH_PRIM on TOP (solid shape): outline of 1396 points within 167.9,39.27 173.93,55.42
+1VALW on TOP (solid shape): 155.41,46.5 156.79,46.5 156.79,45.93 157.29,45.93 157.29,46.5 157.55,46.5 157.61,46.43 157.61,45.2 157.47,45.06 157.47,43.62 157.43,43.58 153.6,43.58 153.32,43.85 153.32,46.65 153.56,46.89 155.02,46.89
+1VALW on TOP (solid shape): 170.4,57.7 170.73,57.7 171.25,57.18 171.25,55.71 171.09,55.54 170.82,55.54 170.82,55.56 170.41,55.56 170.41,56.12 169.97,56.12 169.97,55.56 169.56,55.56 169.56,55.54 168.89,55.54 168.58,55.86 168.58,57.52 169.07,58.01 170.1,58.01
+1VALW on TOP (solid shape): outline of 248 points within 145.73,69.54 154.25,76.02
+1VALW on BOTTOM (solid shape): 184.16,20.62 183.65,20.62 183.65,19.91 184.16,19.91 184.16,19.42 183.65,19.42 183.65,18.71 184.12,18.71 184.15,18.65 184.16,18.63 184.16,15.42 183.62,15.42 183.62,14.67 184.16,14.67 184.16,14.23 183.62,14.23 183.62,13.47 184.16,13.47 184.16,12.93 184.09,12.85 181.7,12.85 181.26,13.29 181.26,16.9 181.04,17.13 181.04,20.86 181.41,21.23 184.16,21.23
+1VALW on VCC: 180.59,17.49 172.72,25.35 149.99,25.35 150.05,76.09 160.85,76.09 160.85,72.04 170.38,62.53 170.38,55.42 171.42,54.38 184.29,54.38 184.29,17.49
+1VALWP on BOTTOM (solid shape): outline of 92 points within 183.77,12.87 200.92,23.28
+1VALWP_B+ on TOP (solid shape): 207.72,17.23 207.72,15.73 207.27,15.28 205.88,15.28 205.18,15.98 205.18,16.3 205.74,16.3 205.74,16.87 205.18,16.87 205.18,17.44 205.33,17.59 207.36,17.59
+1VALWP_B+ on BOTTOM (solid shape): 207.72,19.09 209.36,19.09 209.42,19.03 209.42,17.7 209.3,17.57 207.84,17.57 207.64,17.37 207.64,16.64 208.29,15.98 208.29,14.39 208.17,14.27 205.43,14.27 205.31,14.39 205.31,16.11 204.99,16.43 204.99,19.26 205.08,19.35 207.47,19.35
+1VALWP_PGOOD on TOP (solid shape): 89.03,11.03 89.34,11.03 89.42,10.95 89.42,10.5 89.17,10.25 89.16,10.25 89.16,10 88.78,9.62 86.24,9.62 86.16,9.7 86.16,9.79 86.22,9.85 88.24,9.85 88.59,10.2 88.59,10.85 88.77,11.03 89.03,11.03
+2.5V_MEM on TOP (solid shape): 149.43,53.18 149.43,51.08 149.68,50.82 149.68,48.05 149.49,47.86 148.97,47.86 148.79,48.03 148.79,49.43 148.48,49.74 148.48,53.24 148.55,53.31 149.3,53.31
+2.5V_MEM on TOP (solid shape): 151.21,39.54 151.21,35.73 151.08,35.6 150.39,35.6 149.93,36.07 149.61,36.07 149.43,36.25 149.43,39.54 149.68,39.79 150.95,39.79
+2.5V_MEM on BOTTOM (solid shape): 150.29,50.51 150.29,47.9 150.06,47.67 148.09,47.67 147.86,47.91 147.86,50.75 147.96,50.85 149.95,50.85
+2.5V_MEM on BOTTOM (solid shape): 150.68,38.74 150.81,38.61 150.81,37.4 151.97,36.24 151.97,35.98 151.33,35.35 151.21,35.35 150.38,36.18 147.92,36.18 147.86,36.24 147.86,38.51 148.09,38.74 150.01,38.74
+2.5V_MEM on BOTTOM (solid shape): 159.35,24.03 159.35,23.62 158.8,23.62 158.8,23.07 159.34,23.07 159.34,22.82 158.79,22.82 158.79,22.27 159.34,22.27 159.34,21.76 157.19,21.76 157,21.95 157,23.85 157.23,24.08 159.29,24.08
+2.5V_MEMP on BOTTOM (solid shape): 164.89,29.64 166.07,29.64 166.1,29.62 166.1,28.51 166.07,28.49 165.5,28.49 165.39,28.6 164.44,28.6 164.43,28.59 163.96,28.59 163.81,28.44 163.81,25.49 163.66,25.34 163.02,25.34 162.9,25.47 162.9,27.07 162.57,27.39 161.81,27.39 161.49,27.08 161.48,27.08 161.48,21.98 161.34,21.84 159.53,21.84 159.5,21.87 159.5,22.42 158.95,22.42 158.95,22.67 159.5,22.67 159.5,23.22 158.94,23.22 158.94,23.47 159.49,23.47 159.49,24.74 159.97,25.21 159.97,27.58 162.26,29.87 164.67,29.87
+2.5VOUT on IN2 (solid shape): outline of 445 points within 100.31,144.56 108.83,155.66
+2.5VSP_VIN on BOTTOM (solid shape): 163.77,21.96 163.77,20.02 164.24,19.55 164.24,18.2 164.24,18.2 164.24,17.92 164.48,17.68 165.31,17.68 165.38,17.61 165.69,17.61 165.76,17.68 166.67,17.68 166.68,17.67 166.8,17.65 166.93,17.67 166.94,17.68 167.22,17.68 167.4,17.5 167.4,16.35 167.01,16.35 167.01,16.87 166.51,16.87 166.51,16.35 166.21,16.35 166.21,16.87 165.71,16.87 165.71,16.35 163.94,16.35 163.53,16.77 163.53,18.85 163.53,18.87 162.88,19.52 162.88,21.95 163.05,22.12 163.6,22.12
+3.3V_1.8V_DVDD on TOP (solid shape): 32.99,39.46 33.2,39.32 33.45,39.35 33.46,39.36 33.63,39.36 33.63,39.36 33.76,39.36 33.77,39.36 33.89,39.33 34.02,39.36 34.03,39.36 34.34,39.36 34.49,39.2 34.49,39.03 34.66,38.86 35.47,38.86 35.61,38.71 35.61,37.26 35.56,37.21 34.68,37.21 34.65,37.18 34.65,36.92 34.58,36.85 34.18,36.85 34.08,36.95 34.08,37.61 34.08,38.03 33.68,38.17 33.68,38.16 33.28,38.16 33.19,38.25 33.19,38.6 33.08,38.71 32.53,38.71 32.47,38.78 32.47,39.41 32.52,39.46
+3.3V_1.8V_DVDD_IO on BOTTOM (solid shape): 27.72,35.02 27.72,34.17 27.97,33.92 27.97,33.57 28.51,33.03 28.51,29.22 28.45,29.16 27.77,29.16 27.61,29.32 27.61,33.83 27.5,33.94 27.5,35.01 27.57,35.08 27.66,35.08
+3.3V_F383 on TOP (solid shape): 117.18,19.14 117.18,17.54 116.99,17.35 115.69,17.35 115.47,17.56 115.47,19.05 115.67,19.25 117.07,19.25
+3.3V_F383 on TOP (solid shape): 141.87,22.71 141.87,21.82 141.74,21.7 138.95,21.7 138.89,21.76 138.89,22.71 138.95,22.78 141.81,22.78
+3.3V_F383 on TOP (solid shape): 162.7,92.69 162.7,91.72 163.33,91.09 163.33,90.4 163.08,90.15 162.38,90.15 162.27,90.27 161.69,90.85 161.69,92.86 161.81,92.99 162.4,92.99
+3.3V_F383 on TOP (solid shape): 174.64,137.37 174.64,136.61 174.45,136.42 172.99,136.42 172.86,136.55 172.86,137.25 173.18,137.57 174.45,137.57
+3.3V_F383 on TOP (solid shape): 268.07,38.63 268.07,37.06 269.14,35.99 269.14,35.55 269,35.41 265.83,35.41 265.7,35.54 265.7,36.02 266.75,37.06 266.75,38.58 266.94,38.77 267.94,38.77
+3.3V_F383 on TOP (solid shape): 74.37,3.45 74.37,2.95 74.5,2.82 74.5,2.62 74.97,2.15 74.97,1.73 74.58,1.34 72.9,1.34 72.87,1.37 72.87,1.91 72.95,1.98 73.26,1.98 73.27,1.98 73.5,1.98 73.63,2.1 73.63,3.47 73.8,3.64 74.18,3.64
+3.3V_F383 on TOP (solid shape): outline of 85 points within 168.47,20.85 174.94,22.76
+3.3V_F383 on BOTTOM (solid shape): 72.4,13.42 72.4,11.33 72.72,11.01 74.12,11.01 74.69,10.44 74.69,9.61 74.5,9.42 73.17,9.42 71.64,10.95 71.64,13.42 71.77,13.55 72.28,13.55
+3.3V_F383 on BOTTOM (solid shape): 74.31,3.39 74.31,1.99 73.86,1.55 71.71,1.55 71.58,1.68 71.58,1.99 71.77,2.18 73.42,2.18 73.55,2.31 73.55,3.45 73.74,3.64 74.06,3.64
+3.3V_F383 on BOTTOM (solid shape): outline of 665 points within 253.32,36.09 274.27,52.35
+3.3V_F383 on IN1 (solid shape): 196.74,24.79 196.74,23.96 196.61,23.84 195.15,23.84 194.83,24.15 194.83,24.6 195.15,24.92 196.61,24.92
+3.3V_F383 on IN1 (solid shape): 254.46,39.52 254.46,39.01 253.51,38.06 253.44,38.06 253.06,38.44 253.06,39.39 253.38,39.71 254.27,39.71
+3.3V_F383 on IN1 (solid shape): outline of 476 points within 67.64,0.91 76.21,10.95
+3.3V_F383 on IN2 (solid shape): 175.46,138.45 175.46,137.85 175.08,137.47 175.08,136.61 174.93,136.45 174.1,136.45 174,136.55 174,137.82 175.02,138.84 175.08,138.84
+3.3V_F383 on IN2 (solid shape): 188.42,150.52 188.42,147.79 185.56,144.93 185.5,144.93 184.83,145.6 184.83,146.42 185.5,147.09 186.26,147.09 187.53,148.36 187.53,150.52 187.78,150.77 188.16,150.77
+3.3V_F383 on IN4 (solid shape): 140.98,23.6 140.98,22.08 140.79,21.89 139.84,21.89 139.71,22.01 139.71,23.6 139.84,23.73 140.86,23.73
+3.3V_F383 on IN4 (solid shape): 163.33,90.85 163.33,90.53 161.81,89.01 161.62,89.01 161.11,89.52 161.11,89.77 162.55,91.21 162.97,91.21
+3.3V_F383 on IN4 (solid shape): 195.98,24.22 195.98,23.96 195.66,23.65 195.4,23.65 194.74,22.98 194.45,22.98 194.06,23.37 194.06,23.7 194.83,24.47 195.72,24.47
+3.3V_F383 on IN4 (solid shape): 175.05,21.5 178.72,21.5 179.08,21.14 179.08,20.25 178.92,20.08 173.75,20.08 171.49,22.34 170.44,22.34 170.19,22.09 170.19,21.65 170.12,21.59 169.61,21.59 169.57,21.63 169.57,23.58 169.71,23.72 172.83,23.72
+3.3V_F383 on IN5 (solid shape): 77.36,9.91 77.36,9.01 77.19,8.83 73.34,8.83 73.19,8.98 73.19,9.84 73.49,10.14 77.13,10.14
+3.3V_F383 on IN5 (solid shape): 117.29,18.79 117.29,17.83 116.83,17.37 115.51,17.37 115.23,17.65 115.23,18.79 115.41,18.98 117.1,18.98
+3V_PCH on TOP (solid shape): 179.42,45.32 179.42,44.88 179.68,44.62 180.87,44.62 180.94,44.55 180.94,44.07 180.84,43.97 180.36,43.97 179.67,43.28 179.02,43.28 178.97,43.33 178.97,43.85 179.08,43.96 179.08,44.35 178.86,44.57 178.86,45.34 178.87,45.36 179.39,45.36
+3V_PCH on TOP (solid shape): 162.07,62.51 162.07,61.56 161.05,60.54 157.68,60.54 156.86,59.71 156.86,59.46 156.73,59.33 152.92,59.33 152.8,59.46 152.8,60.1 152.86,60.16 153.37,60.16 153.62,60.41 153.62,60.73 154.7,61.81 160.29,61.81 160.61,62.13 160.61,62.44 160.86,62.7 161.88,62.7
+3V_PCH on BOTTOM (solid shape): 182.79,52.67 182.79,51.04 182.58,50.83 182.13,50.83 181.94,51.02 181.68,51.02 181.62,51.09 181.62,51.72 181.74,51.85 182,51.85 182.13,51.98 182.13,52.7 182.22,52.79 182.67,52.79
+3V_PCH on BOTTOM (solid shape): 175.78,33.35 175.78,33.23 175.82,33.2 175.82,32.97 175.78,32.88 175.69,32.87 175.41,32.82 175.28,32.58 175.27,32.53 174.57,32.53 174.52,32.55 174.47,32.55 174.42,32.55 174.38,32.55 174.33,32.53 173.94,32.53 173.76,32.7 173.76,32.79 174.08,33.11 174.08,33.12 174.37,33.41 174.81,33.41 174.89,33.32 174.93,33.32 174.94,33.32 175.05,33.3 175.15,33.32 175.16,33.32 175.18,33.32 175.33,33.47 175.66,33.47
+3V_PCH on BOTTOM (solid shape): 181.49,33.32 181.49,33.04 181.6,32.93 181.6,32.93 181.98,32.93 182.17,32.74 183.2,32.74 183.4,32.54 183.4,32.02 184.41,31 185.74,31 185.93,30.81 185.93,30.18 185.87,30.11 184.85,30.11 184.73,30.24 183.84,30.24 182.53,31.55 181.69,31.55 181.58,31.66 181.58,31.98 181.41,32.16 181.1,32.16 180.98,32.04 180.98,31.02 181.07,30.94 181.07,30.41 181.36,30.11 184.47,30.11 185.04,29.54 185.93,29.54 186.12,29.73 186.12,30.94 185.81,31.26 185.81,31.76 185.93,31.89 186.57,31.89 187.01,31.45 187.01,29.22 186.57,28.78 184.79,28.78 184.22,29.35 180.53,29.35 180.11,29.78 180.11,30.51 179.78,30.85 179.78,30.89 179.9,31.02 180.41,31.02 180.54,31.15 180.54,32.22 180.81,32.49 180.81,33.34 180.93,33.45 181.35,33.45
+3V_PCH on IN3 (solid shape): outline of 12727 points within 154.32,20.88 188.55,63.02
+3V_PCH on IN5 (solid shape): outline of 501 points within 176.35,49.18 183.8,53.48
+3VALW on TOP (solid shape): 88.78,22.66 88.78,20.54 88.71,20.47 88.24,20.47 88.12,20.59 88.12,22.68 88.2,22.77 88.68,22.77
+3VALW on TOP (solid shape): 149.62,167.73 149.62,166.9 149.3,166.58 147.72,166.58 147.65,166.65 147.65,168.05 147.84,168.24 149.11,168.24
+3VALW on TOP (solid shape): 105.11,6.99 105.11,4.22 104.22,3.33 103.07,3.33 102.72,3.68 102.72,4.43 101.67,5.47 101.67,7.26 101.87,7.46 103.55,7.46 103.59,7.5 104.6,7.5
+3VALW on TOP (solid shape): 91.99,6.54 91.99,4.41 91.61,4.04 91.61,3.49 91.49,3.37 90.88,3.37 90.83,3.42 90.83,3.96 91.76,4.89 91.76,6.54 91.82,6.59 91.94,6.59
+3VALW on TOP (solid shape): 91.58,27.86 91.58,26.98 91.54,26.95 90.95,26.95 90.88,27.01 90.13,27.01 89.97,26.85 89.69,26.85 89.61,26.93 89.61,27.26 90.26,27.9 91.54,27.9
+3VALW on TOP (solid shape): 118.95,10.44 118.95,10.31 118.82,10.18 118.82,8.72 118.25,8.15 116.92,8.15 116.77,8.3 116.77,8.38 116.6,8.55 116.6,9.99 116.73,10.12 117.49,10.12 117.89,10.52 118.86,10.52
+3VALW on TOP (solid shape): 97.18,6.54 97.18,4.88 97.5,4.57 97.5,4.09 97.74,3.85 97.74,3.33 97.55,3.14 96.86,3.14 96.73,3.26 96.73,4.21 96.91,4.38 96.91,4.76 96.97,4.82 96.97,6.54 97.03,6.61 97.12,6.61
+3VALW on TOP (solid shape): 146.89,60.54 146.89,60.29 146.57,59.97 146.57,59.02 146.76,58.83 148.8,58.83 149.37,59.4 149.91,59.4 149.96,59.35 149.97,59.35 149.97,57.96 149.72,57.71 146.55,57.71 145.68,58.57 145.68,60.54 145.81,60.67 146.76,60.67
+3VALW on TOP (solid shape): 242.39,16.79 242.39,15.58 242.52,15.45 246.08,15.45 246.27,15.26 246.27,12.28 245.89,11.9 244.01,11.9 242.51,12.84 240.74,12.67 240.74,16.79 240.81,16.85 242.33,16.85
+3VALW on TOP (solid shape): outline of 98 points within 69.36,3.49 87.94,9.49
+3VALW on TOP (solid shape): outline of 116 points within 123.42,1.23 148.03,2.98
+3VALW on TOP (solid shape): outline of 121 points within 124.21,5.93 145.63,9.31
+3VALW on BOTTOM (solid shape): 56.84,63.83 56.84,61.17 56.77,61.1 55.95,61.1 55.76,61.29 53.22,61.29 52.84,61.67 52.84,63.96 53.15,64.28 56.39,64.28
+3VALW on BOTTOM (solid shape): 94.06,105.9 94.06,105.77 94.61,105.21 95.5,105.21 95.52,105.2 95.52,103.99 95.45,103.93 94.75,103.93 94.63,104.06 94.63,104.25 93.14,105.73 93.14,105.92 93.22,106 93.95,106
+3VALW on BOTTOM (solid shape): 166.95,157.64 166.95,155.67 165.75,154.48 165.75,154.22 165.68,154.16 165.49,154.16 165.43,154.22 165.43,154.98 166.19,155.75 166.19,157.57 166.32,157.69 166.89,157.69
+3VALW on BOTTOM (solid shape): 192.35,152.16 192.35,151.4 191.97,151.03 191.21,151.03 191.02,150.84 191.02,149.62 190.9,149.49 189.62,149.49 189.42,149.68 189.42,150.64 190.19,151.4 190.19,151.84 190.31,151.97 191.27,151.97 191.6,152.31 192.2,152.31
+3VALW on BOTTOM (solid shape): 119.28,167.19 119.28,166.71 119.23,166.67 117.82,166.67 116.87,165.72 116.87,165.14 116.62,164.89 115.33,164.89 115.08,165.14 115.08,165.99 115.29,166.2 115.94,166.2 116.99,167.25 119.22,167.25
+3VALW on BOTTOM (solid shape): 39.8,39.85 39.8,38.62 39.3,38.62 39.3,37.92 39.8,37.92 39.8,37.42 39.3,37.42 39.3,36.72 39.8,36.72 39.8,33.67 39.82,33.65 39.82,33.39 39.3,33.39 39.3,32.68 39.82,32.68 39.82,32.19 39.3,32.19 39.3,31.48 39.82,31.48 39.82,30.95 39.69,30.82 37.7,30.82 37.3,31.22 37.3,39.98 37.54,40.22 39.43,40.22
+3VALW on BOTTOM (solid shape): 129.12,168.28 129.22,168.2 129.34,168.17 129.53,168.18 129.7,168.27 129.75,168.24 129.81,168.2 129.81,167.53 129.68,167.4 128.52,167.4 127.72,166.6 125.69,166.6 125.55,166.75 125.55,167.24 125.7,167.4 126.24,167.4 126.51,167.66 126.7,167.66 126.82,167.54 126.82,167.53 127.19,167.34 127.46,167.66 127.46,167.71 128.02,168.28
+3VALW on IN1 (solid shape): 151.17,166.69 151.17,165.97 151.04,165.84 149.33,165.84 148.58,166.58 148.58,167.54 148.75,167.71 150.15,167.71
+3VALW on IN1 (solid shape): 191.02,151.34 191.02,150.33 190.32,149.63 189.55,149.63 189.43,149.76 189.43,150.64 190.26,151.47 190.9,151.47
+3VALW on IN1 (solid shape): 59.06,64.28 59.06,63.39 58.49,62.82 57.28,62.82 54.55,60.09 54.55,59.13 54.42,59.01 53.25,59.01 52.36,59.9 52.36,63.39 53.82,64.85 58.49,64.85
+3VALW on IN1 (solid shape): 187.89,7.1 192.68,7.1 193.23,7.64 205.56,7.64 206.14,7.07 206.14,5.87 205.88,5.61 198.57,5.61 198.3,5.61 197.82,5.13 186.41,5.13 185.49,6.06 185.49,7.68 185.68,7.88 187.11,7.88
+3VALW on IN1 (solid shape): 83.01,12.72 83.01,12.27 82.97,12.18 82.87,12.17 82.4,11.84 82.87,11.5 82.97,11.49 83.01,11.4 83.01,11.2 85.26,8.95 85.26,6.16 85.07,5.96 81.61,5.96 81.42,6.16 81.42,9.62 80.09,10.95 80.09,12.41 80.6,12.91 82.82,12.91
+3VALW on IN1 (solid shape): outline of 91 points within 110.44,157.82 126.82,168.11
+3VALW on IN1 (solid shape): outline of 91 points within 92.03,5.68 107.77,8.28
+3VALW on IN1 (solid shape): outline of 110 points within 280.68,36.81 293.7,47.86
+3VALW on IN1 (solid shape): outline of 284 points within 229.2,10.65 248.95,18.53
+3VALW on IN1 (solid shape): outline of 355 points within 113.49,5.17 149.11,11.26
+3VALW on IN4 (solid shape): 147,60.53 147,59.89 146.71,59.59 144.62,59.59 144.49,59.72 144.49,60.65 144.59,60.75 145.65,60.75 145.66,60.76 146.77,60.76
+3VALW on IN4 (solid shape): 150.22,168.18 150.42,167.98 150.42,166.82 150.23,166.63 148.34,166.63 147.57,167.4 146.37,167.4 146.18,167.59 146.18,168.77 146.36,168.95 149.45,168.95
+3VALW on IN4 (solid shape): 119.53,168.7 119.53,167.66 117.51,165.65 117.03,165.65 116.52,166.16 116.52,166.74 117.98,168.2 117.98,168.43 117.99,168.52 117.98,168.6 117.98,168.68 118.11,168.81 119.42,168.81
+3VALW on IN4 (solid shape): 147.91,9.04 147.91,4.6 147.65,4.34 147.34,4.34 147.26,4.39 147.25,4.49 147.11,4.95 146.64,4.84 146.57,4.8 146.5,4.81 146.39,4.86 146.27,4.86 146.25,4.86 146.19,4.91 146.19,8.72 145.62,9.3 145.62,9.87 145.94,10.18 146.76,10.18
+3VALW on IN4 (solid shape): outline of 1120 points within 36.97,34.63 58.18,64.41
+3VALW on VCC: 67.97,1.22 67.97,2 67.32,3.57 65.75,4.22 34.65,4.22 34.44,4.21 34.24,4.18 34.24,4.79 34.24,6.8 29.48,11.56 29.48,23.16 33.79,27.47 33.79,45.82 39.95,51.98 39.95,57.86 39.94,57.86 39.94,59.53 41.15,59.53 42.72,60.18 43.37,61.75 43.37,64.78 44.65,64.78 51.46,65.38 58.06,67.15 58.12,67.04 58.44,66.58 58.87,66.21 58.87,63.94 58.87,63.94 58.87,60.15 54.06,60.15 51.76,57.84 51.76,54.35 41.85,44.44 41.85,24.19 35.45,17.78 35.45,14.33 36.17,13.61 46.71,13.61 48.11,12.22 71.6,12.22 74.97,8.85 148.71,8.85 152.84,12.98 160.69,12.98 163.8,9.87 168.82,9.87 172.44,6.25 213.29,6.25 218.24,11.2 237.99,11.2 245.04,18.25 251.77,18.25 251.77,1.22 224.86,1.22 224.31,1.59 223.65,1.72 217.65,1.72 216.99,1.59 216.44,1.22 162.66,1.22 162.11,1.59 161.45,1.72 155.45,1.72 154.79,1.59 154.24,1.22 112.31,1.22 111.76,1.59 111.1,1.72 107.1,1.72 106.44,1.59 105.89,1.22
+3VALW_PCH on TOP (solid shape): 152.67,59.14 154.89,59.14 154.89,58.57 156.29,58.57 156.29,59.14 156.8,59.14 157.05,58.89 157.05,57.57 156.81,57.34 151.69,57.34 151.54,57.49 151.54,58.05 151.27,58.32 151.27,59.21 151.53,59.46 152.35,59.46
+3VALW_PD on BOTTOM (solid shape): 122.31,152.32 122.31,152.25 122.25,152.19 121.74,152.19 121.3,152.63 120.73,152.63 120.66,152.7 120.66,153.21 120.73,153.27 121.36,153.27
+3VALWP on BOTTOM (solid shape): 46.05,40.81 46.05,37.06 45.61,36.62 45.61,32.17 44.91,31.48 42.43,31.48 41.9,32 41.09,32 40.28,31.19 40.28,30.92 40.22,30.86 40.04,30.86 39.99,30.91 39.99,31.62 39.44,31.62 39.44,32.06 39.94,32.06 39.94,32.08 39.95,32.08 39.95,32.79 39.94,32.79 39.94,32.81 39.44,32.81 39.44,33.26 39.94,33.26 39.94,33.28 39.95,33.28 39.95,36.04 39.95,36.04 39.95,36.82 39.93,36.82 39.93,36.85 39.44,36.85 39.44,37.29 39.93,37.29 39.93,37.32 39.95,37.32 39.95,38.02 39.93,38.02 39.93,38.05 39.44,38.05 39.44,38.49 39.93,38.49 39.93,38.5 39.99,38.5 39.99,39.46 40.1,39.56 40.1,39.56 40.91,40.37 42.56,40.37 43.26,41.06 45.8,41.06
+3VLP on TOP (solid shape): 86.16,14.24 87.89,14.24 87.95,14.18 87.95,14.09 87.89,14.03 86.18,14.03 86.12,13.97 85.67,13.97 85.42,14.22 84.9,14.22 84.8,14.32 84.8,14.88 84.89,14.98 85.43,14.98
+3VLP on BOTTOM (solid shape): 33.41,27.58 33.41,27.49 33.36,27.44 32.3,27.44 31.89,27.03 31.89,26.84 31.9,26.83 31.9,26.14 31.79,26.03 30.72,26.03 30.67,26.08 30.67,27.09 30.82,27.25 31.55,27.25 31.95,27.65 33.34,27.65
+3VS on TOP (solid shape): 159.29,64.27 159.29,63.76 159.11,63.58 156.86,63.58 156.78,63.66 156.78,64.51 156.87,64.6 158.96,64.6
+3VS on TOP (solid shape): 192.29,163.73 192.29,162.27 192.17,162.14 190.45,162.14 190.32,162.27 190.32,162.9 190.2,163.03 189.12,163.03 189.05,163.09 189.05,163.6 189.31,163.85 192.17,163.85
+3VS on TOP (solid shape): 295.73,68.18 295.73,66.2 295.73,66.19 295.73,64.7 295.48,64.45 294.3,64.45 294.08,64.67 294.08,68.31 294.21,68.43 295.48,68.43
+3VS on TOP (solid shape): 296.24,54.45 296.24,50.4 295.86,50.02 294.27,50.02 294.14,50.15 294.14,52.79 294.15,52.79 294.15,53.3 293.51,53.94 293.51,54.7 293.57,54.76 295.92,54.76
+3VS on TOP (solid shape): 89.42,26.95 89.42,26.62 89.6,26.45 91.36,26.45 91.54,26.26 91.54,25.36 91.46,25.28 89.67,25.28 88.79,26.16 88.79,26.95 88.91,27.08 89.3,27.08
+3VS on TOP (solid shape): 64.26,67.47 64.26,67.44 64.24,67.31 64.27,67.18 64.28,67.17 64.28,65.94 64.28,65.81 64.28,65.05 63.01,63.78 58.18,63.78 57.04,64.92 57.04,65.56 57.31,65.83 60.34,65.83 61.04,66.06 62.43,66.83 63.9,67.59 64.15,67.59
+3VS on TOP (solid shape): 190.37,78.74 190.37,77.65 190.6,77.42 190.92,77.42 190.95,77.45 191.41,77.45 191.77,77.81 191.77,78.09 191.85,78.18 192.93,78.18 193.41,78.65 194.16,78.65 194.31,78.5 194.31,77.35 194.2,77.24 193.58,77.24 193.55,77.21 193.52,77.21 193.2,76.89 193.2,76.08 192.87,75.75 190.32,75.75 190.23,75.84 190.23,76.61 189.8,77.04 189.8,78.75 189.92,78.87 190.23,78.87
+3VS on TOP (solid shape): outline of 808 points within 145.49,22.97 180.11,55.59
+3VS on TOP (solid shape): outline of 842 points within 154.34,95.37 163.08,116.87
+3VS on BOTTOM (solid shape): 182.07,73.91 182.07,72.16 181.88,71.97 181.51,71.97 181.31,72.11 181.1,72.25 181.1,74.02 181.13,74.04 181.93,74.04
+3VS on BOTTOM (solid shape): 296.21,51.76 296.21,50.27 296,50.06 293.46,50.06 293.33,50.19 293.33,50.84 293.41,50.93 294.93,50.93 295.04,51.03 295.04,51.79 295.16,51.91 296.06,51.91
+3VS on BOTTOM (solid shape): 186.85,41.16 188.15,41.16 188.32,40.99 188.32,36.43 188.01,36.11 186.4,36.11 186.11,36.4 186.11,41.09 186.21,41.18 186.84,41.18
+3VS on BOTTOM (solid shape): 120.69,161.19 120.69,160.77 121.1,160.36 121.1,159.71 121.27,159.54 122.16,159.54 122.21,159.49 122.21,158 121.85,157.63 119.67,157.63 119.51,157.8 119.51,161.1 119.65,161.24 120.64,161.24
+3VS on BOTTOM (solid shape): 295.76,68.41 295.96,68.3 296.18,68.22 296.18,67.59 296.11,67.52 295.04,67.52 294.97,67.59 293.38,67.59 293.32,67.65 293.32,68.29 293.45,68.41
+3VS on BOTTOM (solid shape): 159.78,150.12 159.78,148.68 159.65,148.55 156.8,148.55 156.8,148.93 156.92,149.06 157.18,149.06 157.49,149.38 158.1,149.38 158.21,149.49 158.21,149.84 158.71,150.34 159.01,150.34 159.03,150.35 159.55,150.35
+3VS on BOTTOM (solid shape): 64.08,67.52 64.2,67.4 64.2,65.36 63.99,65.14 62.88,65.14 62.1,64.73 61.93,64.67 57.1,64.67 56.97,64.79 56.97,65.56 57.29,65.87 60.53,65.87 61.04,66.06 62.12,66.64 62.75,66.95 63.77,67.52
+3VS on BOTTOM (solid shape): 138.78,167.54 138.78,166.07 138.69,165.98 138.2,165.98 137.99,165.77 137.99,165.45 138.43,165.01 138.43,164.81 138.18,164.55 136.91,164.55 136.63,164.83 136.63,165.26 136.78,165.26 136.9,165.38 137.1,165.38 137.23,165.51 137.23,167.39 137.31,167.47 137.67,167.47 137.83,167.63 138.69,167.63
+3VS on BOTTOM (solid shape): 70.63,59.9 70.63,59.65 70.5,59.52 70.5,59.14 70.69,58.95 71.13,58.95 71.71,59.52 71.77,59.52 72.15,59.14 72.15,59.08 71.71,58.63 71.71,58.51 71.96,58.25 71.96,57.3 71.58,57.3 71.45,57.43 71.45,57.68 70.69,58.44 70.31,58.44 70.02,58.73 69.47,58.73 69.37,58.83 69.37,58.91 70.45,59.98 70.55,59.98
+3VS on IN1 (solid shape): outline of 514 points within 290.31,50.06 296.06,68.46
+3VS on IN1 (solid shape): outline of 1700 points within 168.99,24.91 195.47,36.78
+3VS on IN2 (solid shape): 190.42,78.87 190.42,78.07 190.29,77.94 189.05,77.94 188.54,78.45 188.54,79.06 188.83,79.36 189.94,79.36
+3VS on IN2 (solid shape): 159.84,65.36 159.84,65.3 159.27,64.73 159.27,64.06 159.07,63.86 158.32,63.86 158.18,64 158.18,65.16 159.01,66 159.2,66
+3VS on IN2 (solid shape): 176.16,60.73 177.88,60.73 178.13,60.48 178.13,59.9 177.94,59.71 175.72,59.71 174.1,61.33 174.1,62.03 174.45,62.38 174.51,62.38
+3VS on IN3 (solid shape): 159.61,150.52 159.61,149.67 159.31,149.37 158.62,149.37 158.16,149.83 158.16,149.86 157.68,150.34 157.68,151.05 158.18,151.55 158.58,151.55
+3VS on IN3 (solid shape): 192.23,163.47 192.23,161.25 192.86,160.62 192.86,159.98 192.8,159.92 191.15,159.92 190.96,160.11 190.96,160.93 191.09,161.06 191.09,163.54 191.21,163.66 192.04,163.66
+3VS on IN5 (solid shape): outline of 1702 points within 171.74,45.94 181.65,62.95
+3VS on VCC: outline of 1179 points within 50.49,12.72 292.86,168.49
+3VS_DP on TOP (solid shape): 194.32,163.4 194.32,162.43 194.13,162.24 192.69,162.24 192.62,162.31 192.62,163.75 192.67,163.8 193.93,163.8
+3VS_DP on BOTTOM (solid shape): 204.93,164.86 204.93,162.01 204.61,161.7 204.61,159.98 204.29,159.66 203.28,159.66 203.02,159.92 203.02,161.7 203.51,162.19 203.51,162.25 203.51,164.99 203.64,165.12 204.67,165.12
+3VS_DP on IN4 (solid shape): 194.36,163.38 194.36,160.65 194.13,160.43 193.88,160.43 193.15,161.16 193.15,163.31 193.4,163.57 194.17,163.57
+3VS_DP on IN4 (solid shape): 203.91,160.87 203.91,160.04 203.72,159.85 202.33,159.85 202.13,160.04 202.13,160.81 202.33,161 203.79,161
+3VS_SSD on TOP (solid shape): outline of 761 points within 226.46,1.68 240.49,45.43
+3VS_SSD on BOTTOM (solid shape): 232.28,27.91 232.28,26.7 232.13,26.55 230.24,26.55 230.01,26.77 230.01,27.93 230.08,28 232.19,28
+3VS_SSD on BOTTOM (solid shape): 233.68,42.39 233.68,40.8 233.52,40.64 230.76,40.64 230.63,40.77 230.63,42.37 230.78,42.52 233.55,42.52
+3VS_SSD on BOTTOM (solid shape): 235.28,18.46 235.28,16.84 235.18,16.74 232.23,16.74 232.04,16.93 232.04,18.21 232.42,18.59 235.15,18.59
+3VS_SSD on BOTTOM (solid shape): 236.99,3.9 236.99,3.13 236.61,2.75 233.78,2.75 233.67,2.85 233.67,3.96 233.8,4.09 236.8,4.09
+3VS_SSD on BOTTOM (solid shape): 232.93,45.08 232.93,44.34 232.74,44.15 230.72,44.15 230.63,44.24 230.63,45.11 230.79,45.27 232.74,45.27
+3VS_SSD on BOTTOM (solid shape): 235.32,21.26 235.32,20.34 235.23,20.25 233.66,20.25 233.44,20.03 232.74,20.03 232.55,20.22 232.55,20.84 233.04,21.32 233.13,21.42 235.15,21.42
+3VS_TBT on TOP (solid shape): 146.87,168.05 146.87,166.62 146.83,166.58 146.2,166.58 146.08,166.58 145.54,166.04 145.54,165.63 144.73,164.82 144.73,161.33 144.92,161.14 144.92,161.03 145.11,160.83 145.11,160.3 145.16,160.26 145.16,160.02 145.1,159.96 144.98,159.96 144.86,160.09 144.86,160.27 144.73,160.4 144.54,160.4 144.47,160.46 144.47,160.73 144.15,161.06 144.15,161.96 143.71,162.39 143.71,162.84 143.81,162.93 143.85,162.93 143.85,162.98 143.97,163.09 143.97,166.12 144.24,166.39 144.62,166.39 145.24,167.01 145.24,167.47 145.36,167.59 145.36,167.95 145.52,168.11 146.82,168.11
+3VS_TBT on IN3 (solid shape): outline of 1848 points within 143.58,142.95 150.4,167.16
+5V_PVDD on TOP (solid shape): 28.33,48.82 28.33,46.85 28.33,46.84 28.47,46.36 28.95,46.5 28.97,46.53 29.16,46.53 29.35,46.34 29.35,45.62 29.29,45.55 28.41,45.55 28.07,45.21 27.27,45.21 27.08,45.4 27.08,47.06 27.11,47.13 27.19,47.16 27.55,47.62 26.99,47.79 26.92,47.77 26.85,47.8 26.44,47.86 26.22,47.51 26.22,47.47 26.13,47.39 25.86,47.39 25.69,47.22 25.69,46.76 25.6,46.67 24.22,46.67 24.14,46.75 24.14,47.67 24.14,47.67 24.14,48.77 24.36,48.99 28.16,48.99
+5V_PVDD on BOTTOM (solid shape): 26.25,47.91 26.34,47.85 26.33,47.74 26.3,47.32 26.7,47.17 26.79,47.15 26.83,47.07 26.83,45.42 26.63,45.23 25.97,45.23 25.82,45.38 25.82,46.35 25.54,46.64 24.61,46.64 24.56,46.68 24.56,47.47 25.01,47.91
+5V_USB_PWR1 on TOP (solid shape): 18.92,52.68 18.92,51.91 19.13,51.7 19.31,51.7 19.44,51.58 19.44,51.01 19.45,51 19.45,50.27 19.5,50.21 19.5,49.99 19.44,49.93 19.31,49.93 18.93,50.31 18.06,50.31 18.04,50.33 18,50.34 17.85,50.5 17.85,52.59 17.98,52.72 18.88,52.72
+5V_USB_PWR1 on BOTTOM (solid shape): outline of 117 points within 13.79,49.02 19.05,57.76
+5V_USB_PWR2 on TOP (solid shape): 306.15,66.34 306.15,62.85 305.38,62.08 305.38,60.94 304.24,59.8 304.24,58.91 303.99,58.65 299.53,58.65 299.41,58.77 298.55,58.77 298.48,58.84 298.48,59.42 298.54,59.48 299.25,59.48 299.48,59.71 299.48,60.31 301.19,62.02 302.27,62.02 302.46,61.83 302.46,61.34 302.47,61.34 302.63,61.18 303.37,61.18 303.54,61.35 303.54,62.21 305,63.67 305,66.34 305.26,66.59 305.89,66.59
+5V_USB_PWR2 on IN1 (solid shape): 306.15,66.64 306.15,65.62 305.77,65.24 305.77,59.84 304.81,58.89 299.73,58.89 299.16,59.46 299.16,60.6 300.05,61.49 303.35,61.49 304.37,62.51 304.37,66.19 305.07,66.89 305.89,66.89
+5V_USB_PWR2 on IN2 (solid shape): 306.21,66.64 306.21,65.81 305.77,65.37 305.77,60.67 304.94,59.84 300.12,59.84 299.61,60.35 299.61,61.24 300.05,61.68 303.29,61.68 304.43,62.83 304.43,66.19 305.07,66.83 306.02,66.83
+5V_USB_PWR2 on IN3 (solid shape): 306.15,66.34 306.15,62.85 305.38,62.08 305.38,60.94 303.68,59.23 300.62,59.23 300.16,59.69 300.16,60.99 301.19,62.02 302.27,62.02 302.28,62.02 303.35,62.02 305,63.67 305,66.34 305.26,66.59 305.89,66.59
+5V_USBC_VBUS on TOP (solid shape): 302.67,43.27 302.67,40.19 302.24,39.77 299.06,39.77 298.86,39.96 298.86,41.78 298.6,42.04 296.84,42.04 296.74,42.14 296.74,42.71 296.85,42.81 298.26,42.81 298.48,43.03 298.48,43.32 298.82,43.66 302.28,43.66
+5V_USBC_VBUS on IN5 (solid shape): outline of 462 points within 300.91,39.71 313.45,45.6
+5VALW on TOP (solid shape): 241.82,145.57 241.82,144.87 241.06,144.11 240.36,144.11 240.11,144.36 240.11,144.93 240.87,145.69 241.7,145.69
+5VALW on TOP (solid shape): 161.3,19.65 161.3,17.3 161.21,17.21 159.57,17.21 159.47,17.32 159.47,19.58 159.7,19.82 161.13,19.82
+5VALW on TOP (solid shape): 165.88,16.28 167.15,16.28 167.34,16.09 167.34,15.45 167.08,15.2 165.18,15.2 164.67,15.71 164.67,16.41 164.8,16.53 165.62,16.53
+5VALW on TOP (solid shape): 166.45,149.69 166.45,148.55 164.92,147.03 164.54,147.03 164.23,147.34 164.23,147.85 165.5,149.12 165.5,149.82 165.81,150.14 166,150.14
+5VALW on TOP (solid shape): 271.09,36.78 272.67,36.78 272.93,36.53 272.93,35.7 272.61,35.38 269.75,35.38 269.5,35.64 269.5,36.02 268.36,37.16 268.36,38.62 268.48,38.75 269.12,38.75
+5VALW on TOP (solid shape): 19.51,47.95 19.51,47.74 19.45,47.68 19.45,46.79 19.42,46.76 19.42,44.57 19.24,44.4 18.1,44.4 17.85,44.66 17.85,46.56 19.31,48.02 19.44,48.02
+5VALW on TOP (solid shape): 294.56,42.72 294.56,41.13 294.48,41.05 293.32,41.05 292.93,40.65 291.6,40.65 290.15,39.2 290.14,39.2 290.14,37.73 289.88,37.48 288.23,37.48 287.98,37.73 287.98,39.38 288.1,39.51 288.1,42.69 288.23,42.81 294.47,42.81
+5VALW on TOP (solid shape): 176.48,152.17 177.62,152.17 177.81,151.98 177.81,151.54 177.94,151.41 178.39,151.41 179.08,150.71 179.08,149.12 178.89,148.93 178.32,148.93 175.46,151.79 175.46,152.61 175.59,152.74 175.91,152.74
+5VALW on TOP (solid shape): 300.17,61.74 300.17,61.19 299.29,60.32 299.29,59.91 299.1,59.71 297.51,59.71 297.38,59.59 297.38,59.58 297.26,59.45 296.29,59.45 296.04,59.7 296.04,61 296.81,61.77 297.74,61.77 298.13,61.38 298.8,61.38 299.4,61.99 299.91,61.99
+5VALW on TOP (solid shape): 36.14,16.07 36.84,16.07 36.84,16.59 37.34,16.59 37.34,16.07 38.04,16.07 38.04,16.59 41.41,16.59 41.41,16.07 42.11,16.07 42.11,16.59 42.61,16.59 42.61,16.07 43.31,16.07 43.31,16.59 44.39,16.59 44.84,16.14 44.84,13.86 44.33,13.35 34.68,13.35 34.29,13.73 34.29,16.21 34.68,16.59 36.14,16.59
+5VALW on TOP (solid shape): 115.86,13.96 115.86,11.4 115.71,11.15 115.86,10.9 115.86,9.67 114.95,8.76 113.13,8.76 112.85,9.05 112.85,10.11 114.89,12.15 114.89,13.96 115.04,14.11 115.71,14.11
+5VALW on TOP (solid shape): 196.24,162.38 196.32,162.34 196.34,162.25 196.36,161.88 196.62,161.61 196.63,161.61 197.22,161.01 199.23,161.01 200.1,160.14 200.1,156.62 199.21,155.73 199.21,155.47 199.15,155.41 198.64,155.41 198.52,155.54 198.52,158.65 198.64,158.77 198.64,158.99 198.65,159 198.68,159.16 198.65,159.31 198.64,159.32 198.64,159.4 198.44,159.61 196.12,159.61 195.17,160.56 195.17,161.55 195.18,161.62 195.17,161.69 195.17,162.18 195.38,162.38
+5VALW on TOP (solid shape): outline of 229 points within 51.45,49.68 56.85,58.51
+5VALW on BOTTOM (solid shape): 166.32,147.15 166.32,145.95 166.19,145.82 165.43,145.82 165.3,145.95 165.3,146.33 164.29,147.34 164.29,147.92 164.42,148.04 165.43,148.04
+5VALW on BOTTOM (solid shape): 56.84,59.64 56.84,55.58 56.65,55.39 54.7,55.39 54.62,55.47 54.62,57.99 55.19,58.56 55.19,58.88 56.01,59.7 56.77,59.7
+5VALW on BOTTOM (solid shape): 104.6,130.47 104.6,126.93 103.39,125.72 101.81,125.72 101.55,125.98 101.55,130.6 101.68,130.73 104.34,130.73
+5VALW on BOTTOM (solid shape): 240.93,145.95 241.5,145.95 241.5,146.52 241.82,146.52 242.01,146.33 242.01,145.19 241.89,145.06 240.55,145.06 240.43,145.19 240.43,146.33 240.62,146.52 240.93,146.52
+5VALW on BOTTOM (solid shape): 162.35,21.9 162.35,20.28 162.2,20.13 161.67,20.13 161.21,19.66 161.21,17.53 161.21,17.53 161.21,17.31 161.11,17.21 160.5,17.21 159.7,18.01 159.7,20.79 159.72,20.82 160.6,20.82 161.89,22.1 162.15,22.1
+5VALW on BOTTOM (solid shape): 166.08,16.22 166.11,16.22 166.11,16.22 166.61,16.22 166.61,16.22 166.63,16.22 166.63,16.74 166.82,16.74 166.88,16.68 166.88,16.22 166.91,16.22 166.91,16.22 167.34,16.22 167.52,16.04 167.52,15.38 167.45,15.32 165.23,15.32 164.99,15.55 164.99,16.06 165.15,16.22 165.23,16.22 165.23,16.22 165.81,16.22 165.81,16.22 165.83,16.22 165.83,16.74 166.08,16.74
+5VALW on BOTTOM (solid shape): 128.8,150.02 128.8,149.75 130,148.55 130.76,148.55 131.05,148.27 131.05,146.32 131.18,146.19 132.66,146.19 132.8,146.06 132.8,145.38 132.62,145.21 130.82,145.21 130.43,144.81 130.43,144.37 130.43,144.36 130.43,140.24 129.41,139.22 126.76,139.22 126.13,139.85 126.13,141.22 127.68,142.77 127.68,143.71 128.56,144.6 128.56,146.28 129.07,146.79 129.07,147.32 128.33,148.06 128.33,150.12 128.42,150.2 128.62,150.2
+5VALW on IN3 (solid shape): 129.88,149.3 129.88,147.24 129.67,147.03 129.36,147.03 128.62,147.77 128.62,150.05 129.13,150.05
+5VALW on IN3 (solid shape): 103.23,128.19 103.23,124.09 101.61,122.47 100.41,122.47 99.71,123.17 99.71,124.47 99.74,124.5 99.74,126.85 101.45,128.57 102.85,128.57
+5VALW on IN3 (solid shape): outline of 185 points within 175.46,150.87 198.04,162.39
+5VALW on IN3 (solid shape): outline of 847 points within 122.44,7.94 138.25,18.09
+5VALW on IN3 (solid shape): outline of 2231 points within 17.39,44.32 83.26,68.35
+5VALW on IN4 (solid shape): 166.57,148.42 166.57,147.79 165.75,146.96 164.73,146.96 164.16,147.53 164.16,147.92 164.42,148.17 165.56,148.17 166.19,148.8
+5VALW on IN4 (solid shape): 175.97,152.55 175.97,149.88 175.46,149.38 170.83,149.38 170.64,149.57 170.64,150.96 170.96,151.28 172.61,151.28 173.37,150.52 174.64,150.52 174.83,150.71 174.83,151.34 175.15,151.66 175.15,152.68 175.21,152.74 175.78,152.74
+5VALW on IN4 (solid shape): outline of 2148 points within 35.83,14.38 57.61,58.57
+5VALW on VCC: 239.39,46.25 289.49,46.32 293.37,50.17 293.37,60.93 294.37,61.93 298.98,61.93 299.34,61.57 299.34,30.92 254,30.92 252.43,30.27 251.78,28.7 251.78,18.75 245.57,18.75 245.57,18.76 244.83,18.76 237.78,11.71 218.03,11.71 213.08,6.76 172.65,6.76 169.03,10.37 164.01,10.37 160.9,13.49 152.63,13.49 148.5,9.36 75.18,9.36 71.81,12.72 48.32,12.72 46.92,14.12 36.38,14.12 35.96,14.54 35.96,17.57 42.36,23.98 42.36,44.23 52.26,54.14 52.26,57.63 54.27,59.64 58.87,59.64 58.87,49.08 53.65,43.86 53.32,43.76 53.22,43.43 49.98,40.19 49.99,24.47 49.99,24.37 51.22,23.14 74.97,23.14 78.9,19.2 169.33,19.2 176.31,12.22 210.24,12.22 216.27,18.25 227.2,18.25 234.33,25.38 234.33,41.19
+5VALW_LED on TOP (solid shape): outline of 186 points within 173.33,156.35 177.35,161.85
+5VALWP on TOP (solid shape): 44.4,18.08 44.4,17 44.14,16.74 43.18,16.74 43.18,16.21 42.73,16.21 42.73,16.72 42.71,16.72 42.71,16.72 42.01,16.72 42.01,16.72 41.98,16.72 41.98,16.21 41.53,16.21 41.53,16.72 41.53,16.72 41.53,16.74 37.91,16.74 37.91,16.2 37.46,16.2 37.46,16.72 37.44,16.72 37.44,16.72 36.74,16.72 36.74,16.72 36.71,16.72 36.71,16.2 36.26,16.2 36.26,16.72 36.26,16.74 35.25,16.74 34.94,17.06 34.94,18.4 35.1,18.55 36.81,18.55 37.13,18.87 43.61,18.87
+5VALWP on BOTTOM (solid shape): 41.41,21.7 43.38,19.73 43.38,17.57 42.75,16.93 38.81,16.93 38.49,17.25 38.49,27.16 38.87,27.54 41.41,27.54
+5VS on TOP (solid shape): 143.52,140.04 143.52,138.26 143.33,138.07 139.33,138.07 138.44,138.96 138.44,140.11 143.46,140.11
+5VS on TOP (solid shape): 183.78,163.66 183.78,161.63 183.72,161.57 182.58,161.57 181.75,162.39 178.07,162.39 178.07,163.41 182.26,163.41 182.7,163.85 183.59,163.85
+5VS on TOP (solid shape): 61.64,59.02 61.73,58.98 61.84,58.98 61.93,58.89 61.93,58.38 62.03,58.27 62.75,58.27 63.12,57.9 63.12,57.06 62.69,56.62 62.69,55.03 62.43,54.78 61.16,54.78 60.97,54.97 60.97,56.18 60.72,56.43 59.81,56.43 59.64,56.6 59.64,58.7 59.96,59.02
+5VS on TOP (solid shape): outline of 117 points within 180.52,2.87 203.34,9.14
+5VS on BOTTOM (solid shape): 198.01,142.9 196.42,142.9 196.04,142.52 195.78,142.52 195.53,142.77 195.53,143.03 196.16,143.66 198.01,143.66
+5VS on BOTTOM (solid shape): 246.98,86.45 247.26,86.17 247.26,85.25 247.39,85.13 247.39,84.82 247.3,84.73 247.01,84.73 246.19,85.55 246.19,85.72 246.1,86 246.18,86.18 246.49,86.35 246.76,86.49
+5VS on BOTTOM (solid shape): 217.88,23.39 217.88,22.57 217.76,22.44 217.31,22.44 217.12,22.25 217.12,22 216.93,21.8 216.1,21.8 215.91,22 215.91,23.14 216.36,23.58 217.69,23.58
+5VS on BOTTOM (solid shape): 244.43,94.39 244.43,89.24 244.43,88.04 243.92,87.53 243.35,87.53 242.9,87.97 242.9,94.26 243.16,94.51 244.3,94.51
+5VS on BOTTOM (solid shape): 63.16,58.22 63.16,57.46 63.6,57.02 63.6,55.14 63.31,54.85 60.94,54.85 60.47,54.38 59.7,54.38 59.57,54.52 59.57,55.03 59.54,55.04 59.01,55.04 59.01,55.29 59.56,55.29 59.56,55.84 59.01,55.84 59.01,56.08 59.57,56.08 59.57,58.12 59.76,58.31 63.07,58.31
+5VS on BOTTOM (solid shape): 191.55,12.15 191.55,10.06 191.14,9.65 182.48,9.65 182.19,9.37 182.19,7.91 182.01,7.73 180.61,7.73 180.44,7.9 180.44,9.4 182.08,11.03 186.91,11.03 186.91,11.03 188.4,11.03 188.66,10.78 190.53,10.78 190.68,10.92 190.68,12.22 190.74,12.28 191.42,12.28
+5VS on IN1 (solid shape): 246.74,90.86 246.74,86.08 247.35,85.46 247.35,84.51 247.2,84.37 246.11,84.37 245.66,84.81 245.66,89.93 243.07,92.51 243.07,93.2 243.3,93.42 244.17,93.42
+5VS on IN3 (solid shape): 60.18,60.66 61.45,59.39 61.78,58.98 62.16,59.34 62.61,59.34 63.05,58.9 63.05,57.6 61.99,56.54 59.44,56.54 57.86,58.13 57.86,60.46 58.4,61 59.84,61
+5VS on IN3 (solid shape): outline of 205 points within 105.71,135.34 123.3,139.75
+5VS on IN4 (solid shape): 219.15,23.33 219.15,22.69 218.9,22.44 217.5,22.44 217.37,22.57 217.37,23.46 217.5,23.58 218.9,23.58
+5VS on IN4 (solid shape): 244.36,93.05 244.36,91.53 244.11,91.27 243.35,91.27 243.03,91.59 243.03,93.12 243.22,93.31 244.11,93.31
+5VS on IN4 (solid shape): 63.58,60.24 63.58,57.68 62.43,56.54 60.02,56.54 59.64,56.92 59.64,59.33 61.44,59.33 61.45,59.28 61.46,59.23 61.48,59.18 61.51,59.13 61.54,59.09 61.58,59.05 61.62,59.02 61.67,59 61.72,58.99 61.77,58.98 61.83,58.98 61.88,58.99 61.93,59 61.98,59.02 62.02,59.05 62.06,59.09 62.09,59.13 62.12,59.18 62.14,59.23 62.15,59.28 62.16,59.33 62.15,59.39 62.14,59.44 62.12,59.49 62.09,59.53 62.06,59.58 62.02,59.61 61.98,59.64 61.93,59.67 61.88,59.68 61.83,59.69 61.77,59.69 61.72,59.68 61.67,59.67 61.62,59.64 61.58,59.61 61.54,59.58 61.51,59.53 61.48,59.49 61.46,59.44 61.45,59.39 61.44,59.33 59.64,59.33 59.64,60.11 60.15,60.62 63.19,60.62
+5VS on IN5 (solid shape): 196.93,144.3 196.93,143.15 196.42,142.65 195.66,142.65 195.47,142.84 195.47,143.53 195.91,143.98 195.91,144.42 196.8,144.42
+5VS on IN5 (solid shape): 184.74,162.65 184.74,161.89 184.23,161.38 182.51,161.38 182.13,161.76 182.13,162.77 182.32,162.97 184.42,162.97
+5VS_TP_LED on TOP (solid shape): 206.77,6.31 206.77,4.47 206.58,4.28 205.56,4.28 205.18,4.66 205.18,6.76 205.75,7.33
+5VS_TP_LED on TOP (solid shape): 200.86,6.63 200.86,6.18 200.67,5.99 199.28,5.99 199.02,5.74 198.39,5.74 198.26,5.87 198.26,6.63 198.58,6.95 200.55,6.95
+5VS_TP_LED on BOTTOM (solid shape): 207.6,5.04 207.6,4.41 207.53,4.34 205.63,4.34 205.5,4.47 205.5,5.1 205.75,5.36 207.28,5.36
+5VS_TP_LED on BOTTOM (solid shape): 214.01,12.58 214.01,9.75 213.83,9.57 213.83,8 213.73,7.9 212.65,7.9 212.54,8.01 212.54,12.19 212.68,12.33 212.91,12.33 213.38,12.8 213.79,12.8
+AVDDL on IN4 (solid shape): outline of 637 points within 195.84,147.05 206.01,153.76
+PVDD on TOP (solid shape): 21.76,21.11 21.76,20.92 21.95,20.73 22.77,20.73 22.81,20.69 22.81,20.56 22.76,20.51 21.72,20.51 21.43,20.22 21.12,20.22 20.99,20.34 20.99,20.79 21.45,21.25 21.62,21.25
+PVDD on TOP (solid shape): 23.42,18.09 23.42,17.29 22.68,16.54 22.68,16.02 22.56,15.9 21.86,15.9 21.3,15.34 19.71,15.34 19.68,15.37 19.68,16.46 20.23,17.01 20.25,17.01 20.55,17.31 21.41,17.31 21.67,17.57 21.67,18.42 21.98,18.74 22.78,18.74
+PVDD on TOP (solid shape): 30.14,18.55 30.14,17.7 30.14,17.63 30.42,17.35 31.79,17.35 31.9,17.23 31.9,17.03 31.92,17.01 31.92,16.91 32.57,16.26 32.57,16 32.16,15.59 30.35,15.59 29.86,16.08 29.86,16.11 28.84,17.13 28.59,17.13 28.4,17.32 28.4,18.06 29.05,18.71 29.98,18.71
+PVDD on BOTTOM (solid shape): 26.94,16.88 26.94,14.59 26.61,14.26 26.61,13.22 24.96,13.22 24.96,14.2 24.71,14.45 24.71,16.91 24.92,17.12 26.7,17.12
+PVDD on BOTTOM (solid shape): 22.55,22.51 22.55,19.91 22.49,19.86 21.92,19.86 21.73,20.05 21.2,20.05 20.96,20.29 20.96,20.92 21.28,21.24 21.28,22.5 21.5,22.71 22.35,22.71
+PVDD on BOTTOM (solid shape): 22.87,18.65 22.87,17.19 22.81,17.13 21.88,17.13 21.58,16.82 21.33,16.82 21.19,16.96 21.19,17.14 21.33,17.27 21.34,17.27 21.67,17.59 21.67,18.33 22.05,18.71 22.81,18.71
+PVDD on IN4 (solid shape): 23.13,20.68 23.13,18.65 23.51,18.27 30.23,18.27 31.85,16.65 32.28,16.65 32.53,16.4 32.53,16.08 32.43,15.98 30.65,15.98 29.43,17.19 27.25,17.19 27.13,17.06 27.13,16.43 26.87,16.17 24.71,16.17 24.46,16.43 24.46,16.87 24.21,17.13 21.86,17.13 21.67,17.32 21.67,18.27 21.98,18.59 21.98,19.71 21.54,20.15 21.16,20.15 20.97,20.34 20.97,21.11 21.24,21.38 22.43,21.38
+V18R on TOP (solid shape): 85.28,9.08 86.14,9.08 86.17,9.05 87.87,9.05 87.93,8.99 87.93,8.9 87.87,8.83 86.19,8.83 86.14,8.78 85.44,8.78 85.17,8.51 84.18,8.51 84.06,8.63 84.06,9.12 84.18,9.25 85.12,9.25
+VCC_CORE on TOP (solid shape): outline of 1553 points within 124.29,92.11 150.32,122.98
+VCC_CORE on BOTTOM (solid shape): outline of 309 points within 125.81,92.67 138.51,94.19
+VCC_CORE on BOTTOM (solid shape): outline of 1458 points within 124.93,105 151.14,123.17
+VCC_CORE on IN1 (solid shape): outline of 3444 points within 124.66,92.38 150.38,121.33
+VCC_CORE on IN2 (solid shape): outline of 4813 points within 124.18,92.41 151.02,121.56
+VCC_CORE on IN3 (solid shape): outline of 3482 points within 124.66,92.38 150.38,121.33
+VCC_CORE on IN4 (solid shape): outline of 3216 points within 124.18,92.41 150.76,121.46
+VCC_CORE on IN5 (solid shape): outline of 2427 points within 124.13,95.15 136.47,115.74
+VCC_CORE on VCC: 138.31,92.79 124.21,92.85 124.21,112.5 130.95,119.24 130.95,121.44 151.29,121.44 151.59,121.14 151.58,116.96 149.95,115.33 136.3,115.33 135.26,114.29 135.26,105.4 133.99,104.13 133.99,99.6 134.52,99.07 136.78,99.07 136.78,94.59 138.31,93.06
+VCCGT on TOP (solid shape): outline of 3614 points within 102.54,92.83 124.04,123.98
+VCCGT on BOTTOM (solid shape): outline of 131 points within 109.28,92.51 121.79,94.46
+VCCGT on BOTTOM (solid shape): outline of 2305 points within 102.28,104.59 127.85,123.17
+VCCGT on IN1 (solid shape): outline of 4672 points within 102.66,92.99 123.84,120.69
+VCCGT on IN2 (solid shape): outline of 4023 points within 102.59,92.88 124.91,118.72
+VCCGT on IN3 (solid shape): outline of 4679 points within 102.66,92.99 123.84,120.69
+VCCGT on IN4 (solid shape): outline of 298 points within 104.66,92.94 123.11,96.06
+VCCGT on IN4 (solid shape): outline of 5298 points within 102.23,95.31 124.54,121.39
+VCCGT on IN5 (solid shape): outline of 3544 points within 103.39,95.25 123.77,115.77
+VCCGT on VCC: 123.7,92.85 108.09,92.86 108.09,105.92 103.39,110.62 103.39,119.74 105.47,121.82 130.21,121.82 130.44,121.59 130.44,119.45 123.7,112.71
+VCCIO on TOP (solid shape): 89.84,93.07 94.06,93.07 94.63,92.5 94.63,90.34 94.25,89.96 86.85,89.96 86.27,90.54 86.27,93.24 86.48,93.44 86.99,93.44 86.99,92.9 86.99,92.9 87.73,92.9 87.74,92.9 87.74,93.43 87.75,93.44 88.19,93.44 88.19,92.9 88.92,92.9 88.93,92.91 88.93,93.41 88.96,93.44 89.46,93.44
+VCCIO on TOP (solid shape): 138.78,101.84 138.88,101.79 138.9,101.68 138.92,101.47 139.05,101.31 139.11,101.2 139.06,101.09 138.93,100.69 139.31,100.5 139.33,100.5 139.55,100.28 139.57,100.28 139.62,100.23 139.6,100.19 139.56,100.05 139.58,99.91 139.58,98.59 139.64,98.25 139.97,98.14 140.08,98.12 140.12,98.02 140.12,97.33 140.08,97.23 139.97,97.21 139.62,97.08 139.6,96.72 139.6,96.22 139.58,96.11 139.59,96.01 139.32,95.74 137.8,95.74 137.52,96.02 137.52,96.8 137.56,96.89 137.66,96.92 137.81,96.94 137.94,97.03 138.18,97.27 139.08,97.27 139.08,98.11 137.98,98.11 137.98,98.08 137.74,97.83 137.6,97.8 137.52,97.92 137.52,101.62 137.74,101.84
+VCCIO on BOTTOM (solid shape): 139.07,104.58 139.07,103.82 139.12,103.77 139.12,103.51 139.08,103.5 138.92,103.38 138.85,103.19 138.85,103.16 138.77,103.08 138.33,103.08 137.81,103.61 137.53,103.61 137.39,103.75 137.39,104.3 137.55,104.46 137.7,104.46 137.93,104.45 138.11,104.6 138.13,104.63 139.01,104.63
+VCCIO on BOTTOM (solid shape): outline of 83 points within 136.84,94.49 140.18,100.02
+VCCIO on IN4 (solid shape): 138.9,104.11 138.9,103.35 138.89,103.34 138.85,103.18 138.89,103.03 138.9,103.01 138.9,101.66 138.89,101.59 138.9,101.53 138.9,100.56 139.47,99.99 139.47,98.42 139.61,98.29 139.65,98.23 139.71,98.18 139.83,98.07 139.95,98.07 140.11,97.91 140.11,97.46 139.97,97.32 139.82,97.32 139.55,97.04 139.55,95.94 139.4,95.79 139.18,95.79 138.05,96.93 138.05,97.7 137.09,98.65 137.09,102.1 137.25,102.33 137.18,102.6 137.15,102.68 137.18,102.76 137.23,102.82 137.25,102.89 137.33,102.98 137.45,102.97 137.95,103.35 137.32,103.31 137.24,103.22 137.12,103.24 137.09,103.26 137.09,103.77 137.69,104.37 138.64,104.37
+VCCIO on VCC: 139.68,108.92 153.02,108.92 157.81,113.71 157.81,120.72 157.03,121.5 151.95,121.5 151.5,121.94 130.8,121.94 130.42,122.33 105.26,122.33 102.88,119.95 102.88,110.41 107.58,105.71 107.58,92.86 98.78,92.86 94.51,88.6 89.79,88.6 89.79,117.19 102.87,130.28 102.87,133.7 110.92,141.75 132.83,141.75 133.11,141.69 133.39,141.75 155.91,141.75 164.41,133.25 164.41,112.58 154.12,102.29 154.12,94.86 152.05,92.79 138.82,92.79 138.82,93.27 137.29,94.8 137.29,103.92 138.94,105.57 138.94,108.18 ; 1 cut-out
+VCCIOP on TOP (solid shape): 93.42,95.87 93.42,93.45 93.23,93.26 90.44,93.26 90.13,93.57 89.66,93.57 89.64,93.58 88.79,93.58 88.79,93.04 88.79,93.04 88.34,93.04 88.34,93.58 88.33,93.59 87.6,93.59 87.59,93.59 87.59,93.06 87.59,93.06 87.14,93.06 87.14,93.06 87.14,93.57 87.13,93.58 86.47,93.58 86.44,93.61 86.44,93.82 86.82,94.2 90.07,94.2 90.07,94.15 90.09,94.09 90.11,94.04 90.13,94 90.17,93.96 90.21,93.92 90.25,93.89 90.3,93.87 90.36,93.85 90.41,93.84 90.46,93.84 90.52,93.85 90.57,93.87 90.62,93.89 90.66,93.92 90.7,93.96 90.74,94 90.77,94.04 90.79,94.09 90.8,94.15 90.81,94.2 90.81,94.25 90.8,94.31 90.78,94.36 90.75,94.41 90.72,94.45 90.68,94.49 90.64,94.52 90.59,94.55 90.54,94.57 90.49,94.58 90.44,94.59 90.38,94.58 90.33,94.57 90.28,94.55 90.23,94.52 90.19,94.49 90.15,94.45 90.12,94.41 90.1,94.36 90.08,94.31 90.07,94.25 90.07,94.2 86.82,94.2 86.94,94.32 86.94,94.34 88.85,96.25 93.04,96.25
+VCCIOP on BOTTOM (solid shape): 93.97,96.84 94.46,96.84 94.56,96.74 94.56,94.4 94.44,94.28 94.43,94.28 94.35,94.19 93.58,94.19 93.42,94.03 93.42,93.11 93.36,93.05 90.9,93.05 90.82,93.13 90.82,94.47 90.63,94.66 89.1,94.66 88.72,95.04 88.72,97.14 89.23,97.64 93.17,97.64
+VCCSA on TOP (solid shape): outline of 1173 points within 134.81,99.54 154.7,121.56
+VCCSA on BOTTOM (solid shape): 155.65,119.34 156.1,119.34 156.79,118.64 156.79,116.31 156.16,115.68 155.78,115.68 155.77,115.67 151.71,115.67 151.4,115.98 151.4,119.91 152.16,120.67 154.32,120.67
+VCCSA on BOTTOM (solid shape): outline of 363 points within 135.89,105.42 138.51,112.42
+VCCSA on IN3 (solid shape): outline of 1955 points within 136.2,106.04 155.11,121.1
+VCCSA on VCC: 134.73,99.58 134.5,99.81 134.5,103.92 135.77,105.19 135.77,114.08 136.51,114.82 150.16,114.82 152.09,116.75 152.1,120.99 156.82,120.99 157.3,120.51 157.3,113.92 152.81,109.43 139.47,109.43 138.43,108.39 138.43,105.78 136.78,104.13 136.78,99.58
+VCCST on TOP (solid shape): 147.01,84.94 149.29,82.67 149.29,76.47 149.1,76.28 146.44,76.28 145.48,77.23 145.48,80.3 145.48,81.4 143.4,83.48 143.4,84.37 144.21,85.19 146.77,85.19
+VCCST on TOP (solid shape): 140.68,108.16 140.68,107.44 140.62,107.38 140.59,107.39 140.3,107.3 140.22,107.01 140.22,106.98 139.93,106.69 139.07,106.69 138.94,106.56 138.94,106.18 138.94,105.35 138.76,105.17 138.76,103.56 138.71,103.51 138.13,103.51 138.11,103.53 138.11,104.15 137.88,104.38 137.55,104.38 137.44,104.49 137.44,105.29 137.72,105.57 138.11,105.57 138.28,105.74 138.28,107.2 138.88,107.8 138.9,107.8 139.11,107.9 139.2,108.11 139.21,108.13 139.42,108.34 140.5,108.34
+VCCST on IN2 (solid shape): outline of 4880 points within 138.25,79.64 147.08,107.78
+VCCSTG on TOP (solid shape): 153.31,80.38 153.31,76.67 152.92,76.28 150.35,76.28 150.06,76.56 150.06,77.2 150.87,78 150.87,79.76 151.96,80.85 152.85,80.85
+VCCSTG on TOP (solid shape): outline of 361 points within 139.04,104.59 147.94,107.85
+VCCSTG on BOTTOM (solid shape): 98.32,104.93 99.69,104.93 99.76,104.86 99.76,103.47 99.62,103.34 98.95,103.34 98.17,104.12 96.98,104.12 96.6,103.74 96.41,103.74 96.21,103.93 96.21,104.98 96.57,105.33 97.92,105.33
GND on TOP (solid shape): 111.72,95.61 111.72,94.27 111.66,94.21 110.77,94.21 110.7,94.27 110.7,95.67 110.77,95.73 111.59,95.73
GND on TOP (solid shape): 114.13,95.61 114.13,94.27 114.1,94.24 113.15,94.24 113.12,94.27 113.12,95.67 113.18,95.73 114.01,95.73
GND on TOP (solid shape): 116.74,95.61 116.74,94.27 116.67,94.21 115.78,94.21 115.72,94.27 115.72,95.61 115.85,95.73 116.61,95.73
GND on TOP (solid shape): 119.15,95.61 119.15,94.27 119.09,94.21 118.2,94.21 118.13,94.27 118.13,95.67 118.26,95.8 118.96,95.8
GND on TOP (solid shape): 120.86,74.83 120.86,71.52 120.79,71.45 119.73,71.45 119.63,71.55 119.63,74.77 119.8,74.94 120.74,74.94
GND on TOP (solid shape): 121.56,95.67 121.56,94.27 121.5,94.21 120.61,94.21 120.55,94.27 120.55,95.67 120.67,95.8 121.44,95.8
GND on TOP (solid shape): 122.83,74.78 122.83,71.54 122.77,71.48 121.35,71.48 121.06,71.77 121.06,74.77 121.25,74.97 122.64,74.97
GND on TOP (solid shape): 124.55,70.33 124.55,67.6 124.29,67.35 121.24,67.35 120.99,67.6 120.99,70.4 121.31,70.71 124.17,70.71
GND on TOP (solid shape): 141.72,76.27 141.72,73.38 141.39,73.05 140.03,73.05 139.88,73.19 139.88,76.27 139.95,76.33 141.66,76.33
GND on TOP (solid shape): 142.07,70.71 142.07,67.92 141.76,67.6 138.9,67.6 138.52,67.98 138.52,70.71 138.77,70.97 141.82,70.97
GND on TOP (solid shape): 149.3,121.01 149.3,118.22 149.17,118.09 145.94,118.09 145.68,118.34 145.68,120.82 146,121.14 149.17,121.14
GND on TOP (solid shape): 149.56,60.26 149.56,59.9 148.73,59.08 146.76,59.08 146.7,59.14 146.7,59.91 147.55,60.76 149.06,60.76
GND on TOP (solid shape): 157.12,173.13 157.12,170.71 156.58,170.17 156.43,170.17 156.3,170.29 156.3,173.13 156.43,173.26 157,173.26
