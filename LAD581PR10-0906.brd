# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CRX_GTX_P10: length 114.4
  IN4 w0.089: v2(140.53,99.27) 140.23,99.27 140.11,99.14 140.11,98.95 140.23,98.83 141.05,98.83 141.62,98.26 143.08,98.26 143.54,98.71 143.54,102.27 144.16,102.89 145.94,102.89 146.08,103.03 146.08,103.11 146.08,103.12 146.08,103.16
  IN4 w0.147: v2(104.52,140.57) 104.24,140.85 104.24,141.1 104.43,141.29 108.93,141.29 109.37,140.85 116.91,140.85 117.59,140.17 131.79,140.17 132.22,139.74 139.92,139.74 140.41,139.26 145.15,139.26 145.85,139.96 148.88,139.96 149.62,139.22 157.49,139.22 160.08,136.64 160.08,117.97 160.52,117.52 160.52,115.84 158.78,114.09 157.19,114.09 149.13,106.03 147.31,106.03 146.08,104.8 146.08,104.61 146.08,104.61 146.08,103.16
  BOTTOM w0.076: v2(140.53,99.27) 140.53,99.19 CPU1.E20
  BOTTOM w0.114: CM68.1 104.41,142.23 104.41,140.68 v2(104.52,140.57)
PEG_CRX_GTX_P11: length 114.4
  IN4 w0.089: v2(141.19,99.25) 141.31,99.12 141.31,98.82 141.67,98.46 142.65,98.46 143.27,99.09 143.27,100.29
  IN4 w0.147: v2(107.21,140.84) 107.21,140.14 107.33,140.01 108,140.01 108.3,140.32 109.19,140.32 109.5,140.01 109.5,139.7 109.64,139.55 110.09,139.55 110.23,139.7 110.23,140.01 110.54,140.32 111.21,140.32 111.52,140.01 111.52,139.7 111.67,139.55 112.11,139.55 112.25,139.7 112.25,140.01 112.56,140.32 113.23,140.32 113.54,140.01 113.54,139.7 113.69,139.55 114.13,139.55 114.28,139.7 114.28,140.01 114.58,140.32 116.7,140.32 117.37,139.64 131.48,139.64 131.9,139.22 139.7,139.22 140.19,138.73 145.38,138.73 146.08,139.43 148.66,139.43 149.4,138.69 157.27,138.69 159.55,136.41 159.55,117.46 156.25,114.16 155.82,114.16 155.62,114.36 155.44,114.36 155.09,114.02 155.09,113.84 155.3,113.64 155.3,113.2 153.32,111.23 152.88,111.23 152.43,111.68 152.25,111.68 151.9,111.34 151.9,111.16 152.36,110.7 152.36,110.27 151.89,109.8 151.45,109.8 150.96,110.28 150.78,110.28 150.44,109.94 150.44,109.76 150.93,109.27 150.93,108.84 150.19,108.1 147.34,108.1 146.74,107.5 146.71,107.5 146.19,106.98 144.89,106.98 143.27,105.35 143.27,100.29
  BOTTOM w0.076: CPU1.E21 140.86,99.57 v2(141.19,99.25)
  BOTTOM w0.114: CM67.1 106.98,142.2 106.98,141.06 v2(107.21,140.84)
PEG_CRX_TTX_N12: length 97.3
  TOP w0.114: v2(160.95,154.98) 160.95,154.04 160.03,153.12 160.03,151.98 159.53,151.47 157.75,151.47 157.45,151.77 156.68,151.77 CT16.1
  IN5 w0.104: v2(160.95,154.98) 160.8,154.83 160.8,154.62 161.05,154.37 164.28,154.37 165.27,153.38 165.27,150.77 167.59,148.45 167.59,144.59 171.44,140.74 171.44,112.83 169.77,111.15 169.77,107.57 161.4,99.21 158.27,99.21 157.91,98.85 155.94,98.85 154.85,97.77 154.37,97.77 153.25,98.89 152.56,98.89 152.22,99.23 148.48,99.23 147.47,100.24 147.3,100.41 144.93,100.41 144.14,99.62 141.55,99.62 140.92,100.24 140.74,100.24 v2(140.53,100.03)
  BOTTOM w0.089: CPU1.F22 140.21,100.34 v2(140.53,100.03)
PEG_CRX_TTX_N12_C: length 2.6
  TOP w0.094: UT1.V22 154,152.53 154.77,152.53 155.46,151.84 155.75,151.84 CT16.2
PEG_CRX_TTX_N13: length 89.6
  TOP w0.114: CT2.1 156.75,154.13 156.81,154.13 156.94,154.27 157.43,154.27 157.85,153.85 158.08,153.85 158.1,153.83 158.64,153.83 158.66,153.85 158.88,153.85 159.24,153.5 v2(159.24,153.43)
  IN5 w0.104: v2(159.24,153.43) 159.24,153.56 159.56,153.88 160.04,153.88 160.42,153.5 163.09,153.5 164.35,152.24 164.35,150.44 166.7,148.09 166.7,143.92 170.57,140.05 170.57,113.19 168.87,111.49 168.87,107.92 162.07,101.12 161.61,101.12 160.59,100.1 148.84,100.1 147.95,100.99 143.7,100.99 142.9,100.2 141.79,100.2 141.49,100.49 141.49,100.68 141.64,100.82 v2(141.83,100.82)
  BOTTOM w0.089: CPU1.D23 141.51,100.95 141.64,100.82 v2(141.83,100.82)
PEG_CRX_TTX_N13_C: length 2.5
  TOP w0.089: UT1.P22 153.77,154.58
  TOP w0.094: CT2.2 155.82,154.05 155.25,154.05 154.87,154.43 154.5,154.43 154.44,154.37 153.98,154.37 153.77,154.58
PEG_CRX_TTX_N14: length 85.4
  TOP w0.114: CT108.1 156.68,156.64 156.89,156.64 v2(157.09,156.84)
  IN5 w0.104: v2(157.09,156.84) 157.72,156.84 158.07,156.49 158.07,156.11 157.01,155.06 157.01,151.46 158.2,150.28 158.2,149.71 159.5,148.41 161.26,148.41 162.93,146.73 162.93,142.95 167.37,138.51 167.37,114.52 165.64,112.78 165.64,110.7 162.09,107.15 162.09,106.77 160.18,104.86 148.6,104.86 148.03,105.43 147.02,105.43 146.48,104.9 146.48,103.31 145.62,102.45 143.9,102.45 142.65,101.2 140.94,101.2 v2(140.54,101.6)
  BOTTOM w0.089: v2(140.54,101.6) 140.21,101.92 CPU1.F24
PEG_CRX_TTX_N14_C: length 2.4
  TOP w0.094: UT1.K22 153.98,156.63 154.02,156.67 154.4,156.67 154.53,156.54 155.72,156.54 CT108.2
PEG_CRX_TTX_N15: length 86
  TOP w0.114: v2(157.1,158.34) 157.1,158.57 156.97,158.7 156.75,158.7 CT110.1
  IN5 w0.104: v2(157.1,158.34) 156.94,158.34 156.81,158.47 156.81,158.63 156.94,158.76 157.4,158.76 157.58,158.58 157.58,158.24 156.14,156.81 156.14,150.09 157.24,149 157.67,149 159.13,147.53 160.9,147.53 162.06,146.37 162.06,142.59 165.37,139.28 165.37,118.49 165.79,118.07 165.79,114.16 164.76,113.14 164.76,111.12 161.5,107.85 161.24,107.85 160.92,107.53 160.92,106.96 159.78,105.82 150.76,105.82 150.25,106.33 146.77,106.33 145.9,105.46 145.9,103.55 145.43,103.08 143.71,103.08 142.46,101.83 141.77,101.83 141.64,101.96 141.64,102.16 v2(141.86,102.37)
  BOTTOM w0.089: CPU1.D25 141.51,102.72 v2(141.86,102.37)
PEG_CRX_TTX_N15_C: length 2.5
  TOP w0.094: CT110.2 155.25,158.49 154.81,158.05 154,158.05 UT1.F22
PEG_CRX_TTX_P12: length 97.3
  TOP w0.114: CT14.1 156.75,151.99 157.54,151.99 157.84,151.7 159.43,151.7 159.81,152.07 159.81,153.22 160.72,154.13 160.72,154.66 160.44,154.94 v2(160.25,154.94)
  IN5 w0.104: v2(140.51,100.81) 140.51,100.56 140.64,100.43 141,100.43 141.63,99.81 144.06,99.81 144.85,100.6 147.38,100.6 147.84,100.14 148.56,99.42 152.3,99.42 152.64,99.08 153.33,99.08 154.45,97.96 154.77,97.96 155.86,99.05 157.83,99.05 158.19,99.4 161.32,99.4 169.57,107.65 169.57,111.23 171.25,112.91 171.25,140.66 167.4,144.51 167.4,148.37 165.08,150.69 165.08,153.3 164.2,154.18 160.97,154.18 160.61,154.54 160.61,154.79 160.46,154.94 v2(160.25,154.94)
  BOTTOM w0.089: CPU1.E22 140.86,100.46 v2(140.51,100.81)
PEG_CRX_TTX_P12_C: length 2.6
  TOP w0.094: CT14.2 155.78,152.03 155.54,152.03 154.85,152.73 154.59,152.73 154.56,152.76 154.56,152.94 154.51,152.99 154.18,152.99 154.13,152.95 154.13,152.86 UT1.V23
PEG_CRX_TTX_P13: length 89.6
  TOP w0.114: CT12.1 157.52,154.49 157.94,154.08 v4(158.37,154.08) v2(159.21,154.08)
  IN5 w0.104: v2(159.21,154.08) 160.12,154.08 160.5,153.69 163.17,153.69 164.55,152.32 164.55,150.52 166.9,148.17 166.9,144 170.76,140.13 170.76,113.11 169.07,111.41 169.07,107.84 162.15,100.93 161.69,100.93 160.67,99.91 148.76,99.91 147.87,100.8 143.78,100.8 142.98,100 141.71,100 141.3,100.41 141.3,100.66 v2(141.15,100.81)
  BOTTOM w0.089: CPU1.E23 140.86,101.1 v2(141.15,100.81)
PEG_CRX_TTX_P13_C: length 2.5
  TOP w0.094: UT1.P23 154.13,154.7 154.13,154.79 154.18,154.83 154.51,154.83 154.56,154.78 154.56,154.65 154.6,154.61 154.95,154.61 155.33,154.23 155.75,154.23 155.95,154.44 CT12.2
PEG_CRX_TTX_P14: length 85.5
  TOP w0.114: v2(157.15,156.04) 157.15,156.29 157.02,156.42 156.75,156.42 156.54,156.2 CT109.1
  IN5 w0.104: v2(141.16,101.61) 141.16,101.52 141.29,101.39 142.57,101.39 143.82,102.64 145.54,102.64 146.29,103.39 146.29,104.98 146.94,105.63 148.11,105.63 148.68,105.06 160.1,105.06 161.89,106.85 161.89,107.23 165.44,110.78 165.44,112.86 167.18,114.6 167.18,138.43 162.74,142.87 162.74,146.65 161.18,148.21 159.42,148.21 158,149.63 158,150.2 156.82,151.38 156.82,155.14 157.87,156.19 157.87,156.41 157.63,156.65 157.44,156.65 157.25,156.45 156.93,156.45 156.82,156.35 156.82,156.17 156.95,156.04 v2(157.15,156.04)
  BOTTOM w0.089: CPU1.E24 140.86,101.76 141,101.61 v2(141.16,101.61)
PEG_CRX_TTX_P14_C: length 2.4
  TOP w0.089: UT1.K23 154.08,156.44 154.03,156.39
  TOP w0.094: 154.03,156.39 154.03,156.27 154.09,156.21 154.49,156.21 154.64,156.36 155.8,156.36 CT109.2
PEG_CRX_TTX_P15: length 86
  TOP w0.114: CT111.1 156.68,158.92 156.95,158.92 v2(157.16,159.14)
  IN5 w0.104: v2(157.16,159.14) 157.34,158.96 157.46,158.96 157.77,158.66 157.77,158.16 156.34,156.73 156.34,150.17 157.32,149.19 157.75,149.19 159.21,147.73 160.98,147.73 162.25,146.45 162.25,142.67 165.56,139.36 165.56,118.57 165.98,118.15 165.98,114.08 164.96,113.06 164.96,111.04 161.58,107.66 161.32,107.66 161.11,107.45 161.11,106.88 159.86,105.62 150.68,105.62 150.17,106.13 146.85,106.13 146.1,105.38 146.1,103.47 145.51,102.89 143.79,102.89 142.54,101.64 141.66,101.64 141.43,101.87 141.43,102.1 v2(141.16,102.37)
  BOTTOM w0.089: v2(141.16,102.37) 141.16,102.5 140.86,102.79 CPU1.E25
PEG_CRX_TTX_P15_C: length 2.5
  TOP w0.089: 155.36,158.71 155.4,158.75 155.4,158.96 155.5,159.06 155.52,159.06
  TOP w0.094: 155.36,158.71 155.19,158.71 154.75,158.27 154.62,158.27 154.57,158.32 154.57,158.33 154.52,158.38 154.52,158.41 154.44,158.5 154.33,158.5 154.23,158.4 UT1.F23
  TOP w0.114: 155.52,159.06 CT111.2
PEG_CTX_C_GRX_N0: length 6.6
  BOTTOM w0.114: CC1.2 174.03,97.38 174.21,97.38 174.97,98.14 v4(175.36,98.14) 177.59,98.14 177.85,98.4 178.57,98.4 178.77,98.2 179.21,98.2 179.56,97.85 UG9.BK27
PEG_CTX_C_GRX_N1: length 7.9
  BOTTOM w0.114: CC2.2 172.39,98.42 172.52,98.29 173.97,98.29 174.55,98.86 178.54,98.86 178.68,99 178.68,99.31 178.77,99.4 178.95,99.4 179,99.35 UG9.BL29
PEG_CTX_C_GRX_N2: length 4.7
  BOTTOM w0.114: UG9.BM30 178.03,99.68 v4(174.72,99.68) 173.96,99.68 CC3.2
PEG_CTX_C_GRX_N3: length 7.8
  BOTTOM w0.114: CC4.2 172.47,101.04 v4(174.83,101.04) 175.5,101.04 176,100.54 178.64,100.54 178.89,100.29 179.19,100.29 179.53,99.95 UG9.BK30
PEG_CTX_C_GRX_N4: length 6.4
  BOTTOM w0.114: CC5.2 173.85,102.06 174.01,101.9 174.12,101.9 174.26,101.76 175.88,101.76 176.66,100.97 178.52,100.97 178.65,101.1 178.65,101.44 178.77,101.56 178.89,101.56 179.02,101.43 179.02,101.37 UG9.BL32
PEG_CTX_C_GRX_N5: length 6.6
  BOTTOM w0.114: UG9.BM33 178.06,101.81 176.87,101.81 176.68,101.99 v4(176.5,102.18) 176.14,102.54 175.78,102.89 175.36,102.89 175.34,102.91 174.8,102.91 174.78,102.89 172.58,102.89 CC6.2
PEG_CTX_C_GRX_N6: length 6.7
  BOTTOM w0.114: UG9.BK33 179.46,102.05 179.13,102.37 178.91,102.37 178.6,102.68 177.36,102.68 v4(176.5,103.54) 175.92,104.11 173.89,104.11 CC7.2
PEG_CTX_C_GRX_N7: length 8.4
  BOTTOM w0.114: UG9.BL35 179.05,103.49 179.05,103.67 178.94,103.78 178.75,103.78 178.62,103.66 178.62,103.23 178.5,103.11 178.06,103.11 176.17,104.99 174.93,104.99 174.91,105.01 174.37,105.01 174.35,104.99 v4(173.18,104.99) 172.61,104.99 172.39,105.21 CC8.2
PEG_CTX_C_GRX_N8: length 5
  BOTTOM w0.114: JCDRA.4 121.05,169.92 120.99,169.86 v4(120.99,168.18) 120.99,167.06 121.01,167.05 121.01,166.51 120.99,166.49 120.99,166.17 CC9.2
PEG_CTX_C_GRX_N9: length 3.2
  BOTTOM w0.114: JCDRA.7 122.25,169.82 122.17,169.74 v4(122.17,168.67) 122.17,167.91 CC10.2
PEG_CTX_C_GRX_N10: length 4.9
  BOTTOM w0.114: CC11.2 123.37,166.14 v4(123.37,168.12) 123.37,169.78 123.45,169.87 JCDRA.10
PEG_CTX_C_GRX_N11: length 3.2
  BOTTOM w0.114: JCDRA.13 124.65,169.95 124.6,169.89 124.6,169.88 124.57,169.86 v4(124.57,168.59) 124.57,167.92 CC12.2
PEG_CTX_C_GRX_P0: length 6.6
  BOTTOM w0.114: CC13.2 174.04,97.12 174.26,97.12 175.06,97.92 v4(176.63,97.92) 177.69,97.92 177.94,98.17 178.48,98.17 178.63,98.03 178.63,97.61 178.75,97.48 178.93,97.48 179.06,97.61 179.06,97.79 UG9.BL27
PEG_CTX_C_GRX_P1: length 7.9
  BOTTOM w0.114: CC14.2 172.58,98.07 174.07,98.07 174.64,98.64 178.63,98.64 178.92,98.93 179.13,98.93 179.46,99.25 UG9.BK29
PEG_CTX_C_GRX_P2: length 4.7
  BOTTOM w0.114: UG9.BM29 178.1,99.45 v4(176.07,99.45) 175,99.45 174.99,99.43 174.45,99.43 174.43,99.45 174.03,99.45 CC15.2
PEG_CTX_C_GRX_P3: length 7.8
  BOTTOM w0.114: UG9.BL30 179.04,99.91 179.04,99.73 178.96,99.66 178.77,99.66 178.64,99.78 178.64,100.16 178.48,100.32 175.91,100.32 175.41,100.82 175.12,100.82 175.1,100.8 174.56,100.8 174.54,100.82 172.72,100.82 172.66,100.75 172.63,100.75 172.39,100.52 CC16.2
PEG_CTX_C_GRX_P4: length 6.4
  BOTTOM w0.114: CC17.2 175.78,101.54 176.57,100.75 178.64,100.75 178.92,101.03 179.13,101.03 179.46,101.35 UG9.BK32
PEG_CTX_C_GRX_P5: length 6.6
  BOTTOM w0.114: CC18.2 172.61,102.67 v4(175.07,102.67) 175.69,102.67 176.14,102.22 176.14,102.2 176.52,101.82 176.54,101.82 176.78,101.58 178.07,101.58 UG9.BM32
PEG_CTX_C_GRX_P6: length 6.7
  BOTTOM w0.114: CC19.2 173.85,103.52 174.22,103.89 175.83,103.89 176.14,103.58 176.14,103.56 176.52,103.17 176.54,103.17 177.26,102.45 178.51,102.45 178.64,102.32 178.64,101.88 178.73,101.79 178.93,101.79 179.01,101.86 179.01,102.04 UG9.BL33
PEG_CTX_C_GRX_P7: length 8.4
  BOTTOM w0.114: UG9.BK35 179.46,103.45 179.13,103.13 178.92,103.13 178.67,102.88 177.97,102.88 176.08,104.77 v4(174.64,104.77) 173.47,104.77 173.45,104.75 172.91,104.75 172.89,104.77 172.55,104.77 CC20.2
PEG_CTX_C_GRX_P8: length 5
  BOTTOM w0.114: JCDRA.3 120.65,169.92 120.77,169.8 120.77,168.57 120.75,168.56 120.75,167.91 120.77,167.89 v4(120.77,166.78) 120.77,166.09 CC21.2
PEG_CTX_C_GRX_P9: length 3.2
  BOTTOM w0.114: CC22.2 121.95,167.91 121.95,168.38 121.93,168.4 121.93,168.94 121.95,168.96 121.95,169.77 121.85,169.87 JCDRA.6
PEG_CTX_C_GRX_P10: length 4.9
  BOTTOM w0.114: CC23.2 123.14,166.11 123.14,167.84 123.13,167.86 123.13,168.38 123.14,168.4 123.14,169.78 123.05,169.87 JCDRA.9
PEG_CTX_C_GRX_P11: length 3.2
  BOTTOM w0.114: JCDRA.12 124.25,169.87 124.35,169.78 124.35,168.87 124.33,168.85 124.33,168.33 124.35,168.31 124.35,167.89 CC24.2
PEG_CTX_GRX_N0: length 77.7
  IN5 w0.104: v2(145.76,90.67) 145.89,90.55 145.89,89.89 146.54,89.24 147.51,89.24 148.19,88.56 148.19,82.37 148.08,82.27 147.8,82.27 147.59,82.05 147.59,81.58 147.8,81.36 148.08,81.36 148.19,81.26 148.19,80.95 148.08,80.84 147.8,80.84 147.59,80.62 147.59,80.15 147.8,79.94 148.08,79.94 148.19,79.83 148.19,79.52 148.08,79.41 147.8,79.41 147.59,79.2 147.59,78.72 147.8,78.51 148.08,78.51 148.19,78.4 148.19,78.09 148.08,77.99 147.8,77.99 147.59,77.77 147.59,77.3 147.8,77.08 148.08,77.08 148.19,76.98 148.19,76.68 148.76,76.11 149.15,76.11 149.25,76.01 149.25,75.3 149.47,75.08 149.94,75.08 150.16,75.3 150.16,76.01 150.26,76.11 150.58,76.11 150.68,76.01 150.68,74.33 150.9,74.12 151.37,74.12 151.59,74.33 151.59,76.01 151.69,76.11 152,76.11 152.11,76.01 152.11,74.33 152.32,74.12 152.8,74.12 153.01,74.33 153.01,76.01 153.12,76.11 153.43,76.11 153.53,76.01 153.53,74.33 153.75,74.12 154.22,74.12 154.44,74.33 154.44,76.01 154.55,76.11 154.98,76.11 156.07,77.2 162.04,77.2 164.21,79.36 164.21,81.08 164.82,81.69 164.82,84.97 165.01,85.17 165.01,86.69 166,87.68 166.66,87.68 168.86,89.88 168.86,93.2 v2(169.17,93.51)
  BOTTOM w0.076: CPU1.B10 142.56,90.98 142.46,90.88 142.46,90.78 142.56,90.68 143.74,90.68 143.83,90.59 144.8,90.59 145.13,90.26 145.85,90.26 145.98,90.39 145.98,90.57 145.87,90.67 v2(145.76,90.67)
  BOTTOM w0.114: CC1.1 173.06,97.35 172.28,97.35 170.17,95.25 170.17,93.92 169.31,93.05 169.13,93.05 168.98,93.2 168.98,93.32 v2(169.17,93.51)
PEG_CTX_GRX_N1: length 76.7
  IN5 w0.104: v2(167.35,93.5) 167.58,93.73 167.58,94.37 167.34,94.61 165.95,94.61 165.69,94.36 165.69,93.05 165.82,92.92 167.87,92.92 168.14,92.66 168.14,92.14 167.92,91.93 167.26,91.93 167.15,91.82 167.15,91.51 167.26,91.4 167.92,91.4 168.14,91.19 168.14,90.11 167.62,89.59 167.07,89.59 166.06,90.6 165.91,90.6 165.69,90.38 165.69,90.24 166.82,89.1 166.82,88.8 166.42,88.4 166.12,88.4 165.34,89.18 165.19,89.18 164.97,88.96 164.97,88.81 165.41,88.36 165.41,88.06 163.5,86.14 163.5,85.73 163.6,85.63 163.92,85.63 164.14,85.41 164.14,84.94 163.92,84.72 163.6,84.72 163.5,84.62 163.5,84.31 163.6,84.2 163.92,84.2 164.14,83.98 164.14,83.51 163.92,83.29 163.6,83.29 163.5,83.19 163.5,82.77 163.6,82.67 163.92,82.67 164.14,82.45 164.14,81.98 163.92,81.76 163.16,81.76 163.03,81.63 163.03,81.09 162.79,80.85 162.25,80.85 161.96,80.56 161.96,80.06 162.06,79.95 162.59,79.95 162.8,79.74 162.8,79.26 162.59,79.05 162.06,79.05 161.96,78.94 161.96,78.29 161.55,77.88 154.48,77.88 153.54,76.94 150.92,76.94 150.49,77.36 149.27,77.36 148.86,77.76 148.86,88.9 147.68,90.09 147.68,90.51 v2(147.51,90.68)
  BOTTOM w0.076: 144.66,91.35 143.85,91.35 143.76,91.26 143.13,91.26 142.91,91.48 142.91,91.67 CPU1.B11
  BOTTOM w0.089: 144.66,91.35 147.31,91.35 147.39,91.35 147.46,91.35 147.63,91.18 147.63,90.81 147.64,90.8 v2(147.51,90.68)
  BOTTOM w0.114: v2(167.35,93.5) 167.57,93.72 167.57,94.32 167.98,94.74 168.41,94.74 170.49,96.81 170.49,97.81 171.19,98.51 171.68,98.51 171.81,98.64 CC2.1
PEG_CTX_GRX_N2: length 76.5
  IN5 w0.104: v2(165.44,95.38) 165.66,95.59 165.66,95.72 165.53,95.85 164.03,95.85 163.85,95.66 163.85,95.15 164,95 164.77,95 165.01,94.76 165.01,94.21 164.8,93.99 164.04,93.99 163.94,93.89 163.94,93.57 164.04,93.47 164.8,93.47 165.01,93.25 165.01,92.35 165.12,92.25 166.26,92.25 166.47,92.03 166.47,91.56 166.26,91.34 165.12,91.34 165.01,91.24 165.01,89.96 163.93,88.88 163.93,88.74 164.38,88.29 164.38,87.98 164.05,87.65 163.74,87.65 163.29,88.1 163.15,88.1 162.92,87.87 162.92,87.73 163.37,87.28 163.37,86.97 163.04,86.64 162.73,86.64 162.28,87.09 162.14,87.09 161.67,86.62 161.67,86.36 162.82,85.22 162.82,82.38 161.28,80.84 161.28,78.95 160.88,78.56 154.26,78.56 154.13,78.69 153.58,78.69 153.48,78.59 153.48,77.83 153.26,77.61 152.79,77.61 152.57,77.83 152.57,78.59 152.46,78.69 152.15,78.69 152.05,78.59 152.05,77.83 151.83,77.61 151.36,77.61 151.14,77.83 151.14,78.59 151.04,78.69 150.09,78.69 149.54,79.24 149.54,89.89 148.17,91.26 145.82,91.26 145.43,91.66 145.43,92.5 v2(145.33,92.6)
  BOTTOM w0.076: v2(145.33,92.6) 145.37,92.6 145.55,92.43 145.55,92.28 145.39,92.13 143.84,92.13 143.71,92.25 142.5,92.25 142.43,92.32 142.43,92.47 142.51,92.55 CPU1.B12
  BOTTOM w0.114: v2(165.44,95.38) 165.6,95.53 165.6,95.84 165.85,96.1 168.3,96.1 169.63,97.42 169.63,98.03 171.22,99.63 172.98,99.63 CC3.1
PEG_CTX_GRX_N3: length 77.2
  IN5 w0.104: v2(147.06,92.62) 147.19,92.49 147.19,92.18 147.43,91.94 148.45,91.94 150.22,90.17 150.22,79.61 150.46,79.37 151.19,79.37 151.41,79.59 151.41,79.94 151.52,80.05 151.83,80.05 151.93,79.94 151.93,79.59 152.15,79.37 152.62,79.37 152.84,79.59 152.84,79.94 152.94,80.05 153.26,80.05 153.36,79.94 153.36,79.59 153.58,79.37 154.41,79.37 154.54,79.23 160.36,79.23 160.6,79.47 160.6,80.14 160.36,80.38 155.56,80.38 155.43,80.51 155.43,80.93 155.54,81.04 156.71,81.04 156.93,81.25 156.93,81.73 156.71,81.94 155.54,81.94 155.43,82.05 155.43,83.24 155.54,83.35 155.96,83.35 156.17,83.57 156.17,84.04 155.96,84.26 155.54,84.26 155.43,84.36 155.43,84.83 155.66,85.06 156.09,85.06 158.06,87.03 161.12,87.03 162.27,88.18 162.27,89 162.4,89.13 163.22,89.13 164.34,90.25 164.34,91.29 163.17,92.45 163.17,96.1 164.06,96.99 165.56,96.99 165.69,96.86 165.69,96.67 165.56,96.54 v2(165.5,96.54)
  BOTTOM w0.076: CPU1.B13 142.88,93.28 142.88,93 143.04,92.84 143.69,92.84 143.92,93.07 147.12,93.07 147.23,92.95 147.23,92.76 147.09,92.62 v2(147.06,92.62)
  BOTTOM w0.114: CC4.1 171.59,100.9 171.15,100.9 170.36,100.1 170.36,99.92 170.36,99.81 168.86,98.31 168.86,97.67 168.51,97.32 165.98,97.32 165.67,97.01 165.67,96.72 v2(165.5,96.54)
PEG_CTX_GRX_N4: length 79.3
  IN5 w0.104: v2(145.26,94.13) 145.49,93.9 145.49,93.41 145.85,93.05 148.47,93.05 150.9,90.62 150.9,80.96 151.14,80.72 151.55,80.72 151.76,80.94 151.76,85.02 151.87,85.12 152.18,85.12 152.28,85.02 152.28,80.94 152.5,80.72 152.97,80.72 153.19,80.94 153.19,85.02 153.29,85.12 153.61,85.12 153.71,85.02 153.71,80.94 153.93,80.72 154.51,80.72 154.75,80.96 154.75,85.45 155.04,85.74 155.81,85.74 157.78,87.7 160.84,87.7 161.59,88.46 161.59,89.54 161.87,89.81 162.94,89.81 163.66,90.53 163.66,91 163.32,91.34 162.84,91.34 162.49,91.69 162.49,96.38 164.37,98.25 167.05,98.25 167.05,98.25 167.07,98.25 167.21,98.11 167.21,97.93 v2(167.07,97.8)
  BOTTOM w0.076: CPU1.B14 142.54,94.13 142.48,94.06 142.48,93.93 142.58,93.83 143.67,93.83 143.79,93.71 144.71,93.71 144.74,93.73 145.45,93.73 145.51,93.8 145.51,94.01 145.39,94.13 v2(145.26,94.13)
  BOTTOM w0.114: v2(167.07,97.8) 167.18,97.9 167.18,98.48 167.46,98.77 168.28,98.77 169.63,100.12 169.63,100.42 171.15,101.94 172.95,101.94 CC5.1
PEG_CTX_GRX_N5: length 76.8
  IN5 w0.104: v2(165.67,99.3) 165.86,99.49 165.86,99.63 165.64,99.86 165,99.86 161.81,96.67 161.81,90.79 161.44,90.42 161.02,90.42 160.92,90.32 160.92,88.75 160.7,88.53 160.23,88.53 160.01,88.75 160.01,90.32 159.9,90.42 159.53,90.42 159.32,90.2 159.32,88.7 159.1,88.48 158.63,88.48 158.41,88.7 158.41,90.31 158.31,90.42 157.41,90.42 157.31,90.31 157.31,88.19 157.07,87.95 156.65,87.95 156.4,88.2 156.4,90.31 156.3,90.42 155.85,90.42 155.75,90.31 155.75,86.63 155.53,86.41 155.06,86.41 154.84,86.63 154.84,89.83 154.74,89.94 154.26,89.94 154.15,89.83 154.15,86.08 153.94,85.86 153.46,85.86 153.25,86.08 153.25,89.83 153.14,89.94 152.7,89.94 152.53,89.77 152.53,86.06 152.27,85.8 151.84,85.8 151.58,86.06 151.58,90.9 148.75,93.73 147.96,93.73 147.93,93.73 147.55,93.73 147.31,93.97 147.31,94.2 v2(147.12,94.39)
  BOTTOM w0.076: v2(147.12,94.39) 147.27,94.53 147.27,94.71 147.12,94.86 145.56,94.86 145.25,94.54 143.83,94.54 143.72,94.43 143.13,94.43 142.91,94.65 142.91,94.82 CPU1.B15
  BOTTOM w0.114: CC6.1 171.6,102.88 170.97,102.88 168.88,100.79 168.88,100.42 168.5,100.04 166.11,100.04 165.85,99.79 165.85,99.48 v2(165.67,99.3)
PEG_CTX_GRX_N6: length 76.6
  IN5 w0.104: v2(144.7,95.59) 144.92,95.38 144.92,95.19 145.22,94.89 149.78,94.89 150.15,94.53 150.15,94.38 149.75,93.99 149.75,93.68 150.09,93.35 150.4,93.35 150.79,93.74 150.93,93.74 151.47,93.2 151.47,91.96 151.75,91.69 152.28,91.69 152.5,91.9 152.5,93.63 152.6,93.74 152.92,93.74 153.02,93.63 153.02,90.86 153.26,90.62 153.62,90.62 153.93,90.92 153.93,93.63 154.03,93.74 154.34,93.74 154.45,93.63 154.45,90.86 154.69,90.62 155.05,90.62 155.36,90.92 155.36,93.63 155.46,93.74 155.77,93.74 155.88,93.63 155.88,91.35 156.13,91.1 156.57,91.1 156.78,91.31 156.78,93.63 156.89,93.74 157.2,93.74 157.3,93.63 157.3,91.35 157.56,91.1 157.99,91.1 158.21,91.31 158.21,93.63 158.31,93.74 158.63,93.74 158.73,93.63 158.73,91.35 158.99,91.1 159.41,91.1 159.64,91.32 159.64,93.63 159.74,93.74 160.05,93.74 160.16,93.63 160.16,91.36 160.4,91.12 160.85,91.12 161.13,91.4 161.13,97.73 161.26,97.85 161.97,97.85 165.13,101.02 167.58,101.02 167.92,100.68 167.92,100.62 v2(167.77,100.47)
  BOTTOM w0.076: v2(144.7,95.59) 144.86,95.44 144.86,95.16 144.73,95.03 144.06,95.03 143.72,95.38 142.55,95.38 142.47,95.45 142.47,95.61 142.56,95.7 CPU1.B16
  BOTTOM w0.114: v2(167.77,100.47) 167.96,100.65 167.96,100.92 170.95,103.91 173.03,103.91 CC7.1
PEG_CTX_GRX_N7: length 76.6
  IN5 w0.104: v2(166.52,101.75) 166.5,101.75 166.25,101.99 166.25,102.15 166.01,102.39 165.27,102.39 161.6,98.72 160.5,98.72 160.26,98.48 160.26,94.84 160.06,94.63 159.52,94.63 159.4,94.76 159.4,98.11 159.13,98.37 158.46,98.37 158.24,98.15 158.24,94.72 158.14,94.62 157.61,94.62 157.51,94.72 157.51,98.15 157.29,98.37 156.19,98.37 155.95,98.13 155.95,94.73 155.82,94.61 155.07,94.61 154.96,94.71 154.96,97.06 154.75,97.28 154.27,97.28 154.06,97.06 154.06,94.71 153.95,94.61 153.48,94.61 153.35,94.73 153.35,97.94 153.11,98.18 152.48,98.18 152.22,97.92 152.22,94.71 152.12,94.61 151.3,94.61 151.06,94.85 151.06,95.72 151.48,96.13 151.48,98.47 151.21,98.74 150.61,98.74 150.39,98.53 150.39,96.54 150.26,96.41 150,96.41 149.87,96.54 149.87,98.53 149.65,98.74 149.01,98.74 148.8,98.53 148.8,96.46 148.56,96.23 146.8,96.23 146.66,96.37 146.66,97.42 v2(146.74,97.5)
  BOTTOM w0.089: CPU1.B17 142.83,96.49 142.95,96.36 142.95,96.23 143.2,95.99 143.42,95.99 143.86,95.99 144.18,96.31 146.33,96.31 146.56,96.54 146.56,97.34 146.72,97.5 v2(146.74,97.5)
  BOTTOM w0.114: v2(166.52,101.75) 166.35,101.58 166.35,101.34 166.48,101.21 167.21,101.21 171.06,105.07 171.63,105.07 CC8.1
PEG_CTX_GRX_N8: length 128.8
  IN4 w0.089: v2(145.54,97.51) 145.54,98.16 145.69,98.31 147.84,98.31
  IN4 w0.147: 147.84,98.31 149.54,98.31 149.91,98.68 150.12,98.68 150.76,98.05 151.18,98.05 151.67,98.54 151.67,98.96 151.03,99.59 151.03,99.8 152.43,101.2 153.01,101.2 153.96,102.15 154.25,102.15 155.34,101.06 155.75,101.06 156.4,101.71 156.4,102.12 155.63,102.89 155.63,103.07 156.13,103.57 156.31,103.57 157.15,102.73 157.72,102.73 158.75,103.76 158.75,104.7 159.34,105.28 160.51,105.28 162.32,107.09 162.32,109.25 165.52,112.45 165.52,113.45 165.66,113.59 166.23,113.59 166.54,113.9 166.54,114.42 166.23,114.73 165.66,114.73 165.52,114.88 165.52,137.52 158.86,144.17 158.52,144.17 158.52,144.17 154.96,144.17 154.75,144.38 154.75,144.38 154.26,144.87 139.13,144.87 136.78,147.22 136.78,150.47 136.38,150.87 136.38,158.14 133.64,160.88 132.05,160.88 130.52,162.41 128.42,162.41 128.18,162.65 121.04,162.65 120.85,162.84 120.85,163.76 v2(121,163.91)
  BOTTOM w0.089: v2(145.54,97.51) 145.49,97.47 145.49,97.06 145.25,96.81 142.56,96.81 142.36,97.01 142.36,97.08 CPU1.C18
  BOTTOM w0.114: CC9.1 121.03,165.13 121.03,164.98 120.82,164.78 120.82,164.09 v2(121,163.91)
PEG_CTX_GRX_N9: length 126.9
  IN4 w0.147: v2(148.41,97.57) 148.41,97.5 148.52,97.39 148.58,97.39 148.65,97.33 151.23,97.33 154.38,100.48 156.22,100.48 158.52,102.78 158.83,102.78 162.85,106.8 162.85,109.03 167.24,113.43 167.24,136.99 159.41,144.82 155.05,144.82 154.46,145.42 139.33,145.42 137.32,147.43 137.32,150.21 137.56,150.46 137.56,154.9 137.27,155.19 137.27,159.33 134.31,162.28 131.43,162.28 130.18,163.54 124.73,163.54 124.45,163.83 124.45,164.24 124.42,164.27 124.42,164.37 124.32,164.47 124.09,164.47 v2(124.06,164.44)
  BOTTOM w0.089: 147.84,97.3 147.72,97.3 146.96,98.06 143.92,98.06 143.6,97.74 143.25,97.74 143.14,97.85 143.14,97.95 143.27,98.08 143.45,98.08 CPU1.A19
  BOTTOM w0.114: v2(124.06,164.44) 124.13,164.51 124.31,164.51 124.44,164.38 124.44,164.28 124.57,164.15 124.57,163.54 124.44,163.41 122.12,163.41 121.93,163.6 121.93,164.45 121.95,164.47 121.95,165.92 121.97,165.93 121.97,166.39 122.09,166.52 122.25,166.52 122.38,166.65 CC10.1 ; 147.84,97.3 148.18,97.3 148.25,97.38 148.29,97.38 148.41,97.5 v2(148.41,97.57)
PEG_CTX_GRX_N10: length 123.8
  IN4 w0.089: 147.84,99.19 147.72,99.19 147.59,99.06 v2(147.59,98.94)
  IN4 w0.147: v2(122.92,163.8) 123.04,163.92 123.04,164.12 122.92,164.25 122.52,164.25 122.41,164.35 122.09,164.35 121.53,164.92 120.12,164.92 119.32,164.12 119.32,160.02 121.02,158.32 121.02,154.3 123.94,151.39 123.94,148.92 124.59,148.27 125.95,148.27 128.25,145.98 136.89,145.98 138.82,144.04 153.95,144.04 154.63,143.36 158.53,143.36 164.67,137.23 164.67,112.91 162.4,110.64 161.94,110.64 160.94,109.65 160.94,108.95 158.89,106.89 158.89,106.01 158.32,105.43 156.86,105.43 154.7,103.28 153.37,103.28 149.28,99.19 147.84,99.19
  BOTTOM w0.089: CPU1.C20 142.29,98.73 142.29,98.54 142.48,98.35 143.63,98.35 143.72,98.26 147.34,98.26 147.57,98.49 147.57,98.92 v2(147.59,98.94)
  BOTTOM w0.114: CC11.1 123.59,164.34 123.33,164.08 123.2,164.08 v2(122.92,163.8)
PEG_CTX_GRX_N11: length 128.3
  IN4 w0.089: v2(145.56,99.47) 145.82,99.73 145.82,99.9 146.18,100.26 147.79,100.26 147.83,100.3 147.84,100.3
  IN4 w0.147: 147.84,100.3 148.28,100.3 148.46,100.48 148.47,100.48 153.06,105.07 154.33,105.07 156.62,107.36 157.47,107.36 158.49,108.38 158.49,108.79 159.82,110.12 159.82,110.95 163.59,114.71 163.59,136.53 157.92,142.2 154.27,142.2 154.06,142.41 144.25,142.41 143.74,141.9 141.98,141.9 141.98,141.91 141.96,141.91 140.93,142.94 138.4,142.94 136.44,144.9 135.14,144.9 134.95,144.7 129.37,144.7 128.74,144.07 127.92,144.07 125.87,146.12 122.92,146.12 119.89,149.15 119.89,157.92 118.24,159.57 118.24,164.57 119.67,166 124.79,166 125.24,165.56 125.24,165.23 v2(125.38,165.08)
  BOTTOM w0.076: CPU1.A21 143.31,99.64 143.22,99.55 143.22,99.47 143.34,99.35 143.61,99.35 143.7,99.43 144.81,99.43 145.18,99.06 145.94,99.06 146.06,99.19 146.06,99.46 145.9,99.63 145.72,99.63 v2(145.56,99.47)
  BOTTOM w0.114: CC12.1 124.61,166.94 124.61,166.45 124.67,166.39 124.7,166.39 125.08,166.02 125.08,165.98 125.21,165.85 125.21,165.26 v2(125.38,165.08)
PEG_CTX_GRX_P0: length 77.7
  IN5 w0.104: v2(168.58,93.51) 168.67,93.42 168.67,89.96 166.58,87.87 165.92,87.87 164.82,86.77 164.82,85.25 164.62,85.05 164.62,81.77 164.01,81.16 164.01,79.44 161.96,77.39 155.99,77.39 154.9,76.3 154.47,76.3 154.25,76.09 154.25,74.41 154.14,74.31 153.83,74.31 153.73,74.41 153.73,76.09 153.51,76.3 153.04,76.3 152.82,76.09 152.82,74.41 152.72,74.31 152.4,74.31 152.3,74.41 152.3,76.09 152.08,76.3 151.61,76.3 151.39,76.09 151.39,74.41 151.29,74.31 150.98,74.31 150.87,74.41 150.87,76.09 150.66,76.3 150.18,76.3 149.97,76.09 149.97,75.38 149.86,75.27 149.55,75.27 149.45,75.38 149.45,76.09 149.23,76.3 148.84,76.3 148.38,76.76 148.38,77.06 148.16,77.27 147.88,77.27 147.78,77.38 147.78,77.69 147.88,77.79 148.16,77.79 148.38,78.01 148.38,78.48 148.16,78.7 147.88,78.7 147.78,78.8 147.78,79.12 147.88,79.22 148.16,79.22 148.38,79.44 148.38,79.91 148.16,80.13 147.88,80.13 147.78,80.23 147.78,80.54 147.88,80.65 148.16,80.65 148.38,80.87 148.38,81.34 148.16,81.56 147.88,81.56 147.78,81.66 147.78,81.97 147.88,82.08 148.16,82.08 148.38,82.29 148.38,88.64 147.59,89.43 146.62,89.43 146.08,89.97 146.08,90.48 146.27,90.67 v2(146.35,90.67)
  BOTTOM w0.076: v2(146.35,90.67) 146.35,90.52 145.92,90.09 145.02,90.09 144.72,90.39 143.75,90.39 143.66,90.49 142.48,90.49 142.26,90.7 142.26,90.88 CPU1.C10
  BOTTOM w0.114: CC13.1 173.06,97.13 172.37,97.13 170.4,95.16 170.4,93.83 169.4,92.83 169.03,92.83 168.76,93.1 168.76,93.33 v2(168.58,93.51)
PEG_CTX_GRX_P1: length 76.7
  IN5 w0.104: v2(167.93,93.5) 167.77,93.66 167.77,94.45 167.42,94.81 165.87,94.81 165.5,94.44 165.5,92.97 165.74,92.73 167.79,92.73 167.94,92.58 167.94,92.22 167.84,92.12 167.18,92.12 166.96,91.9 166.96,91.43 167.18,91.21 167.84,91.21 167.94,91.11 167.94,90.19 167.54,89.79 167.15,89.79 166.14,90.8 165.83,90.8 165.5,90.46 165.5,90.16 166.63,89.02 166.63,88.88 166.34,88.59 166.2,88.59 165.42,89.37 165.11,89.37 164.77,89.04 164.77,88.73 165.22,88.28 165.22,88.14 163.3,86.22 163.3,85.65 163.52,85.44 163.84,85.44 163.94,85.33 163.94,85.02 163.84,84.91 163.52,84.91 163.3,84.7 163.3,84.23 163.52,84.01 163.84,84.01 163.94,83.9 163.94,83.59 163.84,83.49 163.52,83.49 163.3,83.27 163.3,82.69 163.52,82.47 163.84,82.47 163.94,82.37 163.94,82.06 163.84,81.95 163.08,81.95 162.84,81.71 162.84,81.17 162.71,81.05 162.17,81.05 161.76,80.64 161.76,79.98 161.98,79.76 162.51,79.76 162.61,79.66 162.61,79.34 162.51,79.24 161.98,79.24 161.76,79.02 161.76,78.37 161.47,78.07 154.4,78.07 153.46,77.13 151,77.13 150.57,77.55 149.35,77.55 149.06,77.84 149.06,88.98 147.87,90.17 147.87,90.55 148,90.68 v2(148.1,90.68)
  BOTTOM w0.076: 144.72,91.54 143.77,91.54 143.68,91.45 143.21,91.45 143.1,91.56 143.1,91.67 143.2,91.77 CPU1.A11
  BOTTOM w0.089: 147.83,90.91 147.81,90.93 147.81,91.25 147.54,91.53 147.39,91.53 147.39,91.53 147.31,91.53 144.74,91.53 144.72,91.54
  BOTTOM w0.114: v2(167.93,93.5) 167.79,93.65 167.79,94.23 168.07,94.51 168.51,94.51 170.72,96.72 170.72,97.72 171.25,98.25 171.68,98.25 171.81,98.13 CC14.1 ; v2(148.1,90.68) 148.06,90.68 147.83,90.91
PEG_CTX_GRX_P2: length 76.5
  IN5 w0.104: v2(145.91,92.6) 145.85,92.6 145.62,92.38 145.62,91.74 145.9,91.45 148.25,91.45 149.73,89.97 149.73,79.32 150.17,78.88 151.12,78.88 151.33,78.67 151.33,77.91 151.44,77.81 151.75,77.81 151.85,77.91 151.85,78.67 152.07,78.88 152.54,78.88 152.76,78.67 152.76,77.91 152.87,77.81 153.18,77.81 153.28,77.91 153.28,78.67 153.5,78.88 154.21,78.88 154.34,78.75 160.8,78.75 161.09,79.03 161.09,80.92 162.63,82.46 162.63,85.14 161.48,86.28 161.48,86.7 162.06,87.28 162.36,87.28 162.81,86.83 162.96,86.83 163.18,87.05 163.18,87.2 162.73,87.65 162.73,87.95 163.07,88.29 163.37,88.29 163.82,87.84 163.97,87.84 164.19,88.06 164.19,88.21 163.74,88.66 163.74,88.96 164.82,90.04 164.82,91.32 165.04,91.53 166.18,91.53 166.28,91.64 166.28,91.95 166.18,92.05 165.04,92.05 164.82,92.27 164.82,93.17 164.72,93.28 163.96,93.28 163.74,93.49 163.74,93.97 163.96,94.18 164.72,94.18 164.82,94.29 164.82,94.68 164.69,94.81 163.92,94.81 163.65,95.07 163.65,95.74 163.95,96.04 165.61,96.04 165.85,95.8 165.85,95.55 v2(166.03,95.38)
  BOTTOM w0.076: v2(145.91,92.6) 145.71,92.4 145.71,92.22 145.46,91.96 143.73,91.96 143.63,92.06 142.42,92.06 142.24,92.24 142.24,92.48 CPU1.C12
  BOTTOM w0.114: v2(166.03,95.38) 165.82,95.58 165.82,95.75 165.95,95.88 168.4,95.88 169.85,97.33 169.85,97.94 171.31,99.4 173.01,99.4 CC15.1
PEG_CTX_GRX_P3: length 77.1
  IN5 w0.104: v2(166.08,96.54) 165.88,96.75 165.88,96.94 165.64,97.18 163.98,97.18 162.98,96.18 162.98,92.37 164.14,91.21 164.14,90.33 163.14,89.32 162.32,89.32 162.08,89.08 162.08,88.26 161.04,87.22 157.98,87.22 156.01,85.25 155.58,85.25 155.24,84.91 155.24,84.28 155.46,84.06 155.88,84.06 155.98,83.96 155.98,83.65 155.88,83.54 155.46,83.54 155.24,83.32 155.24,81.97 155.46,81.75 156.63,81.75 156.73,81.65 156.73,81.33 156.63,81.23 155.46,81.23 155.24,81.01 155.24,80.43 155.48,80.19 160.28,80.19 160.41,80.06 160.41,79.55 160.28,79.43 154.62,79.43 154.49,79.56 153.66,79.56 153.55,79.67 153.55,80.02 153.34,80.24 152.86,80.24 152.65,80.02 152.65,79.67 152.54,79.56 152.23,79.56 152.13,79.67 152.13,80.02 151.91,80.24 151.44,80.24 151.22,80.02 151.22,79.67 151.11,79.56 150.54,79.56 150.41,79.69 150.41,90.25 148.53,92.13 147.51,92.13 147.39,92.26 147.39,92.44 147.57,92.62 v2(147.65,92.62)
  BOTTOM w0.076: v2(147.65,92.62) 147.58,92.62 147.4,92.8 147.4,93.02 147.19,93.23 143.81,93.23 143.61,93.03 143.12,93.03 143.07,93.08 143.07,93.2 143.21,93.34 CPU1.A13
  BOTTOM w0.114: v2(166.08,96.54) 165.9,96.73 165.9,96.92 166.07,97.1 168.6,97.1 169.08,97.58 169.08,98.22 170.58,99.72 170.58,100.01 171.25,100.67 171.59,100.67 CC16.1
PEG_CTX_GRX_P4: length 79.3
  IN5 w0.104: v2(167.66,97.8) 167.61,97.8 167.4,98 167.4,98.19 167.15,98.44 167.13,98.44 167.13,98.45 164.29,98.45 162.3,96.46 162.3,91.61 162.76,91.15 163.24,91.15 163.46,90.92 163.46,90.61 162.86,90 161.79,90 161.4,89.62 161.4,88.54 160.76,87.9 157.7,87.9 155.73,85.93 154.96,85.93 154.56,85.53 154.56,81.04 154.43,80.92 154.01,80.92 153.9,81.02 153.9,85.1 153.69,85.32 153.21,85.32 153,85.1 153,81.02 152.89,80.92 152.58,80.92 152.48,81.02 152.48,85.1 152.26,85.32 151.79,85.32 151.57,85.1 151.57,81.02 151.47,80.92 151.22,80.92 151.09,81.04 151.09,90.7 148.55,93.24 145.93,93.24 145.68,93.49 145.68,93.93 v2(145.89,94.13)
  BOTTOM w0.076: v2(145.89,94.13) 145.81,94.13 145.68,94.01 145.68,93.73 145.52,93.57 144.8,93.57 144.78,93.54 143.68,93.54 143.59,93.63 142.5,93.63 142.29,93.85 142.29,94 CPU1.C14
  BOTTOM w0.114: CC17.1 173.26,101.54 173.08,101.72 171.24,101.72 169.85,100.33 169.85,100.03 168.37,98.54 167.56,98.54 167.4,98.39 167.4,98.05 v2(167.66,97.8)
PEG_CTX_GRX_P5: length 76.7
  IN5 w0.104: v2(147.71,94.39) 147.63,94.39 147.5,94.26 147.5,94.05 147.63,93.92 147.93,93.92 147.96,93.92 148.83,93.92 151.77,90.98 151.77,86.14 151.92,85.99 152.19,85.99 152.34,86.14 152.34,89.85 152.62,90.13 153.22,90.13 153.44,89.91 153.44,86.16 153.54,86.06 153.86,86.06 153.96,86.16 153.96,89.91 154.18,90.13 154.82,90.13 155.04,89.91 155.04,86.71 155.14,86.61 155.45,86.61 155.56,86.71 155.56,90.39 155.77,90.61 156.38,90.61 156.59,90.39 156.59,88.28 156.73,88.14 156.99,88.14 157.11,88.27 157.11,90.39 157.33,90.61 158.39,90.61 158.6,90.39 158.6,88.78 158.71,88.67 159.02,88.67 159.13,88.78 159.13,90.28 159.45,90.61 159.98,90.61 160.2,90.4 160.2,88.83 160.31,88.72 160.62,88.72 160.72,88.83 160.72,90.4 160.94,90.61 161.36,90.61 161.62,90.87 161.62,96.75 164.92,100.05 165.72,100.05 166.06,99.71 166.06,99.5 v2(166.26,99.3)
  BOTTOM w0.076: CPU1.A15 143.42,94.96 143.24,94.96 143.12,94.84 143.12,94.72 143.21,94.63 143.64,94.63 143.72,94.7 145.18,94.7 145.49,95.02 147.21,95.02 147.46,94.77 147.46,94.63 v2(147.71,94.39)
  BOTTOM w0.114: v2(166.26,99.3) 166.07,99.48 166.07,99.69 166.2,99.82 168.59,99.82 169.1,100.33 169.1,100.7 171.06,102.66 171.6,102.66 CC18.1
PEG_CTX_GRX_P6: length 76.6
  IN5 w0.104: v2(168.36,100.47) 168.11,100.72 168.11,100.76 168.06,100.82 167.66,101.21 165.05,101.21 161.89,98.05 161.18,98.05 160.94,97.81 160.94,91.48 160.77,91.32 160.48,91.32 160.35,91.44 160.35,93.71 160.13,93.93 159.66,93.93 159.44,93.71 159.44,91.4 159.33,91.29 159.07,91.29 158.92,91.43 158.92,93.71 158.71,93.93 158.23,93.93 158.02,93.71 158.02,91.4 157.9,91.29 157.64,91.29 157.5,91.43 157.5,93.71 157.28,93.93 156.81,93.93 156.59,93.71 156.59,91.4 156.47,91.29 156.21,91.29 156.07,91.43 156.07,93.71 155.85,93.93 155.38,93.93 155.16,93.71 155.16,91 154.97,90.81 154.77,90.81 154.64,90.94 154.64,93.71 154.42,93.93 153.95,93.93 153.73,93.71 153.73,91 153.54,90.81 153.34,90.81 153.21,90.94 153.21,93.71 153,93.93 152.52,93.93 152.31,93.71 152.31,91.98 152.2,91.88 151.83,91.88 151.67,92.04 151.67,93.28 151.01,93.93 150.71,93.93 150.32,93.54 150.17,93.54 149.95,93.76 149.95,93.91 150.34,94.3 150.34,94.61 149.86,95.09 145.3,95.09 145.11,95.27 145.11,95.42 v2(145.29,95.59)
  BOTTOM w0.076: v2(145.29,95.59) 145.02,95.33 145.02,95.09 144.8,94.87 143.99,94.87 143.65,95.21 142.48,95.21 142.28,95.41 142.28,95.59 CPU1.C16
  BOTTOM w0.114: CC19.1 173.03,103.69 171.04,103.69 168.18,100.83 168.18,100.65 v2(168.36,100.47)
PEG_CTX_GRX_P7: length 76.6
  IN5 w0.104: v2(165.92,101.75) 166.06,101.89 166.06,102.07 165.93,102.2 165.35,102.2 161.68,98.53 160.58,98.53 160.46,98.4 160.46,94.76 160.14,94.44 159.44,94.44 159.2,94.68 159.2,98.03 159.05,98.18 158.54,98.18 158.43,98.07 158.43,94.64 158.22,94.43 157.53,94.43 157.32,94.64 157.32,98.07 157.21,98.18 156.27,98.18 156.14,98.05 156.14,94.65 155.9,94.41 154.99,94.41 154.77,94.63 154.77,96.98 154.67,97.09 154.35,97.09 154.25,96.98 154.25,94.63 154.03,94.41 153.4,94.41 153.16,94.65 153.16,97.86 153.03,97.99 152.56,97.99 152.42,97.84 152.42,94.63 152.2,94.41 151.22,94.41 150.87,94.77 150.87,95.8 151.28,96.21 151.28,98.39 151.13,98.55 150.69,98.55 150.58,98.45 150.58,96.46 150.34,96.22 149.92,96.22 149.68,96.46 149.68,98.45 149.57,98.55 149.09,98.55 148.99,98.45 148.99,96.38 148.64,96.04 146.72,96.04 146.47,96.29 146.47,97.25 146.22,97.5 v2(146.2,97.5)
  BOTTOM w0.089: CPU1.A17 143.27,96.49 143.14,96.36 143.14,96.29 143.27,96.17 143.34,96.17 143.78,96.17 144.11,96.49 146.25,96.49 146.38,96.62 146.38,97.31 v2(146.2,97.5)
  BOTTOM w0.114: CC20.1 171.57,104.84 171.15,104.84 167.3,100.99 166.38,100.99 166.13,101.25 166.13,101.54 v2(165.92,101.75)
PEG_CTX_GRX_P8: length 128.9
  IN4 w0.089: v2(144.88,97.52) 145.04,97.52 145.36,97.85 145.36,98.23 145.61,98.49 147.73,98.49 147.82,98.58 147.84,98.58
  IN4 w0.147: 147.84,98.58 149.42,98.58 149.8,98.96 150.23,98.96 150.87,98.32 151.06,98.32 151.39,98.65 151.39,98.84 150.75,99.48 150.75,99.92 152.31,101.47 152.9,101.47 153.84,102.42 154.37,102.42 155.45,101.33 155.63,101.33 156.13,101.83 156.13,102.01 155.36,102.78 155.36,103.18 156.02,103.85 156.43,103.85 157.27,103.01 157.61,103.01 158.48,103.88 158.48,104.81 159.22,105.56 160.4,105.56 162.05,107.2 162.05,109.37 165.24,112.56 165.24,113.56 165.55,113.87 166.12,113.87 166.26,114.01 166.26,114.31 166.12,114.46 165.55,114.46 165.24,114.76 165.24,137.4 158.75,143.89 158.64,143.89 154.85,143.89 154.64,144.11 154.63,144.11 154.15,144.59 139.02,144.59 136.51,147.1 136.51,150.35 136.1,150.76 136.1,158.02 133.52,160.6 131.93,160.6 130.41,162.13 128.31,162.13 128.06,162.38 120.93,162.38 120.58,162.72 120.58,163.75 v2(120.42,163.91)
  BOTTOM w0.089: CPU1.B18 142.78,97.31 142.6,97.31 142.54,97.25 142.54,97.08 142.63,96.99 145.18,96.99 145.32,97.13 145.32,97.22 145.18,97.36 145.18,97.41 145.06,97.52 v2(144.88,97.52)
  BOTTOM w0.114: v2(120.42,163.91) 120.6,164.09 120.6,164.87 120.81,165.07 120.81,165.13 CC21.1
PEG_CTX_GRX_P9: length 126.9
  IN4 w0.147: v2(148.41,96.99) 148.48,97.05 151.34,97.05 154.5,100.21 156.34,100.21 158.64,102.51 158.94,102.51 163.12,106.69 163.12,108.92 167.52,113.31 167.52,137.1 159.52,145.1 155.17,145.1 154.57,145.7 139.44,145.7 137.59,147.54 137.59,150.1 137.83,150.34 137.83,155.02 137.54,155.31 137.54,159.44 134.43,162.56 131.55,162.56 130.29,163.82 124.85,163.82 124.72,163.94 124.72,164.33 v2(124.83,164.44)
  BOTTOM w0.089: CPU1.B19 142.95,97.93 142.95,97.79 143.18,97.56 143.67,97.56 143.99,97.88 146.88,97.88 147.69,97.08 147.84,97.08
  BOTTOM w0.114: CC22.1 121.74,166.03 121.73,166.01 121.73,164.56 121.71,164.54 121.71,163.51 122.03,163.19 124.53,163.19 124.79,163.44 124.79,164.4 v2(124.83,164.44) ; 147.84,97.08 148.33,97.08 v2(148.41,96.99)
PEG_CTX_GRX_P10: length 123.9
  IN4 w0.089: v2(147.02,98.96) 147.52,99.47 147.84,99.47
  IN4 w0.147: v2(122.92,164.72) 122.73,164.52 122.63,164.52 122.53,164.63 122.21,164.63 121.64,165.2 120,165.2 119.05,164.24 119.05,159.9 120.75,158.2 120.75,154.19 123.66,151.27 123.66,148.81 124.47,148 125.84,148 128.14,145.7 136.77,145.7 138.71,143.77 153.84,143.77 154.52,143.09 158.42,143.09 164.39,137.11 164.39,113.03 162.28,110.92 161.83,110.92 160.67,109.76 160.67,109.06 158.62,107.01 158.62,106.12 158.21,105.71 156.75,105.71 154.59,103.55 153.25,103.55 149.17,99.47 147.84,99.47
  BOTTOM w0.089: CPU1.B20 142.62,98.85 142.47,98.7 142.47,98.61 142.55,98.53 143.7,98.53 143.79,98.44 147.27,98.44 147.39,98.56 147.39,98.62 147.23,98.79 147.23,98.94 147.21,98.96 v2(147.02,98.96)
  BOTTOM w0.114: CC23.1 123.36,164.93 123.36,164.43 123.23,164.31 123.03,164.31 122.92,164.41 v2(122.92,164.72)
PEG_CTX_GRX_P11: length 128.3
  IN4 w0.089: v2(146.46,99.47) 146.46,99.34 146.33,99.21 146.13,99.21 146,99.34 146,99.83 146.25,100.08 147.79,100.08 147.84,100.04
  IN4 w0.147: 147.84,100.04 147.86,100.02 148.39,100.02 148.58,100.21 148.58,100.21 153.18,104.8 154.45,104.8 156.73,107.09 157.58,107.09 158.76,108.27 158.76,108.67 160.1,110.01 160.1,110.83 163.86,114.6 163.86,136.65 158.04,142.48 154.39,142.48 154.18,142.68 144.13,142.68 143.63,142.18 142.09,142.18 142.09,142.18 142.08,142.18 141.04,143.22 138.51,143.22 136.55,145.17 135.03,145.17 134.83,144.98 129.26,144.98 128.62,144.34 128.03,144.34 125.98,146.39 123.04,146.39 120.17,149.26 120.17,158.03 118.52,159.68 118.52,164.46 119.79,165.72 124.68,165.72 124.96,165.44 124.96,165.25 v2(124.8,165.08)
  BOTTOM w0.076: v2(146.46,99.47) 146.23,99.24 146.23,99.12 146.01,98.89 145.11,98.89 144.74,99.27 143.76,99.27 143.68,99.18 143.24,99.18 143.03,99.39 143.03,99.54 142.93,99.64 CPU1.B21
  BOTTOM w0.114: v2(124.8,165.08) 124.98,165.27 124.98,165.76 v4(124.72,166.03) 124.39,166.35 124.39,166.89 CC24.1
PEG_CTX_TRX_N12: length 87.4
  TOP w0.114: v2(161.14,153.02) 160.92,152.8 160.92,151.79 159.73,150.6 156.65,150.6 CT15.1
  IN5 w0.104: v2(147.33,101.43) 147.46,101.56 148.07,101.56 148.2,101.43 149.04,100.59 160.22,100.59 161.26,101.62 161.7,101.62 163.09,103 163.09,103.39 168.37,108.67 168.37,111.67 170.09,113.39 170.09,139.85 166.22,143.72 166.22,147.84 164.7,149.36 164.39,149.36 162.31,151.44 162.22,151.44 161.86,151.79 161.2,151.79 160.94,152.05 160.94,152.67 160.93,152.68 160.93,152.89 161.05,153.02 v2(161.14,153.02)
  BOTTOM w0.076: v2(147.33,101.43) 147.31,101.42 147.31,100.86 146.87,100.42 144.86,100.42 144.26,99.82 143.83,99.82 143.72,99.94 142.48,99.94 142.16,100.25 CPU1.C22
PEG_CTX_TRX_N12_C: length 3
  TOP w0.094: CT15.2 155.91,150.53 155.38,150.53 155.13,150.78 155.13,151.27 154.8,151.61 154,151.61 UT1.Y22
PEG_CTX_TRX_N13: length 82.9
  TOP w0.114: v2(159.28,152.15) 159.06,152.36 157.88,152.36 157.29,152.95 156.71,152.95 CT13.1
  IN5 w0.104: v2(145.56,101.43) 145.64,101.43 145.77,101.56 145.77,101.59 145.87,101.69 145.87,101.96 146.68,102.77 146.92,102.77 147,102.77 147,102.77 148.09,102.77 148.2,102.66 149.37,101.5 159.57,101.5 163.93,105.85 163.93,106.34 167.5,109.91 167.5,112.04 169.22,113.75 169.22,139.27 165.24,143.25 165.24,147.59 164.34,148.49 164.03,148.49 161.95,150.57 160.79,150.57 160.07,151.29 160.07,152.31 159.84,152.54 159.67,152.54 159.63,152.5 v2(159.28,152.15)
  BOTTOM w0.076: CPU1.A23 143.35,101.33 143.23,101.33 143.11,101.21 143.11,101.03 143.21,100.93 143.62,100.93 143.7,101.01 145.75,101.01 145.84,101.09 145.84,101.24 145.79,101.29 145.79,101.35 145.7,101.43 v2(145.56,101.43)
PEG_CTX_TRX_N13_C: length 2.6
  TOP w0.089: UT1.T22 153.77,153.66
  TOP w0.094: 153.77,153.66 153.98,153.45 154.11,153.45 154.44,153.45 154.67,153.22 154.8,153.22 155.14,152.87 155.86,152.87 CT13.2
PEG_CTX_TRX_N14: length 82.6
  TOP w0.114: v2(158.79,154.6) 158.67,154.72 158.67,155.06 158.41,155.31 157.87,155.31 157.65,155.54 156.64,155.54 CT18.1
  IN5 w0.104: v2(147.44,103.28) 147.44,103.4 147.56,103.53 148.02,103.53 148.64,102.91 160.26,102.91 163.44,106.09 163.44,106.54 167.01,110.11 167.01,112.24 168.73,113.96 168.73,139.07 164.29,143.51 164.29,147.46 161.66,150.08 160.54,150.08 158.75,151.87 158.75,154.57 v2(158.79,154.6)
  BOTTOM w0.076: CPU1.C24 142.4,101.77 142.4,101.72 142.62,101.49 143.74,101.49 143.83,101.4 144.63,101.4 145.07,101.84 145.88,101.84 146.56,102.51 146.82,102.51 146.95,102.51 147.26,102.82 147.26,103.1 v2(147.44,103.28)
PEG_CTX_TRX_N14_C: length 2.5
  TOP w0.094: UT1.M22 154,155.75 154.4,155.75 154.75,155.4 154.93,155.4 155.16,155.63 CT18.2
PEG_CTX_TRX_N15: length 84
  TOP w0.114: CT21.1 156.73,157.73 157.08,157.73 157.83,156.98 157.83,156.63 158.38,156.08 158.79,156.08 v2(158.96,156.25)
  IN5 w0.104: v2(158.96,156.25) 158.96,156.21 158.67,155.92 158.56,155.92 157.58,154.95 157.58,151.75 160.4,148.93 161.58,148.93 163.42,147.09 163.42,143.15 167.86,138.71 167.86,114.32 166.12,112.58 166.12,110.46 162.57,106.91 162.57,106.51 159.84,103.78 149,103.78 147.8,104.98 147.4,104.98 147.11,104.69 147.11,104.46 146.94,104.29 v2(146.85,104.29)
  BOTTOM w0.076: CPU1.A25 143.31,102.79 143.22,102.69 143.22,102.62 143.34,102.5 143.61,102.5 143.7,102.58 145.39,102.58 146.63,103.82 146.9,103.82 147.04,103.96 147.04,104.1 147.01,104.13 v2(146.85,104.29)
PEG_CTX_TRX_N15_C: length 2.4
  TOP w0.094: UT1.H22 154,157.59 155.43,157.59 155.76,157.92 CT21.2
PEG_CTX_TRX_P12: length 87.4
  TOP w0.114: v2(160.55,153.02) 160.7,152.87 160.7,151.88 159.64,150.82 156.94,150.82 156.7,151.06 CT3.1
  IN5 w0.104: v2(146.74,101.43) 146.89,101.43 146.96,101.5 146.96,101.59 147.17,101.8 148.1,101.8 148.28,101.63 149.12,100.78 160.14,100.78 161.18,101.81 161.62,101.81 162.89,103.08 162.89,103.47 168.18,108.75 168.18,111.75 169.89,113.47 169.89,139.77 166.02,143.64 166.02,147.76 164.62,149.17 164.31,149.17 162.23,151.25 162.14,151.25 161.78,151.6 161.12,151.6 160.74,151.97 160.74,152.59 160.73,152.6 160.73,152.84 v2(160.55,153.02)
  BOTTOM w0.076: CPU1.B22 142.52,100.43 142.44,100.35 142.44,100.23 142.57,100.1 143.79,100.1 143.9,99.99 144.2,99.99 144.79,100.58 146.8,100.58 147.15,100.93 147.15,101.11 146.97,101.29 146.97,101.35 146.89,101.43 v2(146.74,101.43)
PEG_CTX_TRX_P12_C: length 3
  TOP w0.089: 154.19,151.88 154.23,151.84 UT1.Y23
  TOP w0.094: 154.19,151.88 154.19,152.01 154.25,152.06 154.53,152.06 154.61,151.99 154.61,151.88 154.68,151.81 154.88,151.81 155.33,151.36 155.33,150.86 155.46,150.73 155.64,150.73 155.71,150.8 155.75,150.8 155.96,151.01 CT3.2
PEG_CTX_TRX_P13: length 82.9
  TOP w0.114: v2(159.28,152.73) 159.13,152.58 157.97,152.58 157.38,153.17 156.71,153.17 CT1.1
  IN5 w0.104: v2(146.14,101.43) 146.06,101.51 146.06,101.61 146.07,101.61 146.07,101.88 146.76,102.58 146.84,102.58 146.92,102.58 146.92,102.58 148.01,102.58 149.29,101.3 159.65,101.3 164.12,105.77 164.12,106.26 167.69,109.83 167.69,111.96 169.41,113.67 169.41,139.35 165.43,143.33 165.43,147.67 164.42,148.68 164.11,148.68 162.03,150.76 160.87,150.76 160.26,151.37 160.26,152.39 159.92,152.73 v2(159.28,152.73)
  BOTTOM w0.076: 142.96,100.94 142.96,100.94 143.14,100.76 143.69,100.76 143.76,100.84 145.82,100.84 146,101.03 146,101.31 146.13,101.43 v2(146.14,101.43)
  BOTTOM w0.089: 142.96,100.94 142.81,101.09 CPU1.B23
PEG_CTX_TRX_P13_C: length 2.6
  TOP w0.094: CT1.2 155.78,153.52 155.62,153.52 155.56,153.46 155.56,153.15 155.46,153.06 155.21,153.06 154.87,153.4 154.77,153.4 154.59,153.58 154.59,153.68 154.49,153.78 154.34,153.78 UT1.T23
PEG_CTX_TRX_P14: length 82.6
  TOP w0.114: v2(158.2,154.6) 158.26,154.6 158.44,154.78 158.44,154.96 158.32,155.09 157.78,155.09 157.56,155.31 157.11,155.31 156.79,154.99 156.61,154.99 CT4.1
  IN5 w0.104: v2(146.85,103.28) 146.98,103.28 147.07,103.36 147.07,103.43 147.35,103.72 147.48,103.72 147.48,103.72 148.1,103.72 148.72,103.1 160.18,103.1 163.25,106.17 163.25,106.62 166.82,110.19 166.82,112.32 168.54,114.04 168.54,138.99 164.1,143.43 164.1,147.38 161.58,149.89 160.46,149.89 158.56,151.79 158.56,154.29 158.41,154.45 158.41,154.56 158.36,154.6 v2(158.2,154.6)
  BOTTOM w0.076: CPU1.B24 142.63,102 142.57,101.93 142.57,101.78 142.69,101.66 143.81,101.66 143.9,101.56 144.56,101.56 145.01,102.01 145.82,102.01 146.49,102.68 146.88,102.68 147.1,102.89 147.1,103.07 146.89,103.28 v2(146.85,103.28)
PEG_CTX_TRX_P14_C: length 2.5
  TOP w0.094: CT4.2 155.82,154.92 155.63,154.92 155.52,155.03 155.52,155.36 155.45,155.43 155.24,155.43 155.01,155.2 154.67,155.2 154.58,155.29 154.47,155.29 154.31,155.29 154.21,155.39 154.21,155.5 UT1.M23
PEG_CTX_TRX_P15: length 84
  TOP w0.114: v2(158.96,155.67) 158.78,155.85 158.29,155.85 157.61,156.54 157.61,156.88 156.99,157.5 156.7,157.5 CT5.1
  IN5 w0.104: v2(158.96,155.67) 158.91,155.73 158.64,155.73 157.78,154.87 157.78,151.83 160.48,149.12 161.66,149.12 163.61,147.17 163.61,143.23 168.05,138.79 168.05,114.24 166.33,112.52 166.33,110.4 162.77,106.83 162.77,106.43 159.92,103.59 148.92,103.59 147.72,104.79 147.48,104.79 147.3,104.61 147.3,104.43 v2(147.44,104.29)
  BOTTOM w0.076: v2(147.44,104.29) 147.21,104.06 147.21,103.89 146.97,103.66 146.7,103.66 145.46,102.41 143.76,102.41 143.68,102.33 143.24,102.33 143.03,102.54 143.03,102.69 142.93,102.79 CPU1.B25
PEG_CTX_TRX_P15_C: length 2.4
  TOP w0.094: CT5.2 155.84,157.35 155.72,157.22 155.72,157.17 155.6,157.06 155.44,157.06 155.36,157.14 155.36,157.32 155.29,157.39 154.84,157.39 154.57,157.12 154.3,157.12 154.23,157.19 UT1.H23
PEG_RCOMP: length 6
  BOTTOM w0.089: RC2.2 v1(140.52,80.48)
  BOTTOM w0.254: CPU1.G2 139.49,85.71 139.49,84.89 140.26,84.12 140.26,84.03
  BOTTOM w0.381: RC2.2 140.83,81.73 140.83,83.46 140.26,84.03
PEX_CLKREQ#: length 40.9
  IN5 w0.097: v2(173.69,92.86) 173.62,92.86 172.99,92.23 172.99,86.89 174.89,84.99 175.53,84.99 176.67,83.84 176.67,80.29 178.39,78.57 179.34,78.57 180.48,77.43 180.48,74.16 182.83,71.81 182.83,71.34 v2(182.89,71.27)
  BOTTOM w0.114: v2(173.69,92.86) 173.12,92.86 172.1,93.88 v1(172.1,94.42) 172.1,94.77 173.41,96.07 RG2.1 174.7,96.07 175.12,96.49 175.3,96.49 175.36,96.54 177.09,96.54 177.26,96.71 177.54,96.71 177.64,96.81 178.46,96.81 178.8,97.15 UG9.BL26 ; QG510.3 185.02,69.55 183.3,71.27 v2(182.89,71.27)
