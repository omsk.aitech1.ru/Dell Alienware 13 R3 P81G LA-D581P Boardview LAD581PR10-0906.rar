# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D1: length 74.7
  IN1 w0.097: v2(82.39,32.75) 82.9,33.27 82.9,39.23 82.76,39.37 82.46,39.37 82.35,39.47 82.35,39.65 82.46,39.75 82.76,39.75 82.9,39.89 82.9,40.57 83.59,41.26 83.59,48.83 83.5,48.93 83.32,48.93 83.23,49.02 83.23,49.22 83.32,49.31 83.5,49.31 83.59,49.41 83.59,52.14 91.81,60.36 91.81,60.85 91.81,70.51 98.31,77.01 98.31,88.78 99.94,90.41 v2(100.43,90.41)
  BOTTOM w0.076: CPU1.BR11 103.25,91.54 102.95,91.23 102.02,91.23 101.92,91.13 101.64,91.13 100.91,90.41 v2(100.43,90.41)
  BOTTOM w0.114: JDIMM2.8 83.78,31.37 v2(82.39,32.75)
DDR_B_D2: length 74
  IN1 w0.097: v2(85.67,31.1) 85.17,31.1 84.97,31.3 84.97,35.2 85.59,35.82 85.59,37.43 85.48,37.54 85.48,37.93 85.39,38.03 85.23,38.03 85.14,38.12 85.14,38.32 85.23,38.41 85.39,38.41 85.48,38.51 85.48,38.7 85.39,38.8 85.22,38.8 85.12,38.9 85.12,39.05 85.22,39.15 85.35,39.15 85.48,39.28 85.48,39.48 85.39,39.57 85.19,39.57 85.09,39.67 85.09,39.86 85.19,39.96 85.39,39.96 85.48,40.05 85.48,43.14 86.08,43.73 86.08,47.88 85.76,48.2 85.76,48.59 85.85,48.68 86.17,48.68 86.27,48.78 86.27,48.97 86.17,49.07 85.85,49.07 85.76,49.17 85.76,49.36 85.85,49.45 86.17,49.45 86.27,49.55 86.27,49.74 86.17,49.84 85.85,49.84 85.76,49.94 85.76,50.13 85.85,50.23 86.17,50.23 86.27,50.32 86.27,50.52 86.17,50.61 85.85,50.61 85.76,50.71 85.76,52.18 93.31,59.74 93.31,69.6 99.8,76.09 99.8,87.05 100.83,88.08
  IN1 w0.099: 100.83,88.08 100.83,88.63 v2(100.65,88.81)
  BOTTOM w0.076: CPU1.BT8 102.59,89.49 101.98,89.49 101.51,89.03 101.18,89.03 100.92,88.77 100.69,88.77 v2(100.65,88.81)
  BOTTOM w0.114: v2(85.67,31.1) 85.78,31 JDIMM2.16
DDR_B_D3: length 74.2
  IN1 w0.097: 100.1,75.97 93.61,69.47 93.61,59.61 86.56,52.57 86.56,52.27 86.47,52.18 86.17,52.18 86.08,52.08 86.08,51.89 86.17,51.79 86.47,51.79 86.56,51.69 86.56,51.32 86.62,51.27 86.62,51.09 86.56,51.03 86.56,43.79 85.78,43.01 85.78,41.11 86.34,40.56 86.34,40.28 85.89,39.83 85.89,39.43 85.99,39.33 86.47,39.33 86.56,39.23 86.56,39.04 86.47,38.94 85.99,38.94 85.89,38.85 85.89,37.98 85.99,37.88 86.47,37.88 86.56,37.79 86.56,37.59 86.47,37.5 85.99,37.5 85.89,37.4 85.89,37.21 85.99,37.11 86.47,37.11 86.56,37.01 86.56,36.82 86.47,36.72 85.99,36.72 85.89,36.63 85.89,35.7 85.27,35.07 85.27,33.76 85.4,33.64 v2(85.67,33.64)
  IN1 w0.099: 100.1,75.97 100.1,87.09 101.12,88.1 101.12,89.09 v2(100.93,89.28)
  BOTTOM w0.076: v2(100.93,89.28) 100.98,89.23 101.48,89.23 101.91,89.66 102.36,89.66 102.77,90.07 103.38,90.07 CPU1.BR8
  BOTTOM w0.114: v2(85.67,33.64) 87.03,34.99 JDIMM2.21
DDR_B_D4: length 74.3
  IN1 w0.097: v2(101.26,91.87) 101.23,91.9 99.7,91.9 97.7,89.9 97.7,77.26 91.21,70.76 91.21,60.61 82.8,52.19 82.8,50.23 82.46,49.88 82.46,48.77 82.33,48.64 82.33,43 82.3,42.98 82.3,42.54 82.33,42.51 82.33,42.23 82.3,42.21 82.3,41.77 82.33,41.74 82.33,41.46 82.3,41.44 82.3,41.09 81.71,40.5 81.71,40.25 81.71,40.25 81.71,34.15 81.83,34.02 v2(82.39,34.02)
  BOTTOM w0.076: CPU1.BP11 103.84,91.83 102.16,91.83 101.91,91.58 101.62,91.58 101.33,91.87 v2(101.26,91.87)
  BOTTOM w0.114: JDIMM2.7 83.53,35.92 82.92,35.31 82.92,34.55 v2(82.39,34.02)
DDR_B_D5: length 74.7
  IN1 w0.097: v2(82.39,31.48) 83.2,32.3 83.2,40.45 83.89,41.13 83.89,52.01 92.11,60.23 92.11,60.98 92.11,60.98 92.11,70.38 98.61,76.88 98.61,88.36 100.29,90.04 100.58,90.04
  IN1 w0.099: 100.58,90.04 101.03,90.49 101.03,91.01 101.8,91.78 v2(101.8,91.97)
  BOTTOM w0.076: v2(101.8,91.97) 101.86,92.03 104.05,92.03 104.55,91.54 CPU1.BN11
  BOTTOM w0.114: JDIMM2.4 82.78,31.1 v2(82.39,31.48)
DDR_B_D6: length 74.7
  IN1 w0.097: v2(85.67,34.91) 85.91,34.67 86.1,34.67 86.22,34.8 86.22,35.99 87,36.77 87,39.49 86.77,39.72 86.59,39.72 86.5,39.82 86.5,40.01 86.59,40.11 86.77,40.11 86.86,40.21 86.86,41.12 86.77,41.21 86.18,41.21 86.08,41.31 86.08,41.5 86.18,41.6 86.77,41.6 86.86,41.7 86.86,41.89 86.77,41.99 86.18,41.99 86.08,42.08 86.08,42.27 86.18,42.37 86.77,42.37 86.86,42.47 86.86,42.66 86.77,42.76 86.34,42.76 86.24,42.85 86.24,43.05 86.34,43.14 86.77,43.14 86.86,43.24 86.86,46.42 87,46.56 87,46.81 86.86,46.95 86.86,47.19 87,47.33 87,47.58 86.86,47.72 86.86,48.4 86.96,48.49 87.09,48.49 87.18,48.59 87.18,48.78 87.09,48.88 86.96,48.88 86.86,48.98 86.86,49.17 86.96,49.27 87.09,49.27 87.18,49.36 87.18,49.56 87.09,49.65 86.96,49.65 86.86,49.75 86.86,49.94 86.96,50.04 87.09,50.04 87.18,50.13 87.18,50.36 87.09,50.45 87.02,50.45 86.92,50.55 86.92,50.74 87.02,50.84 87.09,50.84 87.18,50.94 87.18,51.13 87.09,51.23 87.02,51.23 86.92,51.32 86.92,51.52 87.02,51.61 87.09,51.61 87.18,51.71 87.18,51.94 86.89,52.23 86.89,52.47 93.91,59.49 93.91,69.35 100.29,75.73 100.29,76.49
  IN1 w0.099: 100.29,76.49 100.29,81.84 102.69,84.24 102.69,88.89 101.75,89.83 101.75,90.03 v2(101.68,90.09)
  BOTTOM w0.076: CPU1.BP8 103.84,90.25 102.73,90.25 102.3,89.82 101.95,89.82 v2(101.68,90.09)
  BOTTOM w0.114: v2(85.67,34.91) 86.03,35.26 JDIMM2.17
DDR_B_D7: length 74.9
  IN1 w0.097: 100.37,75.35 100.09,75.07 100.09,74.39 94.21,68.51 94.21,59.36 87.48,52.64 87.48,48.06 87.3,47.88 87.3,43.53 87.52,43.31 87.52,43.11 87.43,43.02 87.4,43.02 87.3,42.92 87.3,42.73 87.4,42.63 87.43,42.63 87.52,42.53 87.52,42.34 87.43,42.25 87.4,42.25 87.3,42.15 87.3,41.96 87.4,41.86 87.43,41.86 87.52,41.76 87.52,41.57 87.43,41.47 87.4,41.47 87.3,41.38 87.3,40.07 87.4,39.97 87.43,39.97 87.52,39.88 87.52,39.68 87.43,39.59 87.4,39.59 87.3,39.49 87.3,37.99 87.4,37.89 87.43,37.89 87.52,37.79 87.52,37.6 87.43,37.51 87.4,37.51 87.3,37.41 87.3,36.65 86.52,35.87 86.52,34.11 86.43,34.02 86.18,34.02 86.08,33.92 86.08,33.73 86.18,33.63 86.43,33.63 86.52,33.53 86.52,33.34 86.43,33.24 86.18,33.24 86.08,33.15 86.08,32.95 86.18,32.86 86.43,32.86 86.52,32.76 86.52,32.52 86.36,32.37 v2(85.67,32.37)
  IN1 w0.099: v2(102.21,90.31) 102.26,90.26 102.26,89.7 102.89,89.07 102.89,84.11 100.48,81.7 100.48,75.46 100.37,75.35
  BOTTOM w0.076: v2(102.21,90.31) 102.3,90.39 102.32,90.39 102.35,90.42 103.97,90.42 104.14,90.25 104.49,90.25 CPU1.BN8
  BOTTOM w0.114: JDIMM2.20 86.78,31.27 v2(85.67,32.37)
DDR_B_D8: length 71.9
  IN1 w0.097: 101.1,77.26 101.1,73.94 94.94,67.78 94.94,59.06 89.43,53.55 89.43,52.14 88.92,51.63 88.62,51.63 88.5,51.5 88.5,51.32 88.54,51.28 88.54,50.96 88.36,50.78 88.31,50.78 88.21,50.68 88.21,43.74 88.25,43.7 88.25,36.57 87.25,35.57 87.25,31.8 v2(87.96,31.1)
  IN1 w0.099: v2(105.76,91.93) 105.76,91.28 104.11,89.63 104.11,85.02 101.1,82 101.1,77.26
  BOTTOM w0.076: v2(105.76,91.93) 106.09,92.26 CPU1.BL12
  BOTTOM w0.114: v2(87.96,31.1) 87.78,30.91 JDIMM2.24
DDR_B_D9: length 72
  IN1 w0.097: v2(87.96,32.37) 87.56,32.77 87.56,35.44 88.55,36.44 88.55,43.8 88.52,43.84 88.52,50.39 89.15,51.02 89.15,51.43 89.73,52.01 89.73,53.43 95.24,58.94 95.24,67.65 101.4,73.81 101.4,76.71
  IN1 w0.099: v2(106.56,91.92) 106.56,91.81 104.3,89.56 104.3,84.76 101.4,81.86 101.4,76.71
  BOTTOM w0.076: v2(106.56,91.92) CPU1.BL11
  BOTTOM w0.114: JDIMM2.28 88.78,31.55 v2(87.96,32.37)
DDR_B_D10: length 72.4
  IN1 w0.097: v2(87.96,34.91) 87.96,35.42 88.85,36.31 88.85,39.14 88.95,39.23 89.17,39.23 89.27,39.33 89.27,39.52 89.17,39.62 88.95,39.62 88.85,39.71 88.85,39.91 88.95,40 89.17,40 89.27,40.1 89.27,40.29 89.17,40.39 88.95,40.39 88.85,40.49 88.85,43.91 88.82,43.94 88.82,47.17 88.92,47.27 89.43,47.27 89.52,47.37 89.52,47.56 89.43,47.66 88.92,47.66 88.82,47.75 88.82,47.95 88.92,48.04 89.43,48.04 89.52,48.14 89.52,48.33 89.43,48.43 88.92,48.43 88.82,48.52 88.82,48.72 88.92,48.81 89.57,48.81 89.67,48.91 89.67,49.1 89.57,49.2 88.92,49.2 88.82,49.3 88.82,49.49 88.92,49.59 89.51,49.59 89.61,49.68 89.61,49.88 89.51,49.97 88.92,49.97 88.82,50.07 88.82,50.26 88.92,50.36 89.45,50.36 89.55,50.46 89.55,50.65 89.45,50.74 89.45,51.31 90.03,51.89 90.03,53.3 95.54,58.81 95.54,67.53 101.7,73.69 101.7,76.69
  IN1 w0.099: 101.7,76.69 101.7,81.84 104.49,84.63 104.49,89.08 v2(105.76,90.36)
  BOTTOM w0.076: v2(105.76,90.36) CPU1.BL8
  BOTTOM w0.114: JDIMM2.25 88.03,34.97 v2(87.96,34.91)
DDR_B_D11: length 72.2
  IN1 w0.097: v2(90.92,32.37) 92.09,32.37 92.18,32.46 92.18,32.66 92.08,32.76 91.44,32.76 91.32,32.87 91.32,33.04 91.44,33.15 92.13,33.15 92.23,33.25 92.23,35.96 92.57,36.3 92.57,52.45 97.68,57.56 97.68,66.69 103.93,72.94 103.93,75.35
  IN1 w0.099: v2(107.43,89.97) 107.02,89.57 107.02,89.06 108.03,88.05 108.03,83.93 107.72,83.62 107.72,83.6 105.95,81.84 105.95,79.2 105.22,78.47 105.22,77.05 103.93,75.76 103.93,75.35
  BOTTOM w0.076: v2(107.43,89.97) CPU1.BJ8
  BOTTOM w0.114: JDIMM2.42 92.28,31.23 91.14,32.37 v2(90.92,32.37)
DDR_B_D12: length 72.2
  IN1 w0.097: 103.32,75.91 103.32,73.19 97.08,66.94 97.08,57.81 91.91,52.64 91.91,50.6 91.53,50.22 91.53,48.22 91.39,48.08 91.39,43.71 91.49,43.61 91.87,43.61 91.97,43.52 91.97,43.33 91.87,43.23 91.49,43.23 91.39,43.13 91.39,42.94 91.49,42.84 91.87,42.84 91.97,42.75 91.97,42.55 91.87,42.46 91.49,42.46 91.39,42.36 91.39,42.17 91.49,42.07 91.87,42.07 91.97,41.97 91.97,41.78 91.87,41.68 91.49,41.68 91.39,41.59 91.39,41.39 91.49,41.3 91.87,41.3 91.97,41.2 91.97,41.01 91.87,40.91 91.49,40.91 91.39,40.82 91.39,40.62 91.49,40.53 91.87,40.53 91.97,40.43 91.97,40.24 91.87,40.14 91.49,40.14 91.39,40.04 91.39,39.85 91.49,39.75 91.87,39.75 91.97,39.66 91.97,39.46 91.87,39.37 91.49,39.37 91.39,39.27 91.39,39.05 91.9,38.54 91.9,36.48 91.63,36.21 91.63,35.62 v2(90.92,34.91)
  IN1 w0.099: 103.32,75.91 104.84,77.44 104.84,82.26 106.31,83.73 106.31,86.34 106.07,86.58 106.07,87.48 106.64,88.05 106.64,90.13 107.01,90.5 107.01,90.86 v2(107.43,91.27)
  BOTTOM w0.076: v2(107.43,91.27) CPU1.BJ11
  BOTTOM w0.114: v2(90.92,34.91) 91.03,35.01 JDIMM2.37
DDR_B_D13: length 71.9
  IN1 w0.097: 103.62,75.88 103.62,73.07 97.38,66.82 97.38,57.68 92.27,52.58 92.27,46.81 92.17,46.71 91.8,46.71 91.71,46.62 91.71,46.42 91.8,46.33 92.17,46.33 92.27,46.23 92.27,46.04 92.17,45.94 91.8,45.94 91.71,45.84 91.71,45.65 91.8,45.56 92.17,45.56 92.27,45.46 92.27,45.27 92.17,45.17 91.8,45.17 91.71,45.07 91.71,44.88 91.8,44.78 92.17,44.78 92.27,44.69 92.27,44.49 92.17,44.4 91.8,44.4 91.71,44.3 91.71,44.11 91.8,44.01 92.17,44.01 92.27,43.91 92.27,36.43 91.93,36.08 91.93,34.64 v2(90.92,33.64)
  IN1 w0.099: v2(107.43,90.62) 106.83,90.03 106.83,87.8 106.84,87.79 106.84,83.99 105.03,82.19 105.03,77.29 103.62,75.88
  BOTTOM w0.076: v2(107.43,90.62) CPU1.BJ10
  BOTTOM w0.114: v2(90.92,33.64) 92.03,34.74 JDIMM2.41
DDR_B_D14: length 72.7
  IN1 w0.097: v2(87.96,33.64) 87.96,33.68 88.36,34.09 88.36,35.4 89.57,36.6 89.57,40.56 89.78,40.77 89.78,41.14 89.68,41.23 89.25,41.23 89.15,41.33 89.15,41.52 89.25,41.62 89.83,41.62 89.93,41.72 89.93,41.91 89.83,42.01 89.25,42.01 89.15,42.1 89.15,42.3 89.25,42.39 89.83,42.39 89.93,42.49 89.93,42.68 89.83,42.78 89.25,42.78 89.15,42.87 89.15,43.07 89.25,43.16 89.68,43.16 89.78,43.26 89.78,43.4 89.68,43.49 89.67,43.49 89.12,44.05 89.12,46.29 89.82,46.99 89.82,48.64 90.33,49.15 90.33,53.18 95.84,58.69 95.84,67.4 102.12,73.68 102.12,75.86
  IN1 w0.099: 102.12,75.86 103.71,77.45 103.71,82.12 105.76,84.17 105.76,85.95 104.84,86.87 104.84,87.67 105.8,88.63 v2(105.8,89.54)
  BOTTOM w0.076: v2(105.8,89.54) CPU1.BL7
  BOTTOM w0.114: v2(87.96,33.64) 89.03,34.7 JDIMM2.29
DDR_B_D15: length 72.3
  IN1 w0.097: v2(90.92,31.1) 91.9,31.1 92.65,31.85 92.65,35.96 92.87,36.18 92.87,48.32 92.96,48.41 93.19,48.41 93.29,48.51 93.29,48.7 93.19,48.8 92.96,48.8 92.87,48.9 92.87,49.09 92.96,49.19 93.19,49.19 93.29,49.28 93.29,49.47 93.19,49.57 92.96,49.57 92.87,49.67 92.87,49.86 92.96,49.96 93.19,49.96 93.29,50.05 93.29,50.25 93.19,50.34 92.96,50.34 92.87,50.44 92.87,50.63 92.96,50.73 93.19,50.73 93.29,50.83 93.29,51.02 93.19,51.12 92.96,51.12 92.87,51.21 92.87,51.41 92.96,51.5 93.19,51.5 93.29,51.6 93.29,51.79 93.19,51.89 92.96,51.89 92.87,51.98 92.87,52.33 97.98,57.43 97.98,66.56 104.23,72.82 104.23,75.35
  IN1 w0.099: 104.23,75.35 104.23,75.67 105.52,76.97 105.52,78.5 106.14,79.12 106.14,81.76 108.22,83.84 108.22,88.53 v2(107.43,89.32)
  BOTTOM w0.076: v2(107.43,89.32) CPU1.BJ7
  BOTTOM w0.114: JDIMM2.38 91.28,30.74 v2(90.92,31.1)
DDR_B_D16: length 70.4
  IN1 w0.089: v2(109.26,91.91) 108.71,91.36 108.71,89.85 108.46,89.6 108.46,89.03 108.82,88.66 108.82,84.01 106.56,81.75 106.56,79.29 105.75,78.47 105.75,76.69 104.96,75.9 104.96,75.35
  IN1 w0.097: 104.96,75.35 104.96,72.51 98.71,66.26 98.71,57.13 94.52,52.94 94.52,52.2 94.42,52.1 94.21,52.1 94.11,52.01 94.11,51.81 94.21,51.72 94.42,51.72 94.52,51.62 94.52,51.43 94.42,51.33 94.21,51.33 94.11,51.24 94.11,51.04 94.21,50.95 94.42,50.95 94.52,50.85 94.52,50.66 94.42,50.56 94.21,50.56 94.11,50.46 94.11,50.35 94.02,50.26 94.02,39.54 93.92,39.44 93.77,39.44 93.67,39.34 93.67,39.15 93.77,39.05 93.92,39.05 94.02,38.96 94.02,38.76 93.92,38.67 93.77,38.67 93.68,38.57 93.68,38.38 93.77,38.28 93.92,38.28 94.02,38.18 94.02,37.99 93.92,37.89 93.77,37.89 93.67,37.8 93.67,37.6 93.77,37.51 93.92,37.51 94.02,37.41 94.02,37.22 93.92,37.12 93.77,37.12 93.67,37.03 93.67,36.83 93.77,36.74 93.92,36.74 94.02,36.64 94.02,36.45 93.92,36.35 93.77,36.35 93.67,36.25 93.67,36.06 93.77,35.96 93.92,35.96 94.02,35.87 94.02,35.64 v2(93.28,34.91)
  BOTTOM w0.076: v2(109.26,91.91) CPU1.BG11
  BOTTOM w0.114: JDIMM2.45 93.03,35.16 v2(93.28,34.91)
DDR_B_D17: length 70.1
  IN1 w0.089: v2(109.26,91.27) 108.89,90.91 108.89,89.77 108.64,89.52 108.64,89.1 109,88.74 109,83.94 106.78,81.72 106.78,78.98 106.07,78.27 106.07,76.53 105.26,75.72 105.26,75.35
  IN1 w0.097: 105.26,75.35 105.26,72.39 99.01,66.14 99.01,57.01 94.82,52.82 94.82,49.92 94.72,49.82 94.53,49.82 94.44,49.73 94.44,49.53 94.53,49.44 94.72,49.44 94.82,49.34 94.82,49.15 94.72,49.05 94.53,49.05 94.44,48.95 94.44,48.76 94.53,48.66 94.72,48.66 94.82,48.57 94.82,48.37 94.72,48.28 94.41,48.28 94.32,48.18 94.32,35.37 93.72,34.77 93.72,34.07 v2(93.28,33.64)
  BOTTOM w0.076: v2(109.26,91.27) CPU1.BG10
  BOTTOM w0.114: v2(93.28,33.64) 94.03,34.38 JDIMM2.49
DDR_B_D18: length 70.3
  IN1 w0.089: 105.56,75.35 105.56,75.64 106.26,76.34 106.26,78.14 106.98,78.87 106.98,81.67 109.18,83.86 109.18,88.81 109.08,88.92 108.85,89.15 108.85,89.43 109.26,89.84 v2(109.26,89.97)
  IN1 w0.097: v2(93.28,32.37) 94.02,33.1 94.02,34.65 94.62,35.24 94.62,42.52 94.71,42.62 95.29,42.62 95.39,42.72 95.39,42.91 95.29,43 94.71,43 94.62,43.1 94.62,47.56 95.12,48.06 95.12,52.69 99.31,56.88 99.31,66.01 105.56,72.26 105.56,75.35
  BOTTOM w0.076: v2(109.26,89.97) CPU1.BG8
  BOTTOM w0.114: v2(93.28,32.37) 93.44,32.37 94.28,31.53 JDIMM2.50
DDR_B_D19: length 70.1
  IN1 w0.089: 107.61,75.35 107.61,75.93 110.99,79.32 110.99,88.25 110.53,88.71 110.53,89.48 110.17,89.85 v2(110.17,89.98)
  IN1 w0.097: 107.61,75.35 107.61,71.76 101.62,65.77 101.62,59.32 101.1,58.81 101.1,56.14 97.56,52.6 97.56,50.77 97.46,50.67 97.01,50.67 96.91,50.58 96.91,50.38 97.01,50.29 97.46,50.29 97.56,50.19 97.56,50 97.46,49.9 97.01,49.9 96.91,49.81 96.91,49.61 97.01,49.52 97.46,49.52 97.56,49.42 97.56,49.23 97.46,49.13 97.01,49.13 96.91,49.03 96.91,48.84 97.01,48.74 97.46,48.74 97.56,48.65 97.56,43.24 97.73,43.07 97.73,34.4 v2(96.97,33.64)
  BOTTOM w0.076: v2(110.17,89.98) 109.83,89.65 CPU1.BF8
  BOTTOM w0.114: v2(96.97,33.64) 96.53,34.08 JDIMM2.59
DDR_B_D20: length 70.3
  IN1 w0.089: 108.21,75.35 108.21,76.03 111.35,79.17 111.35,88.4 110.89,88.86 110.89,89.7 110.71,89.88 110.71,91.37 v2(110.17,91.91)
  IN1 w0.097: 108.21,75.35 108.21,71.51 102.21,65.52 102.21,59.07 101.7,58.56 101.7,55.89 98.65,52.83 98.65,50.26 98.16,49.78 98.16,43.49 98.33,43.32 98.33,32.46 v2(96.97,31.1)
  BOTTOM w0.076: v2(110.17,91.91) CPU1.BF11
  BOTTOM w0.114: JDIMM2.62 97.28,30.79 v2(96.97,31.1)
DDR_B_D21: length 70.2
  IN1 w0.089: v2(110.17,91.27) 110.53,90.91 110.53,89.77 110.71,89.59 110.71,88.78 111.17,88.32 111.17,79.24 107.91,75.98 107.91,75.35
  IN1 w0.097: v2(96.97,32.37) 98.03,33.43 98.03,35.07 98.03,35.07 98.03,43.2 97.86,43.36 97.86,50.09 97.96,50.19 98.15,50.19 98.25,50.29 98.25,50.48 98.15,50.58 97.96,50.58 97.86,50.67 97.86,52.47 101.4,56.01 101.4,58.68 101.92,59.2 101.92,65.64 107.91,71.64 107.91,75.35
  BOTTOM w0.076: v2(110.17,91.27) CPU1.BF10
  BOTTOM w0.114: JDIMM2.58 96.28,31.68 v2(96.97,32.37)
DDR_B_D22: length 70.2
  IN1 w0.089: v2(109.26,89.32) 109.37,89.21 109.37,83.8 107.18,81.62 107.18,78.69 106.58,78.08 106.58,76.32 105.88,75.62 105.88,75.35
  IN1 w0.097: v2(93.28,31.1) 94.46,32.27 94.46,34.66 95.74,35.94 95.74,43.95 95.64,44.05 95.01,44.05 94.92,44.14 94.92,44.34 95.01,44.43 95.64,44.43 95.74,44.53 95.74,44.72 95.64,44.82 95.31,44.82 95.22,44.92 95.22,45.11 95.31,45.21 95.64,45.21 95.74,45.3 95.74,47.24 95.42,47.57 95.42,52.57 99.61,56.76 99.61,65.88 105.88,72.15 105.88,75.35
  BOTTOM w0.076: v2(109.26,89.32) CPU1.BG7
  BOTTOM w0.114: JDIMM2.46 93.28,31.09 v2(93.28,31.1)
DDR_B_D23: length 69.9
  IN1 w0.089: v2(110.17,89.32) 110.12,89.27 110.12,88.03 110.49,87.66 110.49,82.95 110.06,82.52 110.06,78.64 107.31,75.88 107.31,75.35
  IN1 w0.097: 107.31,75.35 107.31,71.89 101.32,65.9 101.32,61.18 101.2,61.07 100.9,61.07 100.8,60.97 100.8,60.78 100.9,60.68 101.2,60.68 101.29,60.58 101.29,60.39 101.2,60.29 100.9,60.29 100.8,60.2 100.8,60 100.9,59.91 101.2,59.91 101.29,59.81 101.29,59.62 101.2,59.52 100.9,59.52 100.8,59.42 100.8,56.26 96.61,52.07 96.61,48.5 97.24,47.88 97.24,43.14 97.33,43.05 97.33,42.87 97.27,42.81 97.03,42.81 96.94,42.71 96.94,42.52 97.03,42.43 97.27,42.43 97.37,42.33 97.37,42.14 97.27,42.04 97.03,42.04 96.94,41.94 96.94,41.75 97.03,41.65 97.27,41.65 97.37,41.56 97.37,41.36 97.27,41.27 97.03,41.27 96.94,41.17 96.94,40.98 97.03,40.88 97.27,40.88 97.37,40.78 97.37,39.75 97.27,39.65 97.03,39.65 96.94,39.55 96.94,39.36 97.03,39.26 97.27,39.26 97.37,39.17 97.37,37.97 97.27,37.87 97.03,37.87 96.94,37.78 96.94,37.58 97.03,37.49 97.27,37.49 97.37,37.39 97.37,37.2 97.27,37.1 97.03,37.1 96.94,37.01 96.94,36.81 97.03,36.72 97.27,36.72 97.37,36.62 97.37,36.43 97.27,36.33 97.03,36.33 96.94,36.23 96.94,36.04 97.03,35.94 97.27,35.94 97.43,35.78 97.43,35.37 v2(96.97,34.91)
  BOTTOM w0.076: v2(110.17,89.32) CPU1.BF7
  BOTTOM w0.114: JDIMM2.63 97.53,35.47 v2(96.97,34.91)
DDR_B_D24: length 69.3
  IN1 w0.089: 112.35,75.35 112.35,75.62 114.44,77.71 114.44,88.82 113.46,89.8 113.46,91.38 v2(112.91,91.92)
  IN1 w0.097: 112.35,75.35 112.35,70.37 105.94,63.95 105.94,54.86 104.07,52.99 104.07,50.84 103.83,50.6 103.83,32.43 v2(102.5,31.1)
  BOTTOM w0.076: v2(112.91,91.92) CPU1.BB11
  BOTTOM w0.114: JDIMM2.84 102.78,30.82 v2(102.5,31.1)
DDR_B_D25: length 69.2
  IN1 w0.089: v2(112,91.91) 111.45,91.36 111.45,89.79 111.28,89.62 111.28,89.02 111.76,88.54 111.76,79.33 109.61,77.18 109.61,77.07 109.02,76.47 109.02,75.35
  IN1 w0.097: v2(99.35,34.91) 99.33,34.91 99.06,35.18 99.06,35.4 99.16,35.5 99.49,35.5 99.59,35.59 99.59,35.79 99.49,35.88 99.16,35.88 99.06,35.98 99.06,36.17 99.16,36.27 99.49,36.27 99.59,36.37 99.59,36.56 99.49,36.66 99.18,36.66 99.08,36.75 99.08,40.78 99.18,40.88 99.48,40.88 99.58,40.98 99.58,41.17 99.48,41.27 99.16,41.27 99.06,41.36 99.06,41.56 99.16,41.65 99.48,41.65 99.59,41.76 99.59,43.09 98.89,43.79 98.89,47.82 99.4,48.33 99.4,52.56 102.43,55.59 102.43,58.26 102.95,58.77 102.95,65.22 109.02,71.29 109.02,75.35
  BOTTOM w0.076: v2(112,91.91) CPU1.BC11
  BOTTOM w0.114: JDIMM2.67 98.53,35.74 v2(99.35,34.91)
DDR_B_D26: length 68.8
  IN1 w0.089: v2(112.91,89.97) 112.91,89.84 114.09,88.67 114.09,78.24 111.75,75.91 111.75,75.35
  IN1 w0.097: 111.75,75.35 111.75,70.62 105.34,64.21 105.34,57.45 105.25,57.36 104.92,57.36 104.83,57.26 104.83,57.07 104.92,56.97 105.25,56.97 105.34,56.87 105.34,56.68 105.25,56.59 104.92,56.59 104.83,56.49 104.83,56.3 104.92,56.2 105.25,56.2 105.34,56.1 105.34,55.91 105.25,55.81 104.92,55.81 104.83,55.72 104.83,55.52 104.92,55.43 105.25,55.43 105.34,55.33 105.34,55.11 103.38,53.14 103.38,51 103.23,50.85 103.23,33.76 103.1,33.64 v2(102.5,33.64)
  BOTTOM w0.076: v2(112.91,89.97) CPU1.BB8
  BOTTOM w0.114: v2(102.5,33.64) 101.53,34.61 JDIMM2.79
DDR_B_D27: length 69.6
  IN1 w0.089: v2(112,89.97) 112,89.83 111.64,89.47 111.64,89.17 111.92,88.89 112.07,88.89 112.81,88.15 112.81,81.33 112.25,80.77 112.25,79.04 109.62,76.41 109.62,75.35
  IN1 w0.097: 109.62,75.35 109.62,71.04 103.55,64.96 103.55,58.52 103.03,58.01 103.03,55.34 100.8,53.11 100.8,50.27 100.06,49.53 100.06,48.23 100.15,48.13 100.71,48.13 100.8,48.04 100.8,47.84 100.71,47.75 100.29,47.75 100.19,47.65 100.19,33.2 v2(99.35,32.37)
  BOTTOM w0.076: v2(112,89.97) CPU1.BC8
  BOTTOM w0.114: JDIMM2.66 98.28,31.29 v2(99.35,32.37)
DDR_B_D28: length 69.4
  IN1 w0.089: 109.32,75.35 109.32,76.52 109.87,77.07 109.87,77.19 111.94,79.26 111.94,88.62 111.46,89.1 111.46,89.55 111.63,89.72 111.63,90.9 v2(112,91.27)
  IN1 w0.097: v2(99.35,33.64) 99.35,33.7 99.89,34.24 99.89,37.27 99.79,37.36 99.48,37.36 99.38,37.46 99.38,37.65 99.48,37.75 99.79,37.75 99.89,37.85 99.89,38.04 99.79,38.14 99.48,38.14 99.38,38.23 99.38,38.43 99.48,38.52 99.79,38.52 99.89,38.62 99.89,43.71 99.76,43.84 99.76,52.49 102.73,55.46 102.73,58.13 103.25,58.64 103.25,65.09 109.32,71.17 109.32,75.35
  BOTTOM w0.076: v2(112,91.27) CPU1.BC10
  BOTTOM w0.114: JDIMM2.71 99.53,35.76 99.89,35.39 99.89,34.17 v2(99.35,33.64)
DDR_B_D29: length 69.1
  IN1 w0.089: 112.05,75.35 112.05,75.76 114.26,77.97 114.26,88.74 113.28,89.72 113.28,90.9 v2(112.91,91.27)
  IN1 w0.097: v2(102.5,32.37) 103.3,32.37 103.53,32.6 103.53,50.73 103.68,50.87 103.68,53.02 105.64,54.98 105.64,64.08 112.05,70.5 112.05,75.35
  BOTTOM w0.076: v2(112.91,91.27) CPU1.BB10
  BOTTOM w0.114: JDIMM2.80 101.78,31.65 v2(102.5,32.37)
DDR_B_D30: length 69.3
  IN1 w0.089: 109.93,75.35 109.93,76.35 112.43,78.85 112.43,80.63 112.99,81.19 112.99,88.22 112,89.21 v2(112,89.32)
  IN1 w0.097: v2(99.35,31.1) 100.62,32.37 100.62,35.97 101.1,36.45 101.1,39.43 101.01,39.52 100.59,39.52 100.49,39.62 100.49,39.81 100.59,39.91 101.01,39.91 101.1,40.01 101.1,49.03 101.01,49.12 100.47,49.12 100.37,49.22 100.37,49.41 100.47,49.51 101.01,49.51 101.1,49.61 101.1,52.98 103.33,55.21 103.33,57.88 103.85,58.4 103.85,64.83 109.93,70.92 109.93,75.35
  BOTTOM w0.076: v2(112,89.32) CPU1.BC7
  BOTTOM w0.114: v2(99.35,31.1) 99.28,31.02 JDIMM2.70
DDR_B_D31: length 68.9
  IN1 w0.089: 111.2,75.35 111.2,75.67 113.91,78.38 113.91,88.33 v2(112.91,89.32)
  IN1 w0.097: 111.2,75.35 111.2,70.49 105.04,64.33 105.04,57.9 104.53,57.39 104.53,54.72 102.57,52.76 102.57,51 102.92,50.64 102.92,42.72 102.83,42.63 102.39,42.63 102.3,42.53 102.3,42.34 102.39,42.24 102.83,42.24 102.92,42.14 102.92,41.95 102.83,41.85 102.39,41.85 102.3,41.76 102.3,41.56 102.39,41.47 102.83,41.47 102.92,41.37 102.92,40.05 102.83,39.95 102.39,39.95 102.3,39.85 102.3,39.66 102.39,39.56 102.83,39.56 102.92,39.47 102.92,37.43 102.83,37.34 102.39,37.34 102.3,37.24 102.3,37.05 102.39,36.95 102.83,36.95 102.92,36.86 102.92,36.66 102.83,36.57 102.39,36.57 102.3,36.47 102.3,36.28 102.39,36.18 102.83,36.18 102.92,36.08 102.92,35.89 102.83,35.79 102.39,35.79 102.3,35.7 102.3,35.5 102.39,35.41 102.83,35.41 102.92,35.31 102.92,35.07 102.76,34.91 v2(102.5,34.91)
  BOTTOM w0.076: v2(112.91,89.32) CPU1.BB7
  BOTTOM w0.114: JDIMM2.83 102.53,34.93 v2(102.5,34.91)
DDR_B_D32: length 68.3
  IN1 w0.089: v2(129.37,91.92) 129.84,91.46 129.84,91.12 129.92,91.04 129.92,89.88 130.24,89.56 130.24,88.56 130.67,88.14 130.67,83.23 133.7,80.19 133.7,77.56 133.46,77.31 133.46,75.35
  IN1 w0.097: 133.46,75.35 133.46,62.67 130.2,59.41 130.2,58.88 130.11,58.78 129.93,58.78 129.83,58.68 129.83,58.49 129.93,58.39 130.11,58.39 130.2,58.3 130.2,58.1 130.11,58.01 129.93,58.01 129.83,57.91 129.83,57.72 129.93,57.62 130.11,57.62 130.2,57.52 130.2,57.33 130.11,57.24 129.93,57.24 129.83,57.14 129.83,56.95 129.93,56.85 130.11,56.85 130.2,56.75 130.2,56.56 130.11,56.46 129.93,56.46 129.83,56.37 129.83,56.17 129.93,56.08 130.11,56.08 130.2,55.98 130.2,55.79 130.11,55.69 129.93,55.69 129.83,55.59 129.83,55.4 129.93,55.3 130.11,55.3 130.2,55.21 130.2,49.43 131.59,48.05 131.59,40.69 131.54,40.64 131.54,40.1 129.83,38.39 129.83,38.16 129.92,38.07 130.15,38.07 130.25,37.97 130.25,37.78 130.15,37.68 129.92,37.68 129.83,37.58 129.83,37.39 129.92,37.3 130.15,37.3 130.25,37.2 130.25,37.01 130.15,36.91 129.91,36.91 129.81,36.81 129.81,35.11 v2(129.96,34.97)
  BOTTOM w0.076: v2(129.37,91.92) CPU1.AA11
  BOTTOM w0.114: JDIMM2.187 130.53,35.53 v2(129.96,34.97)
DDR_B_D33: length 68.6
  IN1 w0.089: 133.16,75.35 133.16,77.45 133.53,77.82 133.53,80.08 130.46,83.15 130.46,88.09 130.07,88.49 130.07,89.45 129.74,89.77 129.74,90.9 v2(129.37,91.27)
  IN1 w0.097: 133.16,75.35 133.16,62.79 129.53,59.16 129.53,55.01 129.63,54.92 129.81,54.92 129.9,54.82 129.9,54.63 129.81,54.53 129.63,54.53 129.53,54.43 129.53,54.24 129.63,54.14 129.81,54.14 129.9,54.05 129.9,53.85 129.81,53.76 129.63,53.76 129.53,53.66 129.53,53.47 129.63,53.37 129.81,53.37 129.9,53.27 129.9,53.08 129.81,52.99 129.63,52.99 129.53,52.89 129.53,52.67 129.9,52.29 129.9,49.31 131.29,47.92 131.29,41.45 131.19,41.35 131.11,41.35 131.01,41.25 131.01,41.06 131.11,40.96 131.15,40.96 131.24,40.87 131.24,40.23 129.53,38.51 129.53,37.64 129.51,37.62 129.51,34.15 v2(129.96,33.7)
  BOTTOM w0.076: v2(129.37,91.27) CPU1.AA10
  BOTTOM w0.114: JDIMM2.183 129.53,34.13 v2(129.96,33.7)
DDR_B_D34: length 68.5
  IN1 w0.089: v2(128.46,91.92) 128.1,91.56 128.1,91.16 127.73,90.8 127.73,88.95 128.18,88.5 128.18,82.13 130.46,79.85 130.46,75.35
  IN1 w0.097: 130.46,75.35 130.46,63.9 126.26,59.71 126.26,48.73 127.23,47.76 127.23,42.89 126.44,42.1 126.44,40.01 125.64,39.21 125.64,32.3 v2(126.79,31.14)
  BOTTOM w0.076: v2(128.46,91.92) CPU1.AC11
  BOTTOM w0.114: JDIMM2.174 127.28,30.64 126.79,31.12 v2(126.79,31.14)
DDR_B_D35: length 68.9
  IN1 w0.089: v2(128.46,91.27) 127.91,90.73 127.91,89.06 128.36,88.61 128.36,82.21 130.76,79.81 130.76,75.35
  IN1 w0.097: 130.76,75.35 130.76,63.78 126.56,59.58 126.56,52.79 127.08,52.28 127.08,48.34 127.53,47.88 127.53,42.49 126.74,41.7 126.74,39.89 126.44,39.59 126.44,38.23 125.94,37.72 125.94,33.47 126.03,33.38 126.29,33.38 126.39,33.28 126.39,32.99 126.29,32.89 126.03,32.89 125.94,32.8 125.94,32.54 126.06,32.41 v2(126.79,32.41)
  BOTTOM w0.076: v2(128.46,91.27) 128.13,90.95 CPU1.AC10
  BOTTOM w0.114: v2(126.79,32.41) 126.38,32 126.38,29.67 126.28,29.56 JDIMM2.170
DDR_B_D36: length 68
  IN1 w0.089: 132.56,75.35 132.56,79.26 129.25,82.58 129.25,89.2 v2(129.37,89.32)
  IN1 w0.097: v2(129.96,31.16) 129.7,31.16 129.21,31.65 128.78,31.65 128.67,31.76 128.67,37.63 128.93,37.89 128.93,38.76 129.86,39.69 129.86,41.07 130.69,41.91 130.69,44.07 130.59,44.16 130.5,44.16 130.41,44.26 130.41,44.45 130.5,44.55 130.59,44.55 130.69,44.65 130.69,44.84 130.59,44.94 130.53,44.94 130.43,45.03 130.43,45.23 130.53,45.32 130.59,45.32 130.69,45.42 130.69,45.61 130.59,45.71 130.53,45.71 130.43,45.8 130.43,46 130.53,46.09 130.59,46.09 130.69,46.19 130.69,46.38 130.59,46.48 130.52,46.48 130.42,46.58 130.42,46.77 130.52,46.87 130.59,46.87 130.69,46.96 130.69,47.67 129.27,49.09 129.27,52.01 128.93,52.35 128.93,59.41 132.56,63.04 132.56,75.35
  BOTTOM w0.076: v2(129.37,89.32) CPU1.AA7
  BOTTOM w0.114: v2(129.96,31.16) 129.89,31.08 129.89,30.89 129.74,30.75 129.74,30.47 129.28,30 JDIMM2.182
DDR_B_D37: length 68.4
  IN1 w0.089: v2(129.37,89.97) 129.43,89.91 129.43,89.8 129.86,89.36 129.86,88.44 130.26,88.05 130.26,83.03 133.35,79.94 133.35,78.12 132.86,77.63 132.86,75.35
  IN1 w0.097: v2(129.96,32.43) 129.5,31.96 129.09,31.96 128.97,32.08 128.97,37.51 129.23,37.76 129.23,38.64 130.16,39.56 130.16,40.95 130.99,41.79 130.99,47.8 129.6,49.19 129.6,52.17 129.23,52.54 129.23,59.29 132.86,62.92 132.86,75.35
  BOTTOM w0.076: v2(129.37,89.97) CPU1.AA8
  BOTTOM w0.114: v2(129.96,32.43) 130.42,31.97 130.42,30.74 130.28,30.6 JDIMM2.186
DDR_B_D38: length 68.6
  IN1 w0.089: v2(128.46,89.97) 128.09,89.6 128.09,89.13 128.54,88.69 128.54,82.28 131.06,79.76 131.06,75.35
  IN1 w0.097: v2(126.79,33.68) 126.36,33.68 126.24,33.81 126.24,37.6 126.74,38.1 126.74,39.47 127.04,39.76 127.04,41.58 128.63,43.17 128.63,43.77 128.53,43.87 127.93,43.87 127.84,43.97 127.84,44.16 127.93,44.26 128.53,44.26 128.63,44.35 128.63,44.55 128.53,44.64 127.93,44.64 127.84,44.74 127.84,44.93 127.93,45.03 128.53,45.03 128.63,45.13 128.63,47.54 127.38,48.8 127.38,52.4 126.86,52.91 126.86,59.46 131.06,63.65 131.06,75.35
  BOTTOM w0.076: v2(128.46,89.97) CPU1.AC8
  BOTTOM w0.114: JDIMM2.169 126.03,34.45 v2(126.79,33.68)
DDR_B_D39: length 68.5
  IN1 w0.089: v2(128.46,89.41) 128.46,89.05 128.71,88.8 128.71,82.35 131.36,79.71 131.36,75.35
  IN1 w0.097: v2(126.79,34.95) 127.06,35.22 127.06,35.44 126.97,35.54 126.63,35.54 126.54,35.64 126.54,35.83 126.63,35.93 126.97,35.93 127.06,36.02 127.06,36.22 126.97,36.31 126.63,36.31 126.54,36.41 126.54,36.6 126.63,36.7 126.97,36.7 127.06,36.8 127.06,36.99 126.97,37.08 126.63,37.08 126.54,37.18 126.54,37.37 126.63,37.47 126.97,37.47 127.06,37.57 127.06,39.17 127.92,40.03 127.92,41.83 128.93,42.84 128.93,47.67 127.68,48.92 127.68,53 127.58,53.09 127.3,53.09 127.2,53.19 127.2,53.38 127.3,53.48 127.58,53.48 127.68,53.58 127.68,53.77 127.58,53.87 127.3,53.87 127.2,53.96 127.2,54.16 127.3,54.25 127.58,54.25 127.68,54.35 127.68,54.54 127.58,54.64 127.3,54.64 127.2,54.73 127.2,54.93 127.3,55.02 127.58,55.02 127.68,55.12 127.68,55.31 127.58,55.41 127.3,55.41 127.2,55.51 127.2,55.7 127.3,55.8 127.58,55.8 127.68,55.89 127.68,56.09 127.58,56.18 127.3,56.18 127.2,56.28 127.2,56.47 127.3,56.57 127.58,56.57 127.73,56.72 127.73,56.95 127.64,57.05 127.26,57.05 127.16,57.14 127.16,57.34 127.26,57.43 127.64,57.43 127.73,57.53 127.73,59.91 131.36,63.53 131.36,75.35
  BOTTOM w0.114: v2(126.79,34.95) 126.79,35.63 127.03,35.86 JDIMM2.173
  BOTTOM w0.127: v2(128.46,89.41) 128.04,89 CPU1.AC7
DDR_B_D40: length 67.2
  IN1 w0.089: v2(131.2,89.43) 131.16,89.48 130.98,89.48 130.81,89.31 130.81,88.75 131.28,88.29 131.28,83.5 134.84,79.94 134.84,75.35
  IN1 w0.097: 134.84,75.35 134.84,62.16 131.53,58.85 131.53,55.57 131.63,55.48 131.93,55.48 132.03,55.38 132.03,55.19 131.93,55.09 131.63,55.09 131.53,55 131.53,54.77 131.63,54.68 132.35,54.68 132.44,54.58 132.44,54.39 132.35,54.29 131.63,54.29 131.53,54.19 131.53,54 131.63,53.9 132.35,53.9 132.44,53.81 132.44,53.61 132.35,53.52 131.63,53.52 131.53,53.42 131.53,53.23 131.63,53.13 132.35,53.13 132.44,53.03 132.44,52.84 132.35,52.74 131.63,52.74 131.53,52.65 131.53,49.99 133,48.52 133,40.85 132.95,40.81 132.95,40.11 132.93,40.1 132.93,38.32 131.99,37.38 v2(131.99,35.03)
  BOTTOM w0.076: v2(131.2,89.43) 130.99,89.65 CPU1.W8
  BOTTOM w0.114: JDIMM2.191 131.53,35.5 v2(131.99,35.03)
DDR_B_D41: length 67.4
  IN1 w0.089: 135.15,75.35 135.15,79.89 131.46,83.58 131.46,88.62 v2(131.2,88.87)
  IN1 w0.097: v2(131.99,33.76) 132.85,34.62 132.85,37.81 133.23,38.19 133.23,39.97 133.3,40.04 133.3,49.88 132.74,50.43 132.74,55.75 132.65,55.84 131.93,55.84 131.83,55.94 131.83,56.13 131.93,56.23 132.65,56.23 132.74,56.33 132.74,56.52 132.65,56.62 131.93,56.62 131.83,56.71 131.83,56.91 131.93,57 132.65,57 132.74,57.1 132.74,57.29 132.65,57.39 131.93,57.39 131.83,57.48 131.83,57.68 131.93,57.77 132.65,57.77 132.74,57.87 132.74,59.63 135.14,62.03 135.14,75.34 135.15,75.35
  BOTTOM w0.076: CPU1.W7 131.08,89 v2(131.2,88.87)
  BOTTOM w0.114: v2(131.99,33.76) 132.53,34.29 JDIMM2.195
DDR_B_D42: length 67.9
  IN1 w0.089: v2(132.08,91.27) 132.48,90.87 132.48,89.72 132.68,89.53 132.68,88.81 133.02,88.47 133.02,84.33 137.53,79.82 137.53,79.32 136.94,78.72 136.94,75.35
  IN1 w0.097: 136.94,75.35 136.94,61.16 134.54,58.76 134.54,52.51 135.08,51.97 135.08,50.64 136.08,49.64 136.08,43.79 135.57,43.28 135.57,37.01 135.47,36.91 135.24,36.91 135.14,36.82 135.14,36.62 135.24,36.53 135.47,36.53 135.57,36.43 135.57,36.24 135.47,36.14 135.24,36.14 135.14,36.04 135.14,35.85 135.24,35.75 135.47,35.75 135.57,35.66 135.57,35.43 135.27,35.13 135.27,34.1 v2(135.67,33.7)
  BOTTOM w0.076: v2(132.08,91.27) 131.66,90.97 CPU1.V10
  BOTTOM w0.114: v2(135.67,33.7) 134.53,34.84 JDIMM2.203
DDR_B_D43: length 67.5
  IN1 w0.089: 137.24,75.37 137.24,78.77 137.71,79.24 137.71,79.89 133.2,84.41 133.2,88.54 132.97,88.77 132.97,89.58 132.66,89.88 132.66,91.35 v2(132.09,91.92)
  IN1 w0.097: 137.24,75.37 137.24,61.04 134.84,58.64 134.84,56.69 135.04,56.49 135.29,56.49 135.38,56.4 135.38,56.2 135.29,56.11 135.04,56.11 134.94,56.01 134.94,55.82 135.04,55.72 135.29,55.72 135.38,55.62 135.38,55.43 135.29,55.33 135.04,55.33 134.94,55.24 134.94,55.05 135.04,54.95 135.29,54.95 135.38,54.85 135.38,54.66 135.29,54.56 135.04,54.56 134.94,54.47 134.94,54.27 135.04,54.18 135.29,54.18 135.38,54.08 135.38,53.89 135.29,53.79 135.04,53.79 134.94,53.69 134.94,53.5 135.04,53.4 135.29,53.4 135.38,53.31 135.38,53.11 135.29,53.02 135.04,53.02 134.94,52.92 134.94,52.73 135.04,52.63 135.26,52.63 135.38,52.51 135.38,50.77 136.37,49.78 136.37,43.67 135.87,43.16 135.87,35.16 v2(135.67,34.97)
  BOTTOM w0.076: v2(132.09,91.92) 131.66,91.62 CPU1.V11
  BOTTOM w0.114: v2(135.67,34.97) 135.53,35.11 JDIMM2.207
DDR_B_D44: length 67.7
  IN1 w0.089: 134.54,75.35 134.54,79.99 131.08,83.45 131.08,88.24 130.62,88.69 130.62,89.49 130.77,89.64 130.77,90.84 v2(131.2,91.27)
  IN1 w0.097: 134.54,75.35 134.54,75.34 134.54,62.28 131.23,58.97 131.23,49.86 132.7,48.4 132.7,40.98 132.65,40.93 132.65,40.21 132.63,40.2 132.63,38.44 131.59,37.4 131.59,32.89 v2(131.99,32.49)
  BOTTOM w0.076: CPU1.W11 130.88,91.6 v2(131.2,91.27)
  BOTTOM w0.114: v2(131.99,32.49) 131.28,31.77 JDIMM2.190
DDR_B_D45: length 67.6
  IN1 w0.089: 134.24,75.35 134.24,80.04 130.87,83.4 130.87,88.19 130.44,88.62 130.44,90.59 v2(130.3,90.73)
  IN1 w0.097: v2(131.99,31.22) 131.87,31.1 131.33,31.1 131.07,31.35 131.07,38.6 132.33,39.86 132.33,40.3 132.35,40.3 132.35,41.05 132.4,41.1 132.4,48.27 130.93,49.74 130.93,59.11 134.19,62.36 134.19,75.3 134.24,75.35
  BOTTOM w0.076: v2(130.3,90.73) 130.52,90.95 CPU1.W10
  BOTTOM w0.114: v2(131.99,31.22) 132.28,30.94 JDIMM2.194
DDR_B_D46: length 67.6
  IN1 w0.089: 136.34,75.35 136.34,79.66 132.03,83.97 132.03,89.23 v2(132.12,89.32)
  IN1 w0.097: v2(135.67,31.16) 134.8,31.16 134.35,31.6 134.35,37.65 134.97,38.27 134.97,39.37 134.87,39.47 134.6,39.47 134.5,39.56 134.5,39.76 134.6,39.85 134.87,39.85 134.97,39.95 134.97,40.71 134.87,40.81 134.6,40.81 134.5,40.9 134.5,41.1 134.6,41.19 134.87,41.19 134.97,41.29 134.97,41.48 134.87,41.58 134.6,41.58 134.5,41.68 134.5,43.45 134.97,43.92 134.97,49.9 133.94,50.93 133.94,57.44 133.94,57.44 133.94,59.01 136.34,61.41 136.34,75.35
  BOTTOM w0.076: v2(132.12,89.32) CPU1.V7
  BOTTOM w0.114: v2(135.67,31.16) 135.78,31.05 JDIMM2.208
DDR_B_D47: length 68
  IN1 w0.089: v2(132.12,89.97) 132.12,89.84 132.5,89.46 132.5,88.72 132.82,88.4 132.82,84.27 137.35,79.74 137.35,79.39 136.64,78.68 136.64,75.35
  IN1 w0.097: 136.64,75.35 136.64,61.29 134.24,58.89 134.24,51.05 135.27,50.03 135.27,43.23 135.17,43.13 134.9,43.13 134.8,43.04 134.8,42.84 134.9,42.75 135.17,42.75 135.27,42.65 135.27,42.46 135.17,42.36 134.9,42.36 134.8,42.26 134.8,42.07 134.9,41.97 135.17,41.97 135.27,41.88 135.27,38.15 134.65,37.53 134.65,33.45 v2(135.67,32.43)
  BOTTOM w0.076: v2(132.12,89.97) CPU1.V8
  BOTTOM w0.114: JDIMM2.204 134.78,31.53 v2(135.67,32.43)
DDR_B_D48: length 67.7
  IN1 w0.089: v2(133.95,91.92) 133.41,91.38 133.41,89.81 133.23,89.63 133.23,88.98 133.58,88.62 133.58,84.28 137.89,79.97 137.89,79.27 138.16,79 138.16,78.55 137.97,78.37 137.97,76.1
  IN1 w0.097: 137.97,76.1 137.97,60.67 136.2,58.9 136.2,50.99 137.13,50.06 137.13,35.67 136.81,35.35 136.81,31.92 v2(137.51,31.22)
  BOTTOM w0.076: v2(133.95,91.92) CPU1.R11
  BOTTOM w0.114: v2(137.51,31.22) 137.78,30.96 JDIMM2.216
DDR_B_D49: length 67.6
  IN1 w0.089: 140.97,79.1 141.04,79.17 141.04,79.99 135.82,85.22 135.82,89.12 135.58,89.35 135.58,90.14 135.41,90.32 135.41,91.38 v2(134.86,91.92)
  IN1 w0.097: 140.97,79.1 140.97,50.76 142.14,49.59 142.14,43.54 141.5,42.91 141.5,37.47 141.9,37.08 141.9,31.92 v2(141.13,31.16)
  BOTTOM w0.076: v2(134.86,91.92) CPU1.P11
  BOTTOM w0.114: JDIMM2.228 140.78,30.8 v2(141.13,31.16)
DDR_B_D50: length 67.4
  IN1 w0.089: v2(134.86,89.32) 135.28,88.9 135.28,84.94 140.14,80.08 140.14,78.27 140.07,78.2
  IN1 w0.097: 140.07,78.2 140.07,59.8 139.31,59.05 139.31,51.08 140.45,49.94 140.45,42.84 140.36,42.75 139.95,42.75 139.85,42.65 139.85,42.46 139.95,42.36 140.36,42.36 140.45,42.26 140.45,42.04 140.36,41.94 139.95,41.94 139.85,41.85 139.85,41.66 139.95,41.56 140.31,41.56 140.41,41.46 140.41,41.27 140.31,41.17 139.95,41.17 139.85,41.08 139.85,40.88 139.95,40.79 140.31,40.79 140.41,40.69 140.41,39.57 140.31,39.47 139.95,39.47 139.85,39.37 139.85,39.18 139.95,39.08 140.12,39.08 140.22,38.99 140.22,37.96 140.12,37.87 139.95,37.87 139.85,37.77 139.85,37.58 139.95,37.48 140.12,37.48 140.75,36.85 140.75,34.08 v2(141.13,33.7)
  BOTTOM w0.076: v2(134.86,89.32) CPU1.P7
  BOTTOM w0.114: JDIMM2.225 140.03,34.8 v2(141.13,33.7)
DDR_B_D51: length 67.2
  IN1 w0.089: v2(133.95,89.97) 133.95,89.84 133.58,89.48 133.58,89.12 133.93,88.77 133.93,84.42 138.57,79.78 138.57,76.7
  IN1 w0.097: v2(137.51,35.03) 137.75,35.27 137.75,37.63 138.28,38.16 138.28,40.89 138.19,40.98 137.85,40.98 137.75,41.08 137.75,41.27 137.85,41.37 138.19,41.37 138.28,41.46 138.28,49.76 137.33,50.71 137.33,52.73 137.21,52.85 136.95,52.85 136.85,52.96 136.85,53.14 136.95,53.24 137.21,53.24 137.31,53.33 137.31,53.53 137.21,53.62 136.95,53.62 136.85,53.73 136.85,53.91 136.95,54.01 137.21,54.01 137.31,54.11 137.31,54.3 137.21,54.4 136.95,54.4 136.85,54.5 136.85,54.68 136.95,54.78 137.21,54.78 137.31,54.88 137.31,55.07 137.21,55.17 136.95,55.17 136.85,55.27 136.85,55.45 136.95,55.55 137.21,55.55 137.31,55.65 137.31,55.84 137.21,55.94 136.95,55.94 136.85,56.04 136.85,56.22 136.95,56.33 137.21,56.33 137.31,56.42 137.31,56.62 137.21,56.71 136.95,56.71 136.85,56.82 136.85,57 136.95,57.1 137.21,57.1 137.31,57.2 137.31,57.39 137.21,57.49 136.95,57.49 136.85,57.59 136.85,57.77 136.95,57.87 137.21,57.87 137.31,57.97 137.31,58.19 137.21,58.29 137.01,58.29 136.91,58.39 136.91,58.57 137.01,58.67 137.21,58.67 137.31,58.77 137.31,59.16 138.57,60.43 138.57,76.7
  BOTTOM w0.076: v2(133.95,89.97) CPU1.R8
  BOTTOM w0.114: JDIMM2.215 137.53,35.97 v2(137.51,35.03)
DDR_B_D52: length 67
  IN1 w0.089: v2(133.95,91.27) 133.58,90.91 133.58,89.73 133.41,89.55 133.41,89.05 133.76,88.7 133.76,84.35 138.33,79.77 138.33,77.6 138.27,77.53 138.27,76.4
  IN1 w0.097: v2(137.51,33.76) 137.24,33.76 137.11,33.89 137.11,35.22 137.45,35.57 137.45,43.39 137.92,43.85 137.92,49.7 137.03,50.58 137.03,51.56 136.91,51.68 136.6,51.68 136.5,51.78 136.5,51.97 136.6,52.07 136.91,52.07 137.01,52.17 137.01,52.36 136.91,52.46 136.65,52.46 136.55,52.55 136.55,58.83 138.27,60.55 138.27,76.4
  BOTTOM w0.076: v2(133.95,91.27) CPU1.R10
  BOTTOM w0.114: v2(137.51,33.76) 136.53,34.75 JDIMM2.211
DDR_B_D53: length 67
  IN1 w0.089: 140.67,78.8 140.74,78.87 140.74,80.04 135.64,85.14 135.64,89.05 135.41,89.28 135.41,90.07 135.23,90.25 135.23,90.9 v2(134.86,91.27)
  IN1 w0.097: 140.67,78.8 140.67,50.63 141.84,49.46 141.84,43.67 141.2,43.03 141.2,37.32 141.58,36.94 141.58,32.87 v2(141.13,32.43)
  BOTTOM w0.076: v2(134.86,91.27) CPU1.P10
  BOTTOM w0.114: JDIMM2.224 139.78,31.07 v2(141.13,32.43)
DDR_B_D54: length 67.6
  IN1 w0.089: 138.87,77 138.87,79.74 134.11,84.5 134.11,89.16 v2(133.95,89.32)
  IN1 w0.097: v2(137.51,32.49) 138.14,33.12 138.14,35.41 138.58,35.85 138.58,36.3 138.49,36.39 138.29,36.39 138.2,36.49 138.2,36.68 138.29,36.78 138.49,36.78 138.58,36.87 138.58,37.07 138.49,37.16 138.29,37.16 138.2,37.26 138.2,37.45 138.29,37.55 138.49,37.55 138.58,37.65 138.58,48.04 138.68,48.14 139.16,48.14 139.26,48.23 139.26,48.42 139.16,48.52 138.68,48.52 138.58,48.62 138.58,48.81 138.68,48.91 139.16,48.91 139.26,49 139.26,49.2 139.16,49.29 138.68,49.29 138.58,49.39 138.58,50.12 138.12,50.58 138.12,59.55 138.87,60.3 138.87,77
  BOTTOM w0.076: v2(133.95,89.32) CPU1.R7
  BOTTOM w0.114: v2(137.51,32.49) 136.78,31.75 JDIMM2.212
DDR_B_D55: length 66.8
  IN1 w0.089: 140.37,78.5 140.44,78.57 140.44,80.09 135.46,85.07 135.46,88.97 135.23,89.21 135.23,89.6 v2(134.86,89.97)
  IN1 w0.097: 140.37,78.5 140.37,59.68 139.61,58.92 139.61,54.95 139.75,54.81 140.27,54.81 140.37,54.72 140.37,54.52 140.27,54.43 139.75,54.43 139.65,54.33 139.65,54.14 139.75,54.04 140.27,54.04 140.37,53.95 140.37,53.75 140.27,53.66 139.75,53.66 139.65,53.56 139.65,53.37 139.75,53.27 140.27,53.27 140.37,53.17 140.37,52.98 140.27,52.88 139.75,52.88 139.65,52.79 139.65,52.59 139.75,52.5 140.27,52.5 140.37,52.4 140.37,52.21 140.27,52.11 139.75,52.11 139.65,52.01 139.65,51.82 139.75,51.73 140.27,51.73 140.37,51.63 140.37,50.51 141.54,49.34 141.54,43.79 140.75,43.01 140.75,37.28 141.13,36.9 v2(141.13,34.97)
  BOTTOM w0.076: v2(134.86,89.97) CPU1.P8
  BOTTOM w0.114: JDIMM2.229 141.03,35.07 v2(141.13,34.97)
DDR_B_D56: length 68.1
  IN1 w0.089: v2(137.57,91.92) 138.04,91.45 138.04,91.13 138.17,91 138.17,90.24 139.4,89.01 139.4,87.34 140.45,86.28 140.45,85.6 140.35,85.51 140.35,84.42 142.84,81.93 143.71,81.93 143.76,81.88
  IN1 w0.097: v2(147.17,33.7) 147.57,34.1 147.57,42.77 147.78,42.97 147.78,49.22 145.58,51.41 145.58,73.31 144.84,74.05 144.84,80.8 143.76,81.88
  BOTTOM w0.076: v2(137.57,91.92) CPU1.L11
  BOTTOM w0.114: v2(147.17,33.7) 145.46,35.41 145.46,35.94 145.03,36.37 JDIMM2.245
DDR_B_D57: length 68.6
  IN1 w0.089: 141.49,79.8 141.49,79.94 136.08,85.35 136.08,90.34 136.14,90.4 136.14,91.37 v2(136.69,91.92)
  IN1 w0.097: 141.49,79.8 141.85,79.44 141.85,72.8 142.09,72.56 142.09,71.37 141.99,71.27 141.8,71.27 141.7,71.18 141.7,70.98 141.8,70.89 141.99,70.89 142.09,70.79 142.09,68.84 141.7,68.45 141.7,51.93 142.09,51.54 142.09,50.67 143.08,49.68 143.08,43.45 142.44,42.82 142.44,37.76 142.63,37.58 142.63,32.01 v2(143.48,31.16)
  BOTTOM w0.076: v2(136.69,91.92) CPU1.M11
  BOTTOM w0.114: v2(143.48,31.16) 142.78,30.45 JDIMM2.236
DDR_B_D58: length 68.5
  IN1 w0.089: 143.12,81.25 142.53,81.25 138.51,85.27 138.51,88.22 137.56,89.17 v2(137.56,89.41)
  IN1 w0.097: 143.12,81.25 143.94,80.43 143.94,73.68 144.32,73.3 144.32,57.48 144.42,57.38 144.59,57.38 144.68,57.28 144.68,57.09 144.59,56.99 144.42,56.99 144.32,56.9 144.32,56.71 144.42,56.61 144.59,56.61 144.68,56.51 144.68,56.32 144.59,56.22 144.42,56.22 144.32,56.13 144.32,55.9 144.42,55.81 144.59,55.81 144.68,55.71 144.68,55.52 144.59,55.42 144.42,55.42 144.32,55.32 144.32,55.13 144.42,55.03 144.59,55.03 144.68,54.94 144.68,54.74 144.59,54.65 144.42,54.65 144.32,54.55 144.32,54.36 144.42,54.26 144.59,54.26 144.68,54.17 144.68,53.97 144.59,53.88 144.42,53.88 144.32,53.78 144.32,53.56 144.68,53.19 144.68,51.04 146.32,49.4 146.32,32 v2(147.17,31.16)
  BOTTOM w0.076: CPU1.L7 137.07,89.05 v2(137.56,89.41)
  BOTTOM w0.114: JDIMM2.250 146.28,30.59 146.84,31.16 v2(147.17,31.16)
DDR_B_D59: length 67.9
  IN1 w0.089: 142.22,80.35 139.77,82.8 139.77,83.19 137.97,84.98 137.97,87.98 137.59,88.37 137.41,88.37 136.62,89.17 v2(136.62,89.29)
  IN1 w0.097: 142.22,80.35 142.75,79.82 142.75,73.18 142.99,72.94 142.99,67.41 142.89,67.31 142.69,67.31 142.6,67.22 142.6,67.02 142.73,66.89 142.89,66.89 142.99,66.79 142.99,66.6 142.89,66.5 142.69,66.5 142.6,66.41 142.6,66.22 142.69,66.12 142.89,66.12 142.99,66.02 142.99,65.83 142.89,65.73 142.69,65.73 142.6,65.64 142.6,65.44 142.69,65.35 142.89,65.35 142.99,65.25 142.99,65.06 142.89,64.96 142.73,64.96 142.63,64.86 142.63,64.67 142.73,64.57 142.89,64.57 142.99,64.48 142.99,51.04 144.52,49.51 144.52,43.58 144.12,43.18 144.12,37.36 144.52,36.96 144.52,34.65 143.9,34.03 143.9,32.84 v2(143.48,32.43)
  BOTTOM w0.076: CPU1.M8 136.23,89.68 v2(136.62,89.29)
  BOTTOM w0.114: JDIMM2.232 141.78,30.72 v2(143.48,32.43)
DDR_B_D60: length 68
  IN1 w0.089: v2(137.57,91.27) 137.93,90.92 137.93,90.23 139.21,88.95 139.21,87.27 140.27,86.21 140.27,85.68 140.18,85.58 140.18,84.34 142.81,81.71 143.51,81.71 143.54,81.67
  IN1 w0.097: v2(147.17,34.97) 147.27,35.07 147.27,42.89 147.48,43.1 147.48,49.09 145.28,51.29 145.28,59.67 145.19,59.77 145.02,59.77 144.92,59.86 144.92,60.06 145.02,60.15 145.19,60.15 145.28,60.25 145.28,60.44 145.19,60.54 145.02,60.54 144.92,60.63 144.92,60.83 145.02,60.92 145.19,60.92 145.28,61.02 145.28,61.21 145.19,61.31 145.02,61.31 144.92,61.41 144.92,61.6 145.02,61.7 145.19,61.7 145.28,61.79 145.28,61.99 145.19,62.08 145.02,62.08 144.92,62.18 144.92,62.37 145.02,62.47 145.19,62.47 145.28,62.56 145.28,62.76 145.19,62.85 145.02,62.85 144.92,62.95 144.92,63.14 145.02,63.24 145.19,63.24 145.28,63.34 145.28,63.53 145.19,63.63 145.02,63.63 144.92,63.72 144.92,63.92 145.02,64.01 145.19,64.01 145.28,64.11 145.28,64.3 145.19,64.4 145.02,64.4 144.92,64.5 144.92,64.69 145.02,64.78 145.19,64.78 145.28,64.88 145.28,73.18 144.54,73.92 144.54,80.67 143.54,81.67
  BOTTOM w0.076: v2(137.57,91.27) CPU1.L10
  BOTTOM w0.114: JDIMM2.249 146.03,35.59 146.65,34.97 v2(147.17,34.97)
DDR_B_D61: length 68.5
  IN1 w0.089: v2(136.69,91.27) 136.31,90.9 136.31,90.32 136.26,90.26 136.26,85.43 141.19,80.49 141.22,80.49 141.79,79.92
  IN1 w0.097: 141.79,79.92 142.15,79.57 142.15,72.92 142.39,72.68 142.39,68.52 142.29,68.43 142.1,68.43 142,68.33 142,54.5 142.1,54.41 142.29,54.41 142.39,54.31 142.39,54.12 142.29,54.02 142.1,54.02 142,53.92 142,53.73 142.1,53.63 142.29,53.63 142.39,53.54 142.39,53.35 142.29,53.25 142.1,53.25 142,53.15 142,52.96 142.1,52.86 142.29,52.86 142.39,52.77 142.39,52.57 142.29,52.48 142.1,52.48 142,52.38 142,52.19 142.1,52.09 142.29,52.09 142.39,51.99 142.39,50.79 143.92,49.26 143.92,43.83 142.82,42.73 142.82,37.81 143.03,37.6 143.03,34.21 143.48,33.76 v2(143.48,33.7)
  BOTTOM w0.076: v2(136.69,91.27) CPU1.M10
  BOTTOM w0.114: v2(143.48,33.7) 142.03,35.15 JDIMM2.233
DDR_B_D62: length 68.5
  IN1 w0.089: v2(136.63,88.65) 136.71,88.65 137.02,88.33 137.02,87.87 136.79,87.64 136.79,86.89 137.29,86.39 137.57,86.39 137.8,86.16 137.8,84.91 139.6,83.11 139.6,82.55 142.01,80.14
  IN1 w0.097: 142.01,80.14 142.45,79.7 142.45,73.05 142.69,72.81 142.69,68.24 142.59,68.14 142.4,68.14 142.3,68.05 142.3,64.28 142.4,64.18 142.59,64.18 142.69,64.08 142.69,63.89 142.59,63.79 142.4,63.79 142.3,63.7 142.3,63.51 142.4,63.41 142.59,63.41 142.69,63.31 142.69,63.12 142.59,63.02 142.4,63.02 142.3,62.93 142.3,62.73 142.4,62.64 142.59,62.64 142.69,62.54 142.69,62.35 142.59,62.25 142.4,62.25 142.3,62.15 142.3,61.96 142.4,61.86 142.59,61.86 142.69,61.77 142.69,61.54 142.59,61.45 142.4,61.45 142.3,61.35 142.3,61.16 142.4,61.06 142.59,61.06 142.69,60.97 142.69,60.77 142.59,60.68 142.4,60.68 142.3,60.58 142.3,60.39 142.4,60.29 142.59,60.29 142.69,60.19 142.69,60 142.59,59.9 142.4,59.9 142.3,59.81 142.3,59.61 142.4,59.52 142.59,59.52 142.69,59.42 142.69,59.23 142.59,59.13 142.4,59.13 142.3,59.03 142.3,58.84 142.4,58.75 142.59,58.75 142.69,58.65 142.69,58.46 142.59,58.36 142.4,58.36 142.3,58.26 142.3,58.07 142.4,57.97 142.59,57.97 142.69,57.88 142.69,57.68 142.59,57.59 142.4,57.59 142.3,57.49 142.3,57.3 142.4,57.2 142.59,57.2 142.69,57.1 142.69,56.91 142.59,56.81 142.4,56.81 142.3,56.72 142.3,56.53 142.4,56.43 142.59,56.43 142.69,56.33 142.69,56.14 142.59,56.04 142.4,56.04 142.3,55.95 142.3,55.75 142.4,55.66 142.59,55.66 142.69,55.56 142.69,55.37 142.59,55.27 142.4,55.27 142.3,55.17 142.3,54.98 142.4,54.88 142.59,54.88 142.69,54.79 142.69,50.92 144.22,49.39 144.22,43.7 143.12,42.6 143.12,37.94 144.22,36.84 144.22,35.66 143.53,34.97 v2(143.48,34.97)
  BOTTOM w0.076: v2(136.63,88.65) 136.27,89 CPU1.M7
  BOTTOM w0.114: v2(143.48,34.97) 143.03,35.42 JDIMM2.237
DDR_B_D63: length 67.9
  IN1 w0.089: v2(137.57,89.97) 137.92,89.63 137.92,89.11 138.89,88.14 138.89,85.14 142.53,81.5 143.29,81.5 143.33,81.46
  IN1 w0.097: v2(147.17,32.43) 146.62,32.97 146.62,49.53 144.98,51.16 144.98,57.67 144.89,57.77 144.72,57.77 144.62,57.86 144.62,58.06 144.72,58.15 144.89,58.15 144.98,58.25 144.98,58.44 144.89,58.54 144.72,58.54 144.62,58.64 144.62,58.86 144.72,58.96 144.89,58.96 144.98,59.05 144.98,59.25 144.89,59.34 144.72,59.34 144.62,59.44 144.62,73.42 144.24,73.8 144.24,80.55 143.33,81.46
  BOTTOM w0.076: v2(137.57,89.97) CPU1.L8
  BOTTOM w0.114: JDIMM2.246 145.28,30.06 146.51,31.3 146.51,31.78 v2(147.17,32.43)
DDR_B_DQS0: length 74.3
  IN1 w0.089: 100.17,89.38 100.17,89.38 100.18,89.39 100.18,89.39 100.22,89.43 100.23,89.43 101.21,90.41 101.21,90.86 101.54,91.19 102.84,91.19 103.34,90.69 103.94,90.69 104.02,90.77 104.02,91 v2(103.86,91.16)
  IN1 w0.097: 100.15,89.36 100.13,89.35 100.13,89.34 100.09,89.31 100.09,89.15 100.1,89.15 100.1,88.7 99.78,88.39 99.78,88.11 99.11,87.44 99.11,76.4 92.62,69.91 92.62,69.89 92.62,69.88 92.62,61.19 92.62,60.02 85.07,52.48 85.07,44.82 84.42,44.16 84.42,43.83 84.79,43.46 84.79,43.17 84.7,43.07 84.63,43.07 84.4,42.84 84.4,42.45 84.66,42.19 84.66,41.81 84.4,41.56 84.4,38.76 84.44,38.72 84.44,35.65 83.71,34.91 83.71,33.79 83.94,33.55 84.11,33.55 v2(84.34,33.32)
  IN1 w0.099: 100.15,89.36 100.17,89.38
  BOTTOM w0.076: CPU1.BR9 103.53,90.75 v2(103.86,91.16)
  BOTTOM w0.114: v2(84.34,33.32) 84.58,33.56 84.8,33.56 85.1,33.86 85.1,35.24 84.91,35.43 84.91,36.15 85.03,36.27 JDIMM2.13
DDR_B_DQS1: length 72.4
  IN1 w0.089: v2(106.58,90.62) 106.45,90.62 106.34,90.52 106.34,88.66 105.21,87.52 105.21,87.01 106.12,86.1 106.12,83.85 104.38,82.11 104.38,77.6 104.36,77.58
  IN1 w0.097: 102.82,75.93 102.81,75.93 102.81,73.39 96.57,67.15 96.57,58.45 91.02,52.89 91.02,48.42 90.51,47.92 90.51,43.65 90.62,43.54 90.62,36.68 89.41,35.47 89.41,33.93 88.78,33.3 88.78,32.57 88.91,32.44 89.24,32.44 89.37,32.57 v2(89.37,32.68)
  IN1 w0.099: 104.36,77.58 104.36,77.48 104.31,77.42 102.82,75.93
  BOTTOM w0.076: v2(106.58,90.62) 106.46,90.51 106.46,90.27 106.55,90.18 106.85,90.18 CPU1.BJ9
  BOTTOM w0.114: JDIMM2.34 90.28,29.72 90.09,29.9 90.09,32.06 89.84,32.3 89.7,32.3 89.37,32.63 v2(89.37,32.68)
DDR_B_DQS2: length 70.1
  IN1 w0.089: 107.27,76.76 107.27,76.77 109.89,79.38 109.89,82.84 110.31,83.27 110.31,87.58 109.81,88.09 109.81,90.4 110.03,90.62 v2(110.15,90.62)
  IN1 w0.097: v2(94.96,33.32) 95.02,33.38 95.24,33.38 95.37,33.25 96.05,33.25 96.43,33.64 96.43,47.53 96.11,47.85 96.11,52.29 100.29,56.47 100.29,65.59 106.66,71.95 106.66,72.84 106.66,72.84 106.66,75.57 106.66,75.57
  IN1 w0.099: 106.66,75.57 107.27,76.18 107.27,76.76
  BOTTOM w0.076: v2(110.15,90.62) CPU1.BF9
  BOTTOM w0.114: JDIMM2.55 95.53,36.29 95.38,36.15 95.38,35.37 95.7,35.05 95.7,33.77 95.43,33.49 95.13,33.49 v2(94.96,33.32)
DDR_B_DQS3: length 69.1
  IN1 w0.089: 110.7,75.35 110.7,75.37 110.7,75.37 110.7,75.42 110.69,75.43 110.69,76.05 113.07,78.43 113.07,80.61 113.37,80.92 113.37,88.34 112.54,89.17 112.54,90.5 112.67,90.62 v2(112.91,90.62)
  IN1 w0.097: 110.7,75.35 110.7,70.71 104.53,64.55 104.53,58.1 104.02,57.59 104.02,54.93 101.79,52.7 101.79,35.31 101.55,35.06 101.55,34.76 101.8,34.51 101.8,32.55 101.56,32.31 101.28,32.31 101.13,32.16 v2(101.13,32.05)
  BOTTOM w0.076: v2(112.91,90.62) CPU1.BB9
  BOTTOM w0.114: JDIMM2.76 100.78,29.69 100.65,29.81 100.65,32.13 100.78,32.25 100.92,32.25 v2(101.13,32.05)
