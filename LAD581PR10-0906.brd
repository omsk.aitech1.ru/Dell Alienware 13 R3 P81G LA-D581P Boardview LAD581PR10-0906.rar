# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D3: length 23.4
  IN5 w0.089: 206.33,128.39 206.33,129.95 206.77,130.39 208.2,130.39 v2(208.61,129.98)
  IN5 w0.145: 206.33,128.39 206.33,126.83 200.74,121.25 200.74,118.72 201.39,118.07 201.39,116.85 201.93,116.31 202.44,116.31 v2(202.45,116.3)
  BOTTOM w0.089: UG1.T2 v2(208.61,129.98)
  BOTTOM w0.142: UG9.U49 202.45,113.6 202.45,115.55 202.54,115.64 202.54,116.21 v2(202.45,116.3)
FBA_D4: length 28.1
  IN5 w0.089: v2(207.81,133.18) 208.22,133.58 210.81,133.58
  IN5 w0.145: 210.81,133.58 212.1,132.29 212.1,128.29 211.15,127.34 211.15,124.17 206.3,119.31 v2(204.2,119.31)
  BOTTOM w0.089: UG1.N4 v2(207.81,133.18)
  BOTTOM w0.142: v2(204.2,119.31) 204.11,119.31 203.81,119.01 203.81,115.92 203.85,115.89 203.85,115.2 204.2,114.85 UG9.R51
FBA_D5: length 24.6
  IN5 w0.089: 210.81,131.74 210.58,131.98 209.81,131.98 v2(209.41,132.38)
  IN5 w0.145: 210.81,131.74 210.92,131.64 210.92,128.19 210.39,127.66 210.39,124.23 206.1,119.94 v2(204.19,119.94)
  BOTTOM w0.089: UG1.N2 209.01,132.78 v2(209.41,132.38)
  BOTTOM w0.142: UG9.R50 204.2,114.1 203.85,114.45 203.85,114.85 203.6,115.1 203.6,115.75 203.56,115.8 203.56,118.06 ; v2(204.19,119.94) 203.47,119.22 203.47,118.15
  BOTTOM w0.178: 203.56,118.06 203.47,118.15
FBA_D6: length 33.9
  IN5 w0.145: v2(207.81,133.98) 207.81,134.03 208.26,134.48 211.17,134.48 213.43,132.22 213.43,122.89 210.83,120.29 208.33,120.29 204.8,116.76 204.8,112.45 v2(203.9,111.55)
  BOTTOM w0.089: UG1.M4 v2(207.81,133.98)
  BOTTOM w0.17: UG9.R47 v2(203.9,111.55)
FBA_D7: length 26.8
  IN5 w0.089: 208.99,128.87 208.99,132.76 v2(209.41,133.18)
  IN5 w0.145: 208.99,128.87 208.99,124.87 206.52,122.39 204.67,122.39 203.34,121.06 203.34,116.01 202.64,115.31 202.64,111.91 v2(203.1,111.45)
  BOTTOM w0.089: v2(209.41,133.18) 209.01,133.58 UG1.M2
  BOTTOM w0.178: UG9.U46 v2(203.1,111.45)
FBA_D8: length 24.8
  IN3 w0.089: v2(202.21,129.98) 201.21,129.98 200.99,129.75 200.99,128.93
  IN3 w0.14: v2(201.79,110.86) 201.42,110.49 200.75,110.49 200.48,110.76 200.48,114.39 198.45,116.43 198.45,126.39 200.99,128.93
  BOTTOM w0.089: UG1.U11 v2(202.21,129.98)
  BOTTOM w0.178: UG9.V46 202.08,111.15 v2(201.79,110.86)
FBA_D9: length 22.8
  IN3 w0.14: v2(199.79,129.18) 199.79,129 197.75,126.96 197.75,116.52 200.15,114.12 200.15,110.52 200.63,110.04 v2(201.11,110.04)
  BOTTOM w0.089: v2(199.79,129.18) 200.19,129.58 UG1.U13
  BOTTOM w0.178: UG9.Y45 v2(201.11,110.04)
FBA_D10: length 20.6
  IN3 w0.14: v2(201.11,112.25) 200.8,112.56 200.8,114.85 199.15,116.5 199.15,126.07 201.44,128.36 201.44,129.05 v2(201.45,129.06)
  BOTTOM w0.089: v2(201.45,129.06) 201.45,130.01 UG1.T11
  BOTTOM w0.178: UG9.Y47 v2(201.11,112.25)
FBA_D11: length 25.8
  IN3 w0.089: 202.39,130.39 200.22,130.39 v2(199.81,129.98) ; 201.95,111.84 201.43,111.84 v2(201.06,111.48)
  IN3 w0.14: 201.95,111.84 202.21,112.1 202.21,114.16 199.85,116.52 199.85,125.82 202.64,128.61 202.64,130.14 202.39,130.39
  BOTTOM w0.089: UG1.T13 v2(199.81,129.98)
  BOTTOM w0.178: v2(201.06,111.48) 200.74,111.15 UG9.Y46
FBA_D12: length 22.9
  IN3 w0.14: v2(201.41,132.38) 201.61,132.38 202.01,131.98 202.51,131.98 204.07,130.42 204.07,127.88 201.2,125.01 201.2,120.4 201.54,120.06 v2(202.04,120.06)
  BOTTOM w0.089: UG1.N11 v2(201.41,132.38)
  BOTTOM w0.142: UG9.V50 202.1,114.17 201.75,114.52 201.75,114.85 201.51,115.08 201.51,115.85 201.44,115.92 201.44,119.46 v2(202.04,120.06)
FBA_D13: length 26.9
  IN3 w0.089: v2(200.61,132.38) 200.99,132 200.99,131.41 201.25,131.15 202.64,131.15 203.4,130.39
  IN3 w0.14: 203.4,130.39 203.4,128.29 200.55,125.44 200.55,116.69 202.71,114.53 202.71,111.9 202.36,111.55 201.8,111.55 v2(201.7,111.45)
  BOTTOM w0.089: UG1.N13 v2(200.61,132.38)
  BOTTOM w0.178: UG9.V47 v2(201.7,111.45)
FBA_D14: length 22.7
  IN3 w0.14: v2(201.41,133.18) 201.81,133.58 202.51,133.58 205.5,130.59 205.5,127.15 203.53,125.18 203.53,118.18 v2(202.5,117.15)
  BOTTOM w0.089: UG1.M11 v2(201.41,133.18)
  BOTTOM w0.142: UG9.U52 202.84,115.39 202.84,116.81 v2(202.5,117.15)
FBA_D15: length 24.1
  IN3 w0.089: v2(199.81,133.18) 199.81,133.16 200.23,132.74 202.52,132.74
  IN3 w0.14: 202.52,132.74 204.74,130.52 204.74,127.41 202.83,125.5 202.83,119.85 202.43,119.45 v2(202.05,119.45)
  BOTTOM w0.089: UG1.M13 v2(199.81,133.18)
  BOTTOM w0.142: v2(202.05,119.45) 201.69,119.09 201.69,116.04 201.76,115.97 201.76,115.19 202.1,114.85 UG9.V51
FBA_D16: length 43.6
  IN1 w0.129: v2(194.75,109.45) 194.7,109.45 194.31,109.84
  IN1 w0.145: 194.31,109.84 194.31,115.03 193.5,115.84 193.5,131.41 193.81,131.72 193.81,140.1 198.2,144.49 201.05,144.49 202.2,143.34 v2(202.2,142.77)
  BOTTOM w0.178: v2(202.2,142.77) 202.2,142.77 UG1.A11 ; UG9.AJ44 194.45,109.75 v2(194.75,109.45)
FBA_D17: length 33.8
  IN1 w0.145: v2(196.05,115.85) 196.74,116.55 196.74,125.32 195.67,126.39 195.67,139.29 198.78,142.41 199.48,142.41 v2(199.8,142.73)
  BOTTOM w0.089: v2(199.8,142.73) 200.15,142.38 UG1.A13
  BOTTOM w0.142: v2(196.05,115.85) 196.05,115.78 196.14,115.68 196.14,112.89 UG9.AG48
FBA_D18: length 43.4
  IN1 w0.1: v2(194.7,110.15) 195.08,109.77 195.72,109.77
  IN1 w0.129: 194.79,113.69 195.64,112.84 195.64,112.6 195.93,112.31 195.93,109.98 195.72,109.77
  IN1 w0.145: 194.79,113.69 194.79,115.44 194.37,115.86 194.37,139.76 198.45,143.85 200.61,143.85 201.44,143.02 201.44,142.75 v2(202.21,141.98)
  BOTTOM w0.089: UG1.B11 v2(202.21,141.98)
  BOTTOM w0.178: UG9.AJ45 v2(194.7,110.15)
FBA_D19: length 35.1
  IN1 w0.145: v2(200.61,141.98) 200.23,142.36 200.23,142.9 199.98,143.15 198.64,143.15 195.02,139.53 195.02,116.23 195.59,115.66 195.59,113.69 195.5,113.6 v2(195.5,113.55)
  BOTTOM w0.089: UG1.B13 200.21,141.58 v2(200.61,141.98)
  BOTTOM w0.17: v2(195.5,113.55) UG9.AG49
FBA_D20: length 33.8
  IN1 w0.145: v2(201.41,139.58) 201.8,139.19 201.8,138.12 199.98,136.3 198.71,136.3 198.2,135.79 198.2,132.74 198.39,132.55 198.39,127.98 199.09,127.28 199.09,114.61 198.5,114.02 198.5,111.85 v2(197.5,110.85)
  BOTTOM w0.089: v2(201.41,139.58) 201.81,139.18 UG1.E11
  BOTTOM w0.102: v2(197.5,110.85) 197.2,111.15 UG9.AF46
FBA_D21: length 32.4
  IN1 w0.145: v2(199.81,138.78) 199.41,139.18 198.03,139.18 196.36,137.5 196.36,126.71 197.31,125.75 197.31,115.53 196.15,114.37 196.15,113.04 196.4,112.79 196.4,111.95 v2(196.8,111.55)
  BOTTOM w0.089: UG1.E13 v2(199.81,138.78)
  BOTTOM w0.17: v2(196.8,111.55) UG9.AF47
FBA_D22: length 31.3
  IN1 w0.145: v2(201.41,138.78) 201.01,138.38 198.18,138.38 197.05,137.25 197.05,127.15 197.88,126.33 197.88,115.28 196.8,114.2 196.8,112.82 v2(196.88,112.74)
  BOTTOM w0.089: UG1.F11 201.81,138.38 v2(201.41,138.78)
  BOTTOM w0.17: v2(196.88,112.74) UG9.AF48
FBA_D23: length 29.5
  IN1 w0.145: v2(197.6,111.55) 198.02,111.97 198.02,114.28 198.45,114.71 198.45,126.96 197.75,127.66 197.75,136.87 198.45,137.57 199.4,137.57 v2(199.81,137.98)
  BOTTOM w0.089: UG1.F13 v2(199.81,137.98)
  BOTTOM w0.17: v2(197.6,111.55) UG9.AD47
FBA_D24: length 36.4
  IN5 w0.145: v2(197.6,113.55) 197.76,113.71 197.76,114.26 196.97,115.05 196.97,116.38 196.67,116.67 196.67,123.79 200.12,127.23 200.12,128.17 201.02,129.07 201.02,130.99 201.22,131.19 201.57,131.19 201.82,131.44 201.82,134.27 202.69,135.13 203.19,135.13 203.79,135.72 203.79,139.6 204.45,140.26 204.45,141.73 205.43,142.71 206.94,142.71 v2(207.01,142.78)
  BOTTOM w0.089: v2(207.01,142.78) 207.41,142.38 UG1.A4
  BOTTOM w0.17: UG9.AD49 v2(197.6,113.55)
FBA_D25: length 39.9
  IN5 w0.145: v2(208.61,142.78) 208.11,143.28 205.06,143.28 203.88,142.11 203.88,141.28 202.71,140.11 202.71,136.17 201,134.46 201,132.22 200.76,131.98 200.46,131.98 200.2,131.72 200.2,129.04 199.38,128.22 199.38,127.28 195.98,123.87 195.98,116.67 196.48,116.17 196.48,115.19 196.74,114.93 196.74,113.71 197.5,112.95 197.5,112.77 v2(197.52,112.75)
  BOTTOM w0.089: UG1.A2 209.01,142.38 v2(208.61,142.78)
  BOTTOM w0.17: v2(197.52,112.75) UG9.AD48
FBA_D26: length 37.3
  IN5 w0.145: v2(198.9,111.45) 198.9,111.57 198.14,112.33 198.14,114.7 197.43,115.41 197.43,123.59 200.77,126.93 200.77,127.84 202.64,129.71 202.64,133.82 204.29,135.47 204.29,139.34 204.99,140.04 204.99,141.44 205.92,142.37 206.37,142.37 206.76,141.98 v2(207.01,141.98)
  BOTTOM w0.089: UG1.B4 207.41,141.58 v2(207.01,141.98)
  BOTTOM w0.17: v2(198.9,111.45) UG9.AC46
FBA_D27: length 37
  IN5 w0.145: v2(208.61,141.98) 208.58,141.98 208.19,141.59 205.84,141.59 205.44,141.18 205.44,139.79 204.74,139.09 204.74,135.22 203.15,133.63 203.15,129.25 201.42,127.52 201.42,126.63 197.99,123.19 197.99,115.61 198.49,115.11 198.49,112.56 v2(198.9,112.15)
  BOTTOM w0.089: v2(208.61,141.98) 209.01,141.58 UG1.B2
  BOTTOM w0.17: v2(198.9,112.15) UG9.AC47
FBA_D28: length 34.7
  IN5 w0.145: v2(207.81,138.78) 207.78,138.78 207.37,139.19 205.53,139.19 205.25,138.9 205.25,135.03 203.67,133.45 203.67,128.82 202.13,127.28 202.13,126.39 198.6,122.85 198.6,115.84 200.07,114.37 200.07,111.92 v2(199.7,111.55)
  BOTTOM w0.089: UG1.E4 207.41,139.18 v2(207.81,138.78)
  BOTTOM w0.178: UG9.AA47 v2(199.7,111.55)
FBA_D29: length 35.1
  IN5 w0.145: v2(208.61,138.78) 208.61,138.77 208.21,138.37 205.92,138.37 205.69,138.14 205.69,134.71 204.26,133.28 204.26,128.45 202.8,126.99 202.8,126.04 199.14,122.38 199.14,116.38 200.36,115.16 200.36,111.33 199.88,110.85 v2(199.7,110.85)
  BOTTOM w0.089: UG1.E2 v2(208.61,138.78)
  BOTTOM w0.178: UG9.AA46 v2(199.7,110.85)
FBA_D30: length 32.9
  IN5 w0.145: v2(207.01,137.98) 206.24,137.21 206.24,134.5 204.93,133.18 204.93,128.1 203.47,126.64 203.47,125.72 199.73,121.98 199.73,116.62 200.79,115.56 200.79,112.54 200.64,112.39 200.64,110.74 200.05,110.15 v2(199.7,110.15)
  BOTTOM w0.089: UG1.F4 v2(207.01,137.98)
  BOTTOM w0.178: UG9.AA45 v2(199.7,110.15)
FBA_D31: length 35.1
  IN5 w0.145: v2(201,109.45) 201.07,109.45 201.36,109.74 201.91,109.74 202.21,110.04 202.21,115.03 200.23,117.01 200.23,121.56 204.17,125.5 204.17,126.39 205.56,127.79 205.56,133.25 206.71,134.39 206.71,136.74 207.55,137.59 208.22,137.59 v2(208.61,137.98)
  BOTTOM w0.089: UG1.F2 v2(208.61,137.98)
  BOTTOM w0.178: UG9.Y44 v2(201,109.45)
FBA_D32: length 19.4
  IN1 w0.145: v2(181.37,128.42) 181.43,128.36 181.43,121.5 184.48,118.45 184.48,117.88 185.14,117.22 185.62,117.22 186.6,116.25 187.07,116.25 187.49,115.82 187.49,115.34 v2(187.1,114.95)
  BOTTOM w0.089: UG2.A4 182.84,129.58 181.69,128.42 v2(181.37,128.42)
  BOTTOM w0.178: UG9.AW51 v2(187.1,114.95)
FBA_D33: length 19
  IN1 w0.145: v2(185.7,115.65) 185.7,115.85 185.28,116.26 185.27,116.26 185.25,116.28 182.84,116.28 180.04,119.09 180.04,128.5 v2(180.35,128.81)
  BOTTOM w0.089: v2(180.35,128.81) 180.43,128.81 181.19,129.58 UG2.A2
  BOTTOM w0.178: UG9.BA52 v2(185.7,115.65)
FBA_D34: length 19.8
  IN1 w0.145: v2(182.74,129.98) 182.14,129.38 182.14,121.94 185.62,118.45 185.62,118.16 187.92,115.87 187.92,114.96 187.2,114.25 v2(187.1,114.25)
  BOTTOM w0.089: UG2.B4 183.14,130.38 v2(182.74,129.98)
  BOTTOM w0.178: UG9.AW50 v2(187.1,114.25)
FBA_D35: length 19.2
  IN1 w0.145: v2(186.3,114.95) 186.11,115.14 186.11,116 185.4,116.71 184.19,116.71 183.46,117.44 183.46,117.95 180.74,120.67 180.74,129.58 v2(181.14,129.98)
  BOTTOM w0.089: UG2.B2 181.54,130.38 v2(181.14,129.98)
  BOTTOM w0.178: UG9.BA51 v2(186.3,114.95)
FBA_D36: length 28.4
  IN1 w0.145: v2(182.74,133.18) 182.33,132.77 179.87,132.77 178.64,131.54 178.64,117.82 182.66,113.8 185.25,113.8 v2(185.7,114.25)
  BOTTOM w0.089: UG2.E4 v2(182.74,133.18)
  BOTTOM w0.178: UG9.BA50 v2(185.7,114.25)
FBA_D37: length 23.7
  IN1 w0.145: v2(185,114.25) 183.16,114.25 179.34,118.07 179.34,131.31 180,131.98 180.74,131.98 v2(181.14,132.38)
  BOTTOM w0.089: v2(181.14,132.38) 181.54,132.78 UG2.E2
  BOTTOM w0.178: UG9.BB50 v2(185,114.25)
FBA_D38: length 32.8
  IN1 w0.145: v2(185.7,112.95) 185.3,112.55 182,112.55 177.33,117.22 177.33,132.08 179.62,134.37 182.35,134.37 v2(182.74,133.98)
  BOTTOM w0.089: UG2.F4 v2(182.74,133.98)
  BOTTOM w0.178: UG9.BA49 v2(185.7,112.95)
FBA_D39: length 30.3
  IN1 w0.145: v2(187.1,112.95) 186.35,112.95 185.89,113.41 182.09,113.41 177.99,117.52 177.99,131.81 179.74,133.57 180.75,133.57 v2(181.14,133.18)
  BOTTOM w0.089: v2(181.14,133.18) 181.54,133.58 UG2.F2
  BOTTOM w0.178: UG9.AW49 v2(187.1,112.95)
FBA_D40: length 21.3
  IN5 w0.089: 186.22,128.32 187.47,129.56 188.76,129.56 v2(189.14,129.18)
  IN5 w0.145: 186.22,128.32 186.2,128.29 186.2,116.67 186.64,116.23 187.15,116.23 187.54,115.84 187.54,113.71 v2(188.4,112.85)
  BOTTOM w0.089: UG2.A11 v2(189.14,129.18)
  BOTTOM w0.17: UG9.AV48 v2(188.4,112.85)
FBA_D41: length 19.5
  IN5 w0.089: v2(190.74,129.18) 190.51,129.18 190.04,128.71 189.66,128.71 189.37,128.42 188.48,128.42 188.38,128.32
  IN5 w0.145: v2(189.2,113.55) 189.28,113.63 189.28,114.23 188.38,115.13 188.38,116.4 187.59,117.18 187.59,127.53 188.38,128.32
  BOTTOM w0.089: v2(190.74,129.18) 190.34,129.58 UG2.A13
  BOTTOM w0.17: UG9.AT49 v2(189.2,113.55)
FBA_D42: length 24.6
  IN5 w0.089: 189.65,128.32 189.82,128.48 190.32,128.48 190.51,128.68 190.77,128.68 191.21,129.12 191.21,130.07 190.9,130.39 189.56,130.39 v2(189.14,129.98)
  IN5 w0.145: v2(189.2,111.55) 189.69,112.04 189.69,115.05 188.99,115.75 188.99,116.74 188.15,117.58 188.15,127.08 189.24,128.17 189.5,128.17 189.65,128.32
  BOTTOM w0.089: UG2.B11 v2(189.14,129.98)
  BOTTOM w0.17: UG9.AT47 v2(189.2,111.55)
FBA_D43: length 22
  IN5 w0.089: 187.36,128.44 187.59,128.68 189.31,128.68 189.56,128.93 189.56,129.37 189.75,129.56 190.32,129.56 v2(190.74,129.98)
  IN5 w0.145: v2(189.2,112.85) 187.88,114.17 187.88,116.07 186.89,117.06 186.89,127.98 187.36,128.44
  BOTTOM w0.089: UG2.B13 v2(190.74,129.98)
  BOTTOM w0.17: UG9.AT48 v2(189.2,112.85)
FBA_D44: length 27.1
  IN5 w0.145: v2(189.2,110.85) 190.05,111.7 190.05,115.87 189.71,116.21 189.71,118.18 188.99,118.9 188.99,126.39 192.1,129.5 192.1,130.9 191.81,131.19 189.71,131.19 189.54,131.37 189.54,131.98 v2(189.14,132.38)
  BOTTOM w0.089: UG2.E11 v2(189.14,132.38)
  BOTTOM w0.17: UG9.AT46 v2(189.2,110.85)
FBA_D45: length 28.5
  IN5 w0.145: v2(182.69,117.69) 182.69,118.96 185.37,121.64 185.37,130.14 188.02,132.79 190.35,132.79 v2(190.74,133.18)
  BOTTOM w0.089: UG2.E13 v2(190.74,133.18)
  BOTTOM w0.102: 183.39,117.05 183.77,116.67 187.28,116.67 188.42,115.53 188.42,115.21 188.1,114.89 UG9.AV51
  BOTTOM w0.178: v2(182.69,117.69) 183.01,117.69 183.39,117.31 183.39,117.05
FBA_D46: length 28.1
  IN5 w0.145: v2(189.14,133.18) 189.12,133.18 188.71,133.59 187.53,133.59 184.67,130.73 184.67,122.2 181.74,119.27 v2(181.74,118.54)
  BOTTOM w0.089: UG2.F11 v2(189.14,133.18)
  BOTTOM w0.102: 182.77,116.67 183.28,116.67 183.47,116.48 187.16,116.48 188.1,115.55 UG9.AV52
  BOTTOM w0.178: 182.77,116.67 181.74,117.7 v2(181.74,118.54)
FBA_D47: length 33.8
  IN5 w0.145: v2(190.74,133.98) 190.74,134.04 190.39,134.39 187.34,134.39 183.97,131.02 183.97,122.77 180.74,119.53 v2(180.74,119.4)
  BOTTOM w0.089: UG2.F13 v2(190.74,133.98)
  BOTTOM w0.102: UG9.AV49 188.1,113.31 187.72,113.69 187.72,115.59 187.02,116.29 182.39,116.29
  BOTTOM w0.178: 182.39,116.29 180.74,117.94 v2(180.74,119.4)
FBA_D48: length 40.9
  IN5 w0.145: v2(194.7,112.85) 194.54,113.01 194.54,125.11 197.58,128.15 197.58,132.03 197.36,132.25 197.36,140.06 192.9,144.51 190,144.51 189.14,143.66 v2(189.14,142.78)
  BOTTOM w0.089: v2(189.14,142.78) 188.74,142.38 UG2.U11
  BOTTOM w0.178: UG9.AJ48 v2(194.7,112.85)
FBA_D49: length 38.1
  IN5 w0.145: v2(190.74,142.78) 190.9,142.78 191.33,143.21 192.42,143.21 195.86,139.77 195.86,132.13 196.27,131.72 196.27,128.4 193.18,125.31 193.18,120.74 193.56,120.36 193.56,115.22 193.78,115 193.78,112.37 v2(194.7,111.45)
  BOTTOM w0.089: UG2.U13 v2(190.74,142.78)
  BOTTOM w0.178: UG9.AJ46 v2(194.7,111.45)
FBA_D50: length 40.9
  IN5 w0.145: v2(194.7,112.15) 194.15,112.7 194.15,120.59 193.82,120.93 193.82,125.17 196.93,128.27 196.93,131.84 196.55,132.22 196.55,140 192.69,143.86 190.27,143.86 189.8,143.39 189.8,143.18 189.55,142.94 189.55,142.51 189.14,142.1 v2(189.14,141.98)
  BOTTOM w0.089: UG2.T11 188.74,141.58 v2(189.14,141.98)
  BOTTOM w0.178: UG9.AJ47 v2(194.7,112.15)
FBA_D51: length 34.7
  IN5 w0.145: v2(193.25,113.7) 193.25,113.78 193.28,113.81 193.28,114.82 192.99,115.12 192.99,120.04 192.48,120.55 192.48,125.56 195.62,128.7 195.62,131.59 195.2,132 195.2,139.61 192.46,142.35 191.95,142.35 191.94,142.37 191.13,142.37 v2(190.74,141.98)
  BOTTOM w0.089: UG2.T13 v2(190.74,141.98)
  BOTTOM w0.178: UG9.AK49 v2(193.25,113.7)
FBA_D52: length 35.2
  IN5 w0.089: 192.8,139.98 189.54,139.98 v2(189.14,139.58)
  IN5 w0.145: v2(192.6,112.15) 192.3,112.45 192.3,114.64 192.42,114.76 192.42,119.72 191.78,120.36 191.78,125.69 194.9,128.8 194.9,131.53 194.45,131.98 194.45,138.33 192.8,139.98
  BOTTOM w0.089: UG2.N11 188.74,139.18 v2(189.14,139.58)
  BOTTOM w0.17: UG9.AM47 v2(192.6,112.15)
FBA_D53: length 33.5
  IN5 w0.089: v2(190.74,138.78) 191.14,139.18 192.65,139.18
  IN5 w0.145: v2(192.7,111.4) 192.65,111.4 191.99,112.06 191.99,114.82 191.85,114.96 191.85,119.34 191.09,120.1 191.09,125.88 194.2,128.99 194.2,131.19 193.75,131.63 193.75,138.07 192.65,139.18
  BOTTOM w0.089: v2(190.74,138.78) 190.34,139.18 UG2.N13
  BOTTOM w0.17: v2(192.7,111.4) 192.55,111.4 UG9.AM46
FBA_D54: length 32.1
  IN5 w0.089: v2(189.14,138.78) 189.53,138.39 190.96,138.39 191.15,138.2 191.15,137.76 191.4,137.5 192.11,137.5
  IN5 w0.145: 192.11,137.5 192.42,137.5 193.05,136.87 193.05,131.55 193.5,131.11 193.5,129.12 190.39,126.01 190.39,119.98 191.28,119.09 191.28,114.92 191.64,114.56 191.64,113.77 191.69,113.71 191.69,113.24 v2(191.3,112.85)
  BOTTOM w0.089: v2(189.14,138.78) 188.74,138.38 UG2.M11
  BOTTOM w0.17: v2(191.3,112.85) UG9.AN48
FBA_D55: length 28.4
  IN5 w0.145: v2(190.74,137.98) 190.74,137.4 192.1,136.04 192.1,134.39 191.91,134.2 191.91,132.99 192.23,132.68 192.23,131.6 192.8,131.02 192.8,129.37 189.69,126.26 189.69,119.53 190.7,118.52 190.7,114.99 191.3,114.4 v2(191.3,113.55)
  BOTTOM w0.089: UG2.M13 v2(190.74,137.98)
  BOTTOM w0.17: v2(191.3,113.55) UG9.AN49
FBA_D56: length 39.6
  IN1 w0.089: v2(192.6,109.45) 192,110.05 192,112.39 192.1,112.49 192.1,114.5
  IN1 w0.145: 192.1,114.5 192.08,114.52 192.08,114.72 191.47,115.33 191.47,119.72 188.73,122.46 188.73,134.36 187.95,135.14 187.95,136 186.51,137.44 186.51,140.77 184.74,142.54 183.3,142.54 v2(182.74,141.98)
  BOTTOM w0.089: UG2.U4 183.14,142.38 v2(182.74,141.98)
  BOTTOM w0.17: UG9.AM44 v2(192.6,109.45)
FBA_D57: length 41.4
  IN1 w0.089: 192.32,114.95 192.32,112.41 192.22,112.31 192.22,111.85 192.32,111.75 192.32,110.43 v2(192.6,110.15)
  IN1 w0.145: v2(181.14,141.98) UG2.U2 182.19,142.38 182.79,142.98 185.2,142.98 187.09,141.08 187.09,137.71 188.64,136.16 188.64,135.38 189.53,134.49 189.53,124.2 191.91,121.82 191.91,115.59 192.32,115.19 192.32,114.95
  BOTTOM w0.089: UG2.U2 181.54,142.38 v2(181.14,141.98)
  BOTTOM w0.178: UG9.AM45 v2(192.6,110.15)
FBA_D58: length 36.9
  IN1 w0.089: v2(191.3,110.15) 191.7,110.55 191.7,111.51 191.78,111.59 191.78,112.47 191.88,112.58 191.88,114.28
  IN1 w0.145: v2(183.54,141.98) 184.4,141.12 185.1,141.12 185.94,140.28 185.94,136.45 187.85,134.54 187.85,122.31 191.09,119.07 191.09,115.07 191.88,114.28
  BOTTOM w0.089: UG2.T4 183.14,141.58 v2(183.54,141.98)
  BOTTOM w0.17: v2(191.3,110.15) UG9.AN45
FBA_D59: length 39.7
  IN1 w0.089: v2(191.3,110.85) 190.98,110.53 189.52,110.53 189.46,110.47 188.17,110.47
  IN1 w0.145: v2(181.14,141.18) 180.74,140.77 180.74,136.68 181.43,135.98 183.15,135.98 183.4,135.72 183.4,134.71 183.97,134.14 183.97,129.25 183.66,128.93 183.66,121.44 186.22,118.87 186.22,118.35 188.28,116.29 188.28,113.54 187.98,113.24 187.98,110.66 188.17,110.47
  BOTTOM w0.089: UG2.T2 181.54,141.58 v2(181.14,141.18)
  BOTTOM w0.17: v2(191.3,110.85) UG9.AN46
FBA_D60: length 31.5
  IN1 w0.145: v2(190.5,112.85) 190.5,113.26 190.31,113.45 190.31,114.83 189.94,115.2 189.94,115.97 189.75,116.16 189.75,118.35 185.92,122.18 185.92,128.85 186.45,129.37 186.45,134.26 184.87,135.85 184.87,138.19 184.69,138.38 183.14,138.38 v2(182.74,138.78)
  BOTTOM w0.089: UG2.N4 183.14,139.18 v2(182.74,138.78)
  BOTTOM w0.17: v2(190.5,112.85) UG9.AR48
FBA_D61: length 34.7
  IN1 w0.089: 191.33,114.1 191.68,113.75 191.68,112.66 191.58,112.56 191.58,111.83 v2(191.3,111.55)
  IN1 w0.145: 191.33,114.1 191.33,114.36 190.77,114.92 190.77,118.35 186.83,122.29 186.83,134.58 185.38,136.03 185.38,138.51 184.71,139.18 182.22,139.18 181.94,138.9 v2(181.94,138.78)
  BOTTOM w0.089: UG2.N2 v2(181.94,138.78)
  BOTTOM w0.17: v2(191.3,111.55) UG9.AN47
FBA_D62: length 30.2
  IN1 w0.145: v2(183.54,137.98) 184.3,137.22 184.3,135.71 185.69,134.33 185.69,129.37 185.18,128.87 185.18,121.95 187.44,119.69 187.44,118.82 189.18,117.08 189.18,116.55 189.07,116.44 189.07,115.5 189.97,114.6 189.97,112.68 v2(190.5,112.15)
  BOTTOM w0.089: UG2.M4 v2(183.54,137.98)
  BOTTOM w0.17: v2(190.5,112.15) UG9.AR47
FBA_D63: length 32.3
  IN1 w0.145: v2(190.5,111.45) 190.05,111.45 189.62,111.88 189.62,114.39 188.67,115.34 188.67,116.69 186.79,118.57 186.79,119.32 184.42,121.69 184.42,134.14 183.72,134.83 183.72,136.3 183.24,136.78 182.09,136.78 181.14,137.73 v2(181.14,137.98)
  BOTTOM w0.089: UG2.M2 181.54,138.38 v2(181.14,137.98)
  BOTTOM w0.17: UG9.AR46 v2(190.5,111.45)
FBA_DBI0: length 24.5
  IN2 w0.145: v2(209.41,131.58) 209.01,131.98 208.4,131.98 208.21,131.79 208.21,128.82 204.57,125.18 204.57,122.64 202.96,121.03 202.96,115.02 202.75,114.81 202.75,112.45 203.05,112.15 v2(203.1,112.15)
  BOTTOM w0.089: UG1.P2 209.01,131.98 v2(209.41,131.58)
  BOTTOM w0.178: UG9.U47 v2(203.1,112.15)
FBA_DBI1: length 20.7
  IN2 w0.102: 200.99,127.91 200.99,131.2 v2(200.61,131.58)
  IN2 w0.145: v2(201.19,113.74) 201.07,113.86 201.07,115.31 200.17,116.21 200.17,126.77 200.99,127.6 200.99,127.91
  BOTTOM w0.089: UG1.P13 v2(200.61,131.58)
  BOTTOM w0.102: UG9.Y48 200.7,112.79 201.03,113.12 201.03,113.58 v2(201.19,113.74)
FBA_DBI2: length 34.3
  IN2 w0.145: v2(199.85,140.36) 199.43,140.78 196.9,140.78 195.09,138.96 195.09,126.71 194.64,126.26 194.64,121.15 195.2,120.59 195.2,115.02 195.9,114.32 195.9,112.55 v2(195.5,112.15)
  BOTTOM w0.089: v2(199.85,140.36) 200.21,140 UG1.D13
  BOTTOM w0.17: UG9.AG47 v2(195.5,112.15)
FBA_DBI3: length 38.9
  IN2 w0.145: v2(209.41,140.38) 209.01,139.97 209.01,137.77 208.82,137.58 207.42,137.58 206.61,136.77 200.38,136.77 199.98,136.36 199.02,136.36 197.76,135.1 197.76,122.12 198.07,121.82 198.07,115.28 199,114.35 v2(199,113.65)
  BOTTOM w0.089: v2(209.41,140.38) 209.01,139.98 UG1.D2
  BOTTOM w0.102: v2(199,113.65) 198.93,113.58 198.93,113.12 198.6,112.79 UG9.AC48
FBA_DBI4: length 23.9
  IN2 w0.145: v2(185.6,114.95) 185.31,114.66 183.01,114.66 178.77,118.9 178.77,130.01 179.94,131.18 180.82,131.18 181.14,131.5 v2(181.14,131.58)
  BOTTOM w0.089: v2(181.14,131.58) 181.54,131.98 UG2.D2
  BOTTOM w0.178: UG9.BB51 v2(185.6,114.95)
FBA_DBI5: length 26.7
  IN2 w0.145: v2(190.74,131.64) 190.27,131.17 187.3,131.17 185.56,129.44 185.56,126.71 184.42,125.56 184.42,117.99 v2(184.05,117.62)
  BOTTOM w0.089: v2(190.74,131.64) 190.41,131.98 UG2.D13
  BOTTOM w0.102: UG9.AV50 188.42,114.27 188.42,114.77 188.61,114.96 188.61,115.62 187.3,116.93
  BOTTOM w0.178: 187.3,116.93 184.22,116.93 184.05,117.1 v2(184.05,117.62)
FBA_DBI6: length 31.7
  IN2 w0.145: v2(192.7,113.65) 192.36,113.99 192.36,119.56 192.48,119.68 192.48,126.52 193.69,127.72 193.69,139.53 193.24,139.98 191.14,139.98 v2(190.74,140.38)
  BOTTOM w0.089: UG2.P13 v2(190.74,140.38)
  BOTTOM w0.102: v2(192.7,113.65) 192.65,113.6 192.65,113.12 192.3,112.77 UG9.AM48
FBA_DBI7: length 36.4
  IN2 w0.145: v2(189.19,118.01) 189.19,118.66 188.41,119.44 188.41,123.17 188.4,123.18 188.4,125.73 191.15,128.48 191.15,134.2 190.96,134.39 190.91,134.39 190.9,134.39 188.3,134.39 185.24,137.44 185.24,138.58 184.66,139.17 181.55,139.17 v2(181.14,139.58)
  BOTTOM w0.089: v2(181.14,139.58) 181.54,139.98 UG2.P2 ; 189.56,116.42 189.56,116.61 ; 189.85,115.48 189.92,115.55
  BOTTOM w0.102: 189.56,116.42 189.92,116.06 189.92,115.55 ; 189.85,115.48 189.85,113.6 UG9.AR49
  BOTTOM w0.178: 189.56,116.61 189.56,116.73 189.19,117.11 v2(189.19,118.01)
FBA_EDC0: length 22.5
  IN2 w0.145: v2(208.61,131.58) 209.02,131.17 209.02,128.46 205.44,124.88 205.44,122.47 203.72,120.75 203.72,114.73 204.3,114.15 204.3,113.25 v2(203.9,112.85)
  BOTTOM w0.089: UG1.R2 209.01,131.18 v2(208.61,131.58)
  BOTTOM w0.17: v2(203.9,112.85) UG9.R48
FBA_EDC1: length 20.6
  IN2 w0.102: 200.15,127.91 200.23,127.99 200.23,130.4 v2(200.61,130.78)
  IN2 w0.145: v2(201.79,112.85) 201.77,112.85 201.4,113.22 200.95,113.22 200.54,113.63 200.54,114.33 199.47,115.4 199.47,127.23 200.15,127.91
  BOTTOM w0.089: UG1.R13 v2(200.61,130.78)
  BOTTOM w0.178: UG9.V48 202.08,112.55 v2(201.79,112.85)
FBA_EDC2: length 36
  IN2 w0.145: v2(200.61,140.38) 200.61,140.26 200.32,139.97 197.17,139.97 195.78,138.58 195.78,126.34 195.45,126.01 195.45,121.99 196.48,120.96 196.48,114.68 196.36,114.56 196.36,110.49 v2(196.8,110.05)
  BOTTOM w0.089: v2(200.61,140.38) 200.21,140.78 UG1.C13
  BOTTOM w0.102: UG9.AF44 v2(196.8,110.05)
FBA_EDC3: length 41.3
  IN2 w0.145: v2(208.61,140.38) 209.01,140.77 209.59,140.77 209.82,140.55 209.82,137.25 209.35,136.78 207.32,136.78 206.86,136.32 202.47,136.32 202.13,135.98 199.34,135.98 198.32,134.95 198.32,122.65 198.77,122.2 198.77,115.53 200.09,114.21 200.09,113.3 v2(199.65,112.86)
  BOTTOM w0.089: UG1.C2 v2(208.61,140.38)
  BOTTOM w0.178: v2(199.65,112.86) 199.96,112.55 UG9.AA48
FBA_EDC4: length 20
  IN2 w0.145: v2(181.94,130.78) 181.55,130.38 181.55,129.74 180.93,129.12 180.93,127.85 180.16,127.09 180.16,118.86 183.66,115.36 184.33,115.36 v2(184.5,115.53)
  BOTTOM w0.089: UG2.C2 v2(181.94,130.78)
  BOTTOM w0.102: UG9.BB52 185.18,115.47 184.56,115.47 v2(184.5,115.53)
FBA_EDC5: length 23.3
  IN2 w0.145: v2(185.2,117.83) 186.4,119.03 186.4,128.88 187.9,130.38 189.54,130.38 v2(189.94,130.78)
  BOTTOM w0.089: UG2.C13 v2(189.94,130.78)
  BOTTOM w0.102: 189.15,114.85 189.15,114.45 189.5,114.1 UG9.AT50
  BOTTOM w0.178: v2(185.2,117.83) 185.53,117.5 187.59,117.5 188.93,116.17 188.93,115.07 189.15,114.85
FBA_EDC6: length 33.6
  IN2 w0.145: v2(189.94,141.18) 190.35,140.77 193.73,140.77 194.39,140.11 194.39,127.34 193.7,126.66 193.7,113.2 193.39,112.89 193.36,112.89 v2(193.36,112.88)
  BOTTOM w0.089: UG2.R13 190.34,140.78 v2(189.94,141.18)
  BOTTOM w0.178: UG9.AK48 193.69,112.55 v2(193.36,112.88)
FBA_EDC7: length 36.2
  IN2 w0.145: v2(181.94,140.38) 181.99,140.38 182.39,139.98 184.67,139.98 185.75,138.9 185.75,137.44 186.61,136.58 187.75,136.58 188.36,135.98 191.01,135.98 191.93,135.06 191.93,134.48 191.78,134.33 191.78,133.25 192.1,132.93 192.1,128.37 189.17,125.44 189.17,119.48 189.81,118.84 189.81,117.31 190.1,117.02 v2(190.21,117.02)
  BOTTOM w0.089: UG2.R2 v2(181.94,140.38)
  BOTTOM w0.142: v2(190.21,117.02) 190.56,116.67 190.56,116.13 190.54,116.11 190.54,115.17 190.2,114.84 UG9.AR51
FBA_WCK01: length 26.8
  IN2 w0.119: v2(207.81,131.58) 207.39,131.17 206.82,131.17 205.37,129.72 205.37,127.92 201.25,123.8 201.25,116.43 202.42,115.26 202.42,110.13 202.59,109.97 202.92,109.97 v2(203.1,110.15)
  BOTTOM w0.089: UG1.P4 207.41,131.97 v2(207.81,131.58)
  BOTTOM w0.119: UG9.U45 v2(203.1,110.15)
FBA_WCK01#: length 26.8
  IN2 w0.119: v2(207.01,131.58) 206.93,131.58 205.16,129.81 205.16,128 201.04,123.88 201.04,116.34 202.21,115.18 202.21,110.05 202.5,109.76 202.97,109.76 203.1,109.63 v2(203.1,109.45)
  BOTTOM w0.089: v2(207.01,131.58) 206.61,131.98 UG1.P5
  BOTTOM w0.119: UG9.U44 v2(203.1,109.45)
FBA_WCK23: length 39.5
  IN2 w0.119: v2(198.9,110.15) 198.74,109.99 198.54,109.99 198.39,110.15 198.39,114.24 197.32,115.31 197.32,121.41 197.03,121.7 197.03,135.99 198.35,137.31 203.78,137.31 205.65,139.18 206.61,139.18 v2(207.01,139.58)
  BOTTOM w0.089: UG1.D4 v2(207.01,139.58)
  BOTTOM w0.119: UG9.AC45 v2(198.9,110.15)
FBA_WCK23#: length 39.5
  IN2 w0.119: v2(198.9,109.45) 198.9,109.66 198.77,109.79 198.46,109.79 198.18,110.06 198.18,114.15 197.11,115.23 197.11,121.32 196.82,121.61 196.82,136.08 198.26,137.52 203.69,137.52 205.56,139.39 206.02,139.39 v2(206.21,139.58)
  BOTTOM w0.089: UG1.D5 v2(206.21,139.58)
  BOTTOM w0.119: UG9.AC44 v2(198.9,109.45)
FBA_WCK45: length 28.8
  IN2 w0.119: v2(188.4,111.55) 188.28,111.43 188.07,111.43 187.79,111.71 187.79,116.02 187.29,116.51 184.24,116.51 183.6,117.15 183.6,117.94 183.26,118.28 183.26,128.77 184.51,130.02 184.51,132.52 184.12,132.92 183.39,132.92 182.84,132.36 v2(182.84,132.36)
  BOTTOM w0.089: UG2.D4 182.84,132.28 v2(182.84,132.36)
  BOTTOM w0.119: UG9.AV47 v2(188.4,111.55)
FBA_WCK45#: length 28.9
  IN2 w0.119: v2(188.41,110.84) 188.41,110.84 188.41,111.03 188.22,111.22 187.98,111.22 187.58,111.62 187.58,115.93 187.2,116.31 184.15,116.31 183.39,117.06 183.39,117.85 183.05,118.19 183.05,128.85 184.3,130.11 184.3,132.43 184.03,132.71 183.48,132.71 183.37,132.6 183.37,132.44 v2(183.54,132.26)
  BOTTOM w0.089: v2(183.54,132.26) 183.54,132.1 183.67,131.98 UG2.D5
  BOTTOM w0.119: v2(188.41,110.84) 188.41,111.02 188.28,111.15 UG9.AV46
FBA_WCK67: length 40.6
  IN2 w0.119: v2(190.5,110.15) 190.32,109.97 190.2,109.97 189.97,110.2 189.97,114.5 191.12,115.65 191.12,126.24 192.97,128.09 192.97,134.94 190.6,137.31 187.67,137.31 186.92,138.07 186.92,138.89 184.62,141.19 184.2,141.19 183.89,140.9 183.87,140.66 v2(183.6,140.43)
  BOTTOM w0.089: v2(183.6,140.43) 183.15,139.98 UG2.P4
  BOTTOM w0.119: UG9.AR45 v2(190.5,110.15)
FBA_WCK67#: length 40.6
  IN2 w0.119: v2(190.5,109.45) 190.5,109.63 190.37,109.76 190.11,109.76 189.77,110.11 189.77,114.59 190.92,115.74 190.92,126.35 192.76,128.19 192.76,134.85 190.51,137.1 187.59,137.1 186.71,137.98 186.71,138.8 184.53,140.98 184.28,140.98 184.09,140.81 184.08,140.66 v2(184.33,140.37)
  BOTTOM w0.089: v2(184.33,140.37) 184.07,140.37 183.94,140.24 UG2.P5
  BOTTOM w0.119: UG9.AR44 190.37,109.75 190.5,109.62 v2(190.5,109.45)
FBB_CLK0: length 42.1
  TOP w0.119: v2(235.22,120.74) 235.22,120.8 235.38,120.96 235.38,121.47 RG113.1
  IN5 w0.114: 216.17,111.34 213.69,108.87 213.69,108.86 213.67,108.85 212.85,108.03 209.42,108.03 v2(208.8,108.65)
  IN5 w0.119: 216.17,111.34 224.86,120.04 227.22,120.04 227.53,120.35 227.53,121.44 227.66,121.56 228.24,121.56 228.36,121.44 228.36,120.28 228.6,120.04 229.13,120.04 229.37,120.28 229.37,121.44 229.49,121.56 235.22,121.56 235.35,121.44 235.35,120.86 v2(235.22,120.74) 235.35,120.61 235.35,119.66 236.49,118.52 236.49,118.18 v2(236.28,117.97)
  BOTTOM w0.119: UG9.H42 v2(208.8,108.65) ; UG3.J12 236.68,118.37 v2(236.28,117.97)
FBB_CLK0#: length 42.1
  TOP w0.119: RG525.1 235.59,121.42 235.59,120.96 v2(235.81,120.74)
  IN5 w0.114: v2(209.5,108.65) 209.5,108.36 209.63,108.23 212.77,108.23 213.49,108.95 213.49,108.95 215.96,111.42 215.96,111.43 216,111.47 216,111.47 216.02,111.49
  IN5 w0.119: v2(237.08,117.97) 236.7,118.35 236.7,118.6 235.55,119.74 235.55,120.49 v2(235.81,120.74) 235.55,120.99 235.55,121.52 235.3,121.77 229.41,121.77 229.16,121.53 229.16,120.37 229.05,120.25 228.69,120.25 228.57,120.37 228.57,121.53 228.33,121.77 227.58,121.77 227.33,121.52 227.33,120.44 227.14,120.25 224.78,120.25 216.02,111.49
  BOTTOM w0.119: UG9.G42 v2(209.5,108.65) ; UG3.J11 v2(237.08,117.97)
FBB_CLK1: length 40.7
  IN1 w0.119: 227.56,133.36 227.94,133.74 228.21,133.74 228.34,133.61 228.34,129.4 227.51,128.57 225.04,128.57 224.15,127.68 224.15,125.84 214.89,116.58 214.89,114.98 214.9,114.98 214.9,113.5 213.69,112.29 212.25,112.29 211.76,111.8 211.31,111.8 211.06,111.55 v2(210.8,111.55) ; 227.56,133.36 227.56,133.43 227.26,133.74 227.09,133.74 226.84,133.99 226.84,135.53 226.41,135.96 225.21,135.96 225.1,135.85 224.74,135.85 224.61,135.73 224.61,135.46 v2(224.61,135.46) ; 227.56,133.36 v2(227.56,133.28)
  BOTTOM w0.089: v2(224.61,135.46) 224.37,135.46 224.21,135.62 UG4.J12
  BOTTOM w0.119: UG9.F47 v2(210.8,111.55) ; RG114.1 228.16,133.45 227.73,133.45 v2(227.56,133.28)
FBB_CLK1#: length 40.9
  IN1 w0.119: v2(223.81,135.58) 224.3,136.06 225.02,136.06 225.12,136.17 226.5,136.17 227.04,135.62 227.04,134.07 227.17,133.95 v2(227.6,133.95) 228.3,133.95 228.55,133.69 228.55,129.31 227.6,128.36 225.12,128.36 224.36,127.6 224.36,125.75 215.1,116.49 215.1,115.18 215.11,115.18 215.11,113.41 213.78,112.08 212.33,112.08 211.85,111.6 211.64,111.6 v2(211.47,111.43)
  BOTTOM w0.089: v2(223.81,135.58) 223.41,135.98 UG4.J11
  BOTTOM w0.119: v2(211.47,111.43) 211.2,111.69 UG9.E47 ; RG526.1 228,133.65 227.89,133.65 v2(227.6,133.95)
FBB_CMD0: length 30
  BOTTOM w0.089: 238.28,111.16 UG3.G3
  BOTTOM w0.142: UG9.B35 213.45,103.45 213.8,103.1 218.02,103.1 218.15,102.98 221.12,102.98 ; 237.37,108.38 237.42,108.42 237.67,108.42 238.05,108.79 238.05,109.27 237.9,109.42 237.9,110.78 238.28,111.16
  BOTTOM w0.178: 237.37,108.38 236.12,107.12 227.01,107.12 222.87,102.98 221.12,102.98
FBB_CMD1: length 28.8
  TOP w0.089: RG49.2 237.08,110.04 v2(237.08,110.77)
  BOTTOM w0.142: 236.6,108.34 237.08,108.82 v2(237.08,110.77) UG3.J3 ; 218.22,103.4 218.17,103.45 UG9.A35
  BOTTOM w0.178: 218.22,103.4 222.48,103.4 226.72,107.64 235.9,107.64 236.6,108.34
FBB_CMD2: length 29.1
  TOP w0.089: 235.66,109.86 235.77,109.97 v2(236.28,109.97)
  TOP w0.178: RG56.1 235.66,109.86
  BOTTOM w0.142: UG9.D35 212.25,103.8 222.09,103.8 ; UG3.J2 236.68,110.37 v2(236.28,109.97) 236.28,108.91 235.75,108.38
  BOTTOM w0.178: 235.75,108.38 235.54,108.16 226.46,108.16 222.09,103.8
FBB_CMD3: length 25.9
  BOTTOM w0.142: UG3.L3 235.43,110.81 235.43,109.36 235.03,108.95 235.03,108.86 ; UG9.A36 221.61,104.15
  BOTTOM w0.178: 221.61,104.15 226.44,108.98 229.45,108.98 229.76,108.67 234.84,108.67 235.03,108.86
FBB_CMD4: length 26.4
  BOTTOM w0.089: 235.87,112.77 UG3.K5
  BOTTOM w0.142: 235.87,112.77 235.52,113.12 230.14,113.12 229.24,112.22 ; UG9.B36 213.5,104.15 213.85,104.5 220.38,104.5
  BOTTOM w0.178: 229.24,112.22 227.58,110.56 227.11,110.56 221.05,104.5 220.38,104.5
FBB_CMD5: length 28.9
  BOTTOM w0.089: 229.15,112.67 229.19,112.67
  BOTTOM w0.102: UG9.C36 212.83,104.15 213.18,104.5 213.5,104.5
  BOTTOM w0.142: 229.19,112.67 229.91,113.4 235.96,113.4 236.3,113.05 236.3,112.55 235.88,112.13 UG3.K4 ; 220.6,104.89 216.48,104.89 216.32,104.73 213.73,104.73 213.5,104.5
  BOTTOM w0.178: 229.15,112.67 228.39,112.67 220.6,104.89
FBB_CMD6: length 28.5
  BOTTOM w0.142: UG3.J5 236.68,113.18 236.18,113.68 229.64,113.68 229.15,113.19 ; 220.5,105.54 220.28,105.31 216.48,105.31 216.14,104.97 213.68,104.97 213.45,105.2 212.95,105.2 UG9.C38
  BOTTOM w0.178: 229.15,113.19 228.16,113.19 220.5,105.54
FBB_CMD7: length 29.3
  BOTTOM w0.142: 229.99,113.97 230,113.96 236.35,113.96 237.12,113.18 237.12,112.42 236.68,111.97 UG3.J4 ; UG9.B38 213.45,105.55 213.79,105.21 215.97,105.21 216.42,105.66 219.89,105.66 220.07,105.84
  BOTTOM w0.178: 220.07,105.84 227.94,113.71 229.21,113.71 229.47,113.97 229.99,113.97
FBB_CMD8: length 28
  BOTTOM w0.142: UG3.H5 237.48,113.27 236.47,114.28 230.39,114.28 ; UG9.A38 215.83,105.55 216.31,106.03 219.52,106.03 219.75,106.26
  BOTTOM w0.178: 230.39,114.28 227.77,114.28 219.75,106.26
FBB_CMD9: length 32
  BOTTOM w0.142: 219.39,106.64 219.12,106.37 216.07,106.37 215.6,105.9 212.25,105.9 UG9.D38 ; 228.68,114.8 228.9,114.58 236.74,114.58 237.89,113.44 237.89,112.42 237.48,112.01 UG3.H4
  BOTTOM w0.178: 228.68,114.8 227.55,114.8 219.39,106.64
FBB_CMD10: length 31
  BOTTOM w0.142: UG9.A39 215.5,106.25 216.01,106.76 218.78,106.76 219.03,107.01 ; 228.57,115.32 229.03,114.86 237.09,114.86 237.89,115.66 237.89,117.88 238.28,118.27 UG3.G12
  BOTTOM w0.178: 219.03,107.01 227.33,115.32 228.57,115.32
FBB_CMD11: length 29.6
  BOTTOM w0.142: 219.08,107.8 218.47,107.19 217.68,107.19 217.55,107.06 215.68,107.06 215.21,106.6 213.85,106.6 213.5,106.25 UG9.B39 ; UG3.H10 237.48,115.89 236.74,115.15 229.31,115.15 228.63,115.84
  BOTTOM w0.178: 228.63,115.84 227.12,115.84 219.08,107.8
FBB_CMD12: length 31.1
  BOTTOM w0.142: UG3.H11 237.48,117.47 237.12,117.12 237.12,115.98 236.59,115.44 229.59,115.44 228.68,116.36 ; 218.75,108.23 218.06,107.54 217.6,107.54 217.49,107.43 215.28,107.43 214.69,106.85 213.75,106.85 213.5,106.6 213.13,106.6 212.78,106.25 UG9.C39
  BOTTOM w0.178: 228.68,116.36 226.88,116.36 218.75,108.23
FBB_CMD13: length 30.1
  BOTTOM w0.142: UG3.K11 235.88,117.54 236.3,117.12 236.3,116.42 235.6,115.72 229.82,115.72 228.66,116.88 ; UG9.C41 212.95,107.3 213.45,107.3 213.67,107.08 214.44,107.08 215.06,107.7 217.25,107.7 217.5,107.95 217.64,107.95 217.97,108.28
  BOTTOM w0.178: 228.66,116.88 226.57,116.88 217.97,108.28
FBB_CMD14: length 28.5
  BOTTOM w0.142: 228.65,117.4 230.01,116.04 235.54,116.04 235.88,116.38 UG3.K10 ; UG9.B41 213.51,107.65 213.85,107.31 214.21,107.31 214.91,108.01 217.15,108.01 217.62,108.48
  BOTTOM w0.178: 228.65,117.4 225.68,117.4 223.19,114.91 223.19,114.06 217.62,108.48
FBB_CMD15: length 29.1
  BOTTOM w0.142: UG9.A41 214.6,108.25 216.85,108.25 216.9,108.3 ; UG3.L12 235.08,118.15 235.54,117.69 235.54,116.72 235.18,116.36 230.2,116.36 228.82,117.74
  BOTTOM w0.178: 228.82,117.74 228.64,117.92 225.43,117.92 222.63,115.12 222.63,114.03 216.9,108.3
FBB_CMD16: length 30
  BOTTOM w0.142: 214.86,115.44 214.86,113.72 214.59,113.45 214.35,113.45 214.2,113.6 213.65,113.6 UG9.B49 ; 214.54,137.22 216.66,137.22 UG4.L3
  BOTTOM w0.178: 214.86,115.44 213.04,117.26 213.04,136.82 213.45,137.22 214.54,137.22
FBB_CMD17: length 31.2
  TOP w0.178: v2(216.61,136.38) 215.74,137.25 214.25,137.25 RG50.2
  BOTTOM w0.089: UG4.J3 217.01,135.98
  BOTTOM w0.142: 217.01,135.98 v2(216.61,136.38) 214.49,136.38 ; UG9.A49 214.25,113 214.69,113 215.2,113.51 215.2,115.16
  BOTTOM w0.178: 214.49,136.38 214.28,136.38 213.56,135.66 213.56,117.47 215.2,115.84 215.2,115.16
FBB_CMD18: length 28.9
  TOP w0.178: v2(215.81,135.58) 215.71,135.47 214.71,135.47 214.33,135.09 214.33,134.97 RG55.1
  BOTTOM w0.142: UG9.A48 214.15,112.7 214.83,112.7 215.48,113.35 ; UG4.J2 v2(215.81,135.58) 215.77,135.53 214.54,135.53 214.53,135.54
  BOTTOM w0.178: 215.48,113.35 215.48,116.29 214.09,117.69 214.09,135.27 214.35,135.54 214.53,135.54
FBB_CMD19: length 28.9
  BOTTOM w0.142: 214.81,112.2 212.25,112.2 UG9.D47 ; UG4.G3 217.01,134.5 216.71,134.8 215.24,134.8 214.61,134.16
  BOTTOM w0.178: 214.81,112.2 215.88,113.27 215.88,117.84 214.61,119.11 214.61,134.16
FBB_CMD20: length 26.7
  BOTTOM w0.142: UG9.A47 214.98,111.85 ; UG4.H5 218.61,134.93 219.04,134.5 219.04,129.48 218.28,128.71 217.44,128.71 217.04,128.32
  BOTTOM w0.178: 214.98,111.85 216.21,113.08 216.21,127.48 217.04,128.32
FBB_CMD21: length 29.5
  BOTTOM w0.142: UG9.B47 213.45,111.85 213.79,111.51 215.07,111.51 ; UG4.H4 217.81,135.29 218.07,135.55 218.89,135.55 219.32,135.11 219.32,129.36 218.35,128.4 217.86,128.4 217.56,128.1
  BOTTOM w0.178: 217.56,128.1 216.73,127.27 216.73,113.17 215.07,111.51
FBB_CMD22: length 30.1
  BOTTOM w0.142: 215.2,111.26 215.14,111.2 214.63,111.2 214.54,111.28 213.67,111.28 213.45,111.5 212.95,111.5 UG9.C47 ; 218.28,128.08 218.44,128.08 219.6,129.25 219.6,135.34 218.96,135.98 UG4.J5
  BOTTOM w0.178: 215.2,111.26 217.25,113.31 217.25,127.05 218.28,128.08
FBB_CMD23: length 32.1
  BOTTOM w0.142: 218.82,128.07 219.88,129.12 219.88,135.52 219.01,136.38 218.22,136.38 UG4.J4 ; 215.38,111.02 215.29,110.93 214.56,110.93 214.45,111.04 213.74,111.04 213.5,110.8 213.1,110.8 212.75,110.45 UG9.C45
  BOTTOM w0.178: 215.38,111.02 217.77,113.41 217.77,126.83 218.68,127.74 218.68,127.92 218.82,128.07
FBB_CMD24: length 31.4
  BOTTOM w0.142: UG9.B45 213.5,110.45 213.85,110.8 214.34,110.8 214.45,110.69 215.56,110.69 215.67,110.8 ; UG4.K5 219.11,136.78 220.16,135.74 220.16,128.97 219.2,128.01
  BOTTOM w0.178: 215.67,110.8 218.29,113.42 218.29,126.62 219.2,127.53 219.2,128.01
FBB_CMD25: length 32.9
  BOTTOM w0.089: 217.81,136.8 UG4.K4
  BOTTOM w0.142: 217.81,136.8 218.2,137.18 219.79,137.18 220.44,136.54 220.44,128.81 219.72,128.1 ; UG9.A45 215.76,110.45
  BOTTOM w0.178: 219.72,128.1 219.72,127.31 218.81,126.4 218.81,113.5 215.76,110.45
FBB_CMD26: length 36.5
  BOTTOM w0.142: 215.88,110.1 212.25,110.1 UG9.D44 ; 220.24,128.14 220.72,128.61 220.72,136.56 221.34,137.18 223.85,137.18 224.21,137.55 UG4.L12
  BOTTOM w0.178: 220.24,128.14 220.24,127.09 219.33,126.19 219.33,113.55 215.88,110.1
FBB_CMD27: length 32.5
  BOTTOM w0.142: 220.76,128.22 221.01,128.47 221.01,136.41 221.38,136.78 UG4.K10 ; 217.44,111.11 216.07,109.75 UG9.A44
  BOTTOM w0.178: 217.44,111.11 219.85,113.53 219.85,125.97 220.76,126.88 220.76,128.22
FBB_CMD28: length 34.4
  BOTTOM w0.142: 216.25,109.45 214.66,109.45 214.62,109.41 213.79,109.41 213.45,109.75 UG9.B44 ; 221.28,128.32 221.28,136.26 221.44,136.42 223.06,136.42 UG4.K11
  BOTTOM w0.178: 221.28,128.32 221.28,126.66 220.37,125.75 220.37,113.57 216.25,109.45
FBB_CMD29: length 34.5
  BOTTOM w0.142: 221.8,128.32 221.8,128.82 221.6,129.02 221.6,135.32 221.82,135.53 223.06,135.53 UG4.H11 ; UG9.C44 212.95,109.4 213.45,109.4 213.68,109.17 216.37,109.17
  BOTTOM w0.178: 216.37,109.17 220.89,113.69 220.89,125.54 221.8,126.45 221.8,128.32
FBB_CMD30: length 33.6
  BOTTOM w0.142: 216.54,108.9 214.55,108.9 214.52,108.93 213.73,108.93 213.5,108.7 213.15,108.7 212.8,108.35 UG9.C42 ; UG4.H10 222.19,135.18 221.88,134.87 221.88,129.13 222.32,128.69 222.32,128.39
  BOTTOM w0.178: 216.54,108.9 221.41,113.77 221.41,125.23 222.32,126.14 222.32,128.39
FBB_CMD31: length 34.6
  BOTTOM w0.142: UG4.G12 223.83,134.76 222.51,134.76 222.16,134.42 222.16,129.48 222.84,128.8 222.84,128.32 ; 216.64,108.57 214.33,108.57 214.22,108.69 213.84,108.69 213.5,108.35 UG9.B42
  BOTTOM w0.178: 222.84,128.32 222.84,125.65 222,124.81 222,113.93 219.58,111.51 216.64,108.57
FBB_D0: length 27.1
  IN5 w0.145: v2(229.73,112.02) 229.46,112.29 221.38,112.29 213.31,104.23 213.31,102.58 212.7,101.97 212.37,101.97 212.36,101.96 212.04,101.96 212.03,101.97 210.32,101.97 v2(209.4,101.05)
  BOTTOM w0.089: UG3.U4 229.78,111.97 v2(229.73,112.02)
  BOTTOM w0.178: UG9.H32 v2(209.4,101.05)
FBB_D1: length 23.8
  IN5 w0.145: v2(229.88,109.97) 229.34,109.43 222.65,109.43 217.44,104.23 217.44,102.07 217.12,101.75 216.07,101.75 216.02,101.7 215.8,101.7 215.55,101.45 v2(215.55,101.3)
  BOTTOM w0.089: UG3.U2 230.28,110.37 v2(229.88,109.97)
  BOTTOM w0.142: v2(215.55,101.3) 215.15,101.7 212.25,101.7 UG9.D32
FBB_D2: length 21.9
  IN5 w0.145: v2(230.68,111.57) 230.27,111.16 229.6,111.16 229.33,110.9 222.07,110.9 214.45,103.27 v2(214.45,102.1)
  BOTTOM w0.089: UG3.T4 v2(230.68,111.57)
  BOTTOM w0.142: UG9.A33 214.4,102.05 v2(214.45,102.1)
FBB_D3: length 23.1
  IN5 w0.145: v2(230.68,109.97) 230.29,110.36 229.72,110.36 229.47,110.11 222.3,110.11 215.44,103.24 215.44,101.84 215,101.41 v2(215,101.3)
  BOTTOM w0.089: UG3.T2 v2(230.68,109.97)
  BOTTOM w0.142: UG9.B32 213.52,101.35 213.97,100.9 214.61,100.9 v2(215,101.3)
FBB_D4: length 32.4
  IN5 w0.145: v2(212.35,100.91) 212.39,100.95 213.12,100.95 213.73,100.33 220.05,100.33 221.63,101.91 221.63,105.12 224.07,107.56 232.94,107.56 234.27,108.88 234.27,111.18 v2(233.88,111.57)
  BOTTOM w0.089: UG3.N4 233.48,111.97 v2(233.88,111.57)
  BOTTOM w0.1: UG9.E32 211.4,101.35 211.76,100.99 212.27,100.99 v2(212.35,100.91)
FBB_D5: length 30.9
  IN5 w0.145: v2(210.11,100.97) 210.75,101.61 213.2,101.61 213.88,102.29 213.88,103.72 221.76,111.59 230,111.59 230.37,111.97 232.12,111.97 232.67,111.41 232.67,110.37 v2(233.08,109.97)
  BOTTOM w0.089: UG3.N2 v2(233.08,109.97)
  BOTTOM w0.178: UG9.G32 209.8,101.28 v2(210.11,100.97)
FBB_D6: length 36.6
  IN5 w0.145: v2(234.68,111.57) 235.07,111.18 235.07,108.76 233.21,106.91 224.43,106.91 222.39,104.86 222.39,101.95 220.31,99.87 213.18,99.87 213.02,99.71 208.64,99.71 v2(208.1,100.25)
  BOTTOM w0.089: UG3.M4 234.28,111.97 v2(234.68,111.57)
  BOTTOM w0.178: UG9.J30 v2(208.1,100.25)
FBB_D7: length 30.6
  IN5 w0.145: v2(233.88,109.97) 233.48,109.57 233.48,109.02 232.67,108.21 223.77,108.21 220.93,105.37 220.93,101.8 219.93,100.8 213.98,100.8 213.47,101.3 211.05,101.3 v2(210.8,101.05)
  BOTTOM w0.089: v2(233.88,109.97) 234.28,110.37 UG3.M2
  BOTTOM w0.17: UG9.F32 v2(210.8,101.05)
FBB_D8: length 28.7
  IN1 w0.145: v2(208.8,103.85) 209.1,103.55 212.91,103.55 214.81,105.45 216.24,105.45 221.35,110.56 222.33,110.56 224.36,112.59 224.36,113.5 228.49,117.63 229.53,117.63 v2(229.88,117.97)
  BOTTOM w0.089: UG3.U11 v2(229.88,117.97)
  BOTTOM w0.178: UG9.H36 v2(208.8,103.85)
FBB_D9: length 28.9
  IN1 w0.1: 209.79,105.7 209.79,104.74
  IN1 w0.129: 209.79,104.74 v2(209.5,104.45)
  IN1 w0.145: v2(229.88,119.57) 229.57,119.88 227.51,119.88 221.69,114.07 221.69,113.33 215.37,107.01 213.56,107.01 212.71,106.16 210.25,106.16 209.79,105.7
  BOTTOM w0.089: UG3.U13 v2(229.88,119.57)
  BOTTOM w0.178: UG9.G36 v2(209.5,104.45)
FBB_D10: length 30.5
  IN1 w0.145: v2(230.68,117.97) 230.29,118.36 228.14,118.36 223.41,113.63 223.41,112.69 222.01,111.29 221.28,111.29 216,106.01 214.76,106.01 212.69,103.94 209.36,103.94 209,104.29 208.26,104.29 v2(208.1,104.45)
  BOTTOM w0.089: UG3.T11 v2(230.68,117.97)
  BOTTOM w0.178: UG9.J36 v2(208.1,104.45)
FBB_D11: length 28.4
  IN1 w0.1: 210.55,105.5 210.55,104.82
  IN1 w0.129: 210.55,104.82 210.2,104.47 v2(210.2,104.45)
  IN1 w0.145: v2(230.68,119.57) 230.28,119.17 227.81,119.17 222.45,113.82 222.45,113.3 221.01,111.86 215.61,106.46 213.6,106.46 212.89,105.75 210.81,105.75 210.55,105.5
  BOTTOM w0.089: UG3.T13 v2(230.68,119.57)
  BOTTOM w0.17: UG9.F36 v2(210.2,104.45)
FBB_D12: length 31.9
  IN1 w0.1: 210.34,102.21 211.18,102.21 211.43,101.96 212.7,101.96
  IN1 w0.129: 210.34,102.21 v2(210.1,102.45)
  IN1 w0.145: v2(233.08,117.97) 233.08,117.77 232.68,117.37 232.68,115.98 231.22,114.51 228.7,114.51 223.37,109.18 221.76,109.18 216.87,104.29 215.03,104.29 212.7,101.96
  BOTTOM w0.089: UG3.N11 v2(233.08,117.97)
  BOTTOM w0.17: UG9.F33 v2(210.1,102.45)
FBB_D13: length 30.6
  IN1 w0.145: v2(233.08,119.57) 232.68,119.17 232.68,117.79 232.45,117.56 232.11,117.56 231.87,117.32 231.87,116.43 230.65,115.21 228.41,115.21 223.08,109.88 221.62,109.88 221.44,109.7 216.61,104.87 214.93,104.87 213.22,103.16 212.5,103.16 212.2,102.86 v2(212.2,102.35)
  BOTTOM w0.089: UG3.N13 v2(233.08,119.57)
  BOTTOM w0.17: UG9.D33 v2(212.2,102.35)
FBB_D14: length 35.9
  IN1 w0.1: 213.16,101.5 211.25,101.5 210.97,101.78 208.83,101.78
  IN1 w0.129: 208.83,101.78 v2(208.1,101.05) ; 214.63,102.97 213.16,101.5
  IN1 w0.145: 214.63,102.97 217.14,102.97 221.95,107.78 223.85,107.78 229.25,113.18 231.79,113.18 234.28,115.67 UG3.M11 v2(233.88,117.97)
  BOTTOM w0.089: UG3.M11 v2(233.88,117.97)
  BOTTOM w0.178: UG9.J32 v2(208.1,101.05)
FBB_D15: length 35
  IN1 w0.1: 212.91,101.75 212.85,101.69 211.39,101.69 211.09,101.99 209.86,101.99 v2(209.5,102.35)
  IN1 w0.145: v2(233.88,119.57) 233.48,119.17 233.48,115.82 231.52,113.86 228.97,113.86 223.59,108.48 221.84,108.48 217.02,103.66 214.82,103.66 212.91,101.75
  BOTTOM w0.089: UG3.M13 v2(233.88,119.57)
  BOTTOM w0.178: UG9.G33 v2(209.5,102.35)
FBB_D16: length 51.1
  IN1 w0.145: v2(211.5,110.75) 212,111.24 212.4,111.24 212.6,111.45 213.78,111.45 215.77,113.43 215.77,116.08 226.88,127.19 240.71,127.19 245.09,122.81 245.09,118.78 v2(243.48,117.17)
  BOTTOM w0.089: v2(243.48,117.17) 243.08,117.57 UG3.A11
  BOTTOM w0.178: v2(211.5,110.75) UG9.E45
FBB_D17: length 47.1
  IN1 w0.145: v2(212.2,110.75) 212.35,110.6 213.65,110.6 216.39,113.34 216.39,115.75 227.18,126.54 240.44,126.54 244.43,122.54 244.43,119.72 v2(243.48,118.77)
  BOTTOM w0.089: UG3.A13 243.08,119.17 v2(243.48,118.77)
  BOTTOM w0.17: UG9.D45 v2(212.2,110.75)
FBB_D18: length 49.5
  IN1 w0.145: v2(242.68,117.17) 243.08,117.57 243.08,119.29 243.78,120 243.78,122.27 240.17,125.89 227.54,125.89 217.06,115.4 217.06,113.39 213.95,110.28 210.67,110.28 v2(210.2,110.75)
  BOTTOM w0.089: UG3.B11 242.28,117.57 v2(242.68,117.17)
  BOTTOM w0.178: v2(210.2,110.75) UG9.F45
FBB_D19: length 46.4
  IN1 w0.145: v2(209.33,110.37) 209.35,110.39 209.75,110.39 210.27,109.87 214.2,109.87 217.76,113.43 217.76,115.15 227.79,125.18 239.95,125.18 243.13,122 243.13,120.02 v2(242.68,119.57)
  BOTTOM w0.089: v2(242.68,119.57) 242.28,119.17 UG3.B13
  BOTTOM w0.178: UG9.G45 209.41,110.45 v2(209.33,110.37)
FBB_D20: length 39.5
  IN1 w0.145: v2(240.28,117.97) 239.88,118.37 239.88,121.44 238.75,122.57 227.21,122.57 219.41,114.77 219.41,113.45 214.78,108.81 213.29,108.81 212.93,108.46 212.39,108.46 v2(212.2,108.65)
  BOTTOM w0.089: UG3.E11 v2(240.28,117.97)
  BOTTOM w0.178: UG9.D42 v2(212.2,108.65)
FBB_D21: length 40
  IN1 w0.145: v2(211.5,108.65) 212.22,109.37 214.43,109.37 218.52,113.46 218.52,114.96 226.78,123.22 239.14,123.22 240.68,121.68 240.68,119.97 v2(240.28,119.57)
  BOTTOM w0.089: UG3.E13 v2(240.28,119.57)
  BOTTOM w0.178: UG9.E42 v2(211.5,108.65)
FBB_D22: length 40.1
  IN1 w0.145: v2(239.48,117.97) 239.09,118.36 239.09,121 238.17,121.92 227.57,121.92 220.17,114.51 220.17,113.3 214.94,108.07 210.78,108.07 v2(210.2,108.65)
  BOTTOM w0.089: UG3.F11 v2(239.48,117.97)
  BOTTOM w0.178: UG9.F42 v2(210.2,108.65)
FBB_D23: length 38.7
  IN1 w0.145: v2(208.8,107.35) 209.22,107.77 211.95,107.77 212.24,107.48 215.09,107.48 220.93,113.32 220.93,114.32 227.87,121.26 237.9,121.26 238.18,120.98 238.18,120.07 v2(238.68,119.57)
  BOTTOM w0.089: v2(238.68,119.57) 239.08,119.17 UG3.F13
  BOTTOM w0.178: UG9.H41 v2(208.8,107.35)
FBB_D24: length 39.4
  IN3 w0.14: v2(211.5,107.35) 211.5,107.36 211.64,107.5 213.75,107.5 213.91,107.66 215.72,107.66 219.72,111.66 223.92,111.66 228.04,115.78 238.56,115.78 238.94,115.4 241.33,115.4 243.3,113.43 243.3,112.19 v2(242.68,111.57)
  BOTTOM w0.089: v2(242.68,111.57) 243.08,111.97 UG3.A4
  BOTTOM w0.178: UG9.E41 v2(211.5,107.35)
FBB_D25: length 43.5
  IN3 w0.14: v2(210.2,106.55) 210.2,106.76 210.53,107.09 210.53,107.56 210.75,107.78 213.22,107.78 213.85,108.42 215.41,108.42 219.6,112.61 223.47,112.61 227.58,116.72 240.68,116.72 243.87,113.53 243.87,111.16 v2(243.48,110.77)
  BOTTOM w0.089: UG3.A2 243.08,110.37 v2(243.48,110.77)
  BOTTOM w0.17: UG9.F39 v2(210.2,106.55)
FBB_D26: length 38
  IN3 w0.14: v2(211.5,106.55) 212.15,107.2 216.28,107.2 219.85,110.77 224.3,110.77 228.68,115.15 238.63,115.15 238.77,115 241.4,115 243.07,113.33 243.07,112.76 v2(242.68,112.37)
  BOTTOM w0.089: v2(242.68,112.37) 242.28,111.97 UG3.B4
  BOTTOM w0.17: v2(211.5,106.55) UG9.E39
FBB_D27: length 37.6
  IN3 w0.14: v2(242.68,110.77) 242.28,111.17 242.28,113.32 241.21,114.39 228.87,114.39 224.55,110.07 220.23,110.07 216.68,106.51 214.18,106.51 214.07,106.4 212.35,106.4 v2(212.2,106.55)
  BOTTOM w0.089: v2(242.68,110.77) 242.28,110.37 UG3.B2
  BOTTOM w0.17: UG9.D39 v2(212.2,106.55)
