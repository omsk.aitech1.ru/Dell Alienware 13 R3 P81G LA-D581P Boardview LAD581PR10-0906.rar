# Allegro board LAD581PR10-0906.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+NVVDD2 on BOTTOM (solid shape): 196.15,106.35 196.15,104.01 196.27,103.89 196.27,103.71 196.12,103.56 196.12,103.43 195.92,103.23 195.53,103.23 195.51,103.25 195.51,103.43 195.54,103.44 195.78,103.75 195.63,104.1 195.63,104.23 195.76,104.5 195.63,104.77 195.63,104.89 195.78,105.19 195.64,105.5 195.62,105.51 195.62,105.59 195.64,105.6 195.78,105.94 195.57,106.24 195.57,106.39 195.64,106.46 196.04,106.46
+NVVDD2 on BOTTOM (solid shape): 196.73,91.73 196.73,91.54 196.52,91.26 196.64,90.92 196.64,90.74 196.54,90.5 196.64,90.26 196.64,90.08 196.52,89.8 196.67,89.45 196.64,89.38 196.52,89.04 196.74,88.75 196.74,88.57 196.65,88.48 196.45,88.48 196.2,88.73 196.2,88.89 196.03,89.06 196.03,89.14 196.15,89.26 196.15,89.64 196.08,89.71 196.08,89.86 196.18,89.96 196.18,90.31 196.05,90.44 196.05,90.54 196.15,90.64 196.15,91.06 196.08,91.14 196.08,91.26 196.15,91.34 196.15,91.74 196.11,91.79 196.18,91.86 196.6,91.86
+NVVDD2 on IN1 (solid shape): outline of 13543 points within 187.07,62.03 222.38,106.91
+NVVDD2 on IN2 (solid shape): outline of 14536 points within 186.84,62.06 222.01,106.96
+NVVDD2 on IN3 (solid shape): outline of 29087 points within 186.58,60.22 246.46,107.97
+NVVDD2 on GND2: 210.81,62.25 204.8,68.27 204.8,70.36 199.64,75.53 195.83,75.53 187.4,83.95 187.4,96.9 186.96,97.35 187.02,106.53 187.51,107.02 190.35,107.02 190.79,106.58 204.63,106.58 205.25,105.96 205.25,88.44 208.8,84.88 208.8,83.61 222.08,70.33 222.08,70.32 222.65,69.76 222.65,63.44 221.46,62.25 ; 2 cut-outs
+PEX_VDD on TOP (solid shape): outline of 173 points within 183.68,88.84 187.16,95.6
+PEX_VDD on TOP (solid shape): outline of 893 points within 171.15,101.38 186.46,152.72
+PEX_VDD on BOTTOM (solid shape): 178.32,138.58 178.32,136.74 177.66,136.07 177.02,136.07 176.54,136.55 176.54,138.2 175.91,138.84 176.93,139.85 177.05,139.85
+PEX_VDD on BOTTOM (solid shape): 175,151.17 175.42,151.17 175.42,151.17 175.42,150.62 175.43,150.61 175.97,150.61 175.98,150.62 175.98,151.16 175.98,151.16 176.22,151.16 176.22,150.62 176.23,150.62 176.78,150.62 176.78,150.62 176.78,151.17 176.8,151.19 177.13,151.19 177.16,151.16 177.16,148.15 176.96,147.95 175.9,147.95 173.18,150.68 173.18,151.8 173.39,152.01 174.16,152.01
+PEX_VDD on BOTTOM (solid shape): 185.69,104.68 185.77,104.66 185.89,104.54 185.89,101.99 185.78,101.88 183.84,101.88 183.78,101.94 183.75,102.01 183.78,102.08 183.86,102.23 183.88,102.39 183.88,102.42 184.15,102.69 184.24,102.71 184.31,102.65 184.52,102.46 184.8,102.52 184.95,102.52 185.07,102.44 185.68,102.75 185.07,103.05 184.95,102.98 184.8,102.98 184.74,103.02 184.66,103.05 184.61,103.08 184.58,103.15 184.51,103.37 184.18,103.58 184.17,103.59 184.08,103.7 183.95,103.75 183.94,103.75 183.72,103.97 183.72,104.14 183.86,104.31 183.87,104.53 183.87,104.56 183.99,104.68 184.35,104.68 184.56,104.55 184.8,104.62 184.95,104.62 185.07,104.54 185.37,104.47 185.62,104.64
+PEX_VDD on BOTTOM (solid shape): outline of 81 points within 184.43,88.94 185.9,95.44
+PEX_VDD on IN5 (solid shape): outline of 2756 points within 177.62,90.58 186.4,104.95
+TBTA_VBUS on TOP (solid shape): 130.38,153.37 130.38,150.14 129.24,149 128.92,149 128.51,148.58 128.51,147.34 128.44,147.28 128.39,147.21 128.39,147.2 128.34,147.15 128.1,147.15 127.57,147.69 127.57,147.96 127.72,148.1 127.72,149.19 128.92,150.39 128.92,153.37 129.13,153.58 130.17,153.58
+TBTA_VBUS on TOP (solid shape): outline of 255 points within 156.29,166.97 161.06,173.15
+TBTA_VBUS on BOTTOM (solid shape): 128.19,149.15 128.19,147.94 128.51,147.61 128.51,147.35 128.45,147.29 128.4,147.22 128.36,147.18 128.11,147.18 127.6,147.69 127.6,147.99 127.93,148.32 127.93,148.34 127.97,148.38 127.97,149.18 128,149.21 128.12,149.21
+TBTA_VBUS on BOTTOM (solid shape): 130.65,153.13 131.64,153.13 132.22,152.54 132.22,152.11 132.03,151.92 129.05,151.92 128.98,151.98 128.41,151.98 128.36,152.03 128.36,152.26 128.23,152.4 128.01,152.4 127.95,152.45 127.96,152.46 127.96,152.75 128,152.79 128.23,152.79 128.37,152.94 128.37,153.13 128.5,153.26 128.62,153.26 128.63,153.26 128.73,153.26 128.96,153.49 130.28,153.49
+TBTA_VBUS on BOTTOM (solid shape): 160.4,173.17 160.4,172.58 160.53,172.45 160.56,172.41 160.6,172.37 160.72,172.26 160.75,172.21 160.74,172.07 160.75,172.02 160.75,171.73 160.64,171.62 160.64,170.23 160.17,169.77 160.17,169.39 160.3,169.26 160.3,169.07 160.17,168.94 159.98,168.94 159.85,169.07 159.85,170.21 160.36,170.72 160.36,171.62 160.37,171.63 160.27,171.73 160.27,171.97 160.28,172.06 160.27,172.15 160.27,172.26 160.19,172.34 160.19,172.35 160.1,172.44 160.1,173.17 160.18,173.24 160.32,173.24
+TBTA_VBUS on BOTTOM (solid shape): 157.9,173.16 157.9,172.42 157.83,172.35 157.83,172.17 157.82,172.11 157.83,172.01 157.93,171.85 158.1,171.76 158.14,171.75 158.14,171.64 158.15,171.63 158.15,170.58 158.52,170.21 158.52,169.39 158.39,169.26 158.2,169.26 157.85,169.61 157.85,170.53 157.85,170.53 157.85,171.69 157.82,171.72 157.7,171.78 157.58,171.81 157.54,171.82 157.47,171.82 157.37,171.92 157.37,172.29 157.6,172.52 157.6,173.17 157.7,173.27 157.8,173.27
+TBTA_VBUS on IN2 (solid shape): outline of 5289 points within 114.29,147.05 162.69,176.21
+TBTA_VBUS on IN3 (solid shape): outline of 2426 points within 113.55,164.14 161.94,176.21
ADPIN on BOTTOM (solid shape): 36.22,55.14 37.66,55.14 38.17,54.63 38.17,41.42 38.04,41.29 35.18,41.29 35.06,41.42 35.06,45.04 34.48,45.61 33.6,45.61 33.34,45.86 33.34,47.39 32.77,47.96 32.77,54.82 33.09,55.14 36.21,55.14
ADPIN on IN4 (solid shape): 36.53,54.82 36.53,49.1 38.17,47.46 38.17,41.42 38.04,41.29 35.18,41.29 35.06,41.42 35.06,45.04 34.48,45.61 33.6,45.61 33.34,45.86 33.34,47.39 32.77,47.96 32.77,54.82 33.09,55.14 36.21,55.14
ADPIN on IN5 (solid shape): 36.53,54.82 36.53,49.1 38.17,47.46 38.17,41.42 38.04,41.29 35.18,41.29 35.06,41.42 35.06,45.04 34.48,45.61 33.6,45.61 33.34,45.86 33.34,47.39 32.77,47.96 32.77,54.42 33.5,55.14 36.21,55.14
AMP_ASEL on BOTTOM (solid shape): 27.82,26.68 27.82,26.18 27.53,25.89 27.53,25.87 27.5,25.84 27.5,25.52 27.39,25.41 27.25,25.41 27.25,25.41 27.12,25.41 27.02,25.52 27.02,25.94 26.85,26.11 26.36,26.11 26.29,26.18 26.29,26.68 26.36,26.75 27.75,26.75
AMP_LDO_A1.5V on TOP (solid shape): 27.46,26.77 27.86,26.77 27.99,26.64 27.99,26.14 27.91,26.06 26.61,26.06 26.58,26.03 26.52,26.03 26.44,25.96 26.4,25.92 26.29,25.81 26.29,25.74 25.81,25.26 25.81,24.39 25.76,24.34 25.66,24.34 25.61,24.39 25.61,25.63 26.04,26.06 26.08,26.06 26.28,26.06 26.28,26.68 26.37,26.77 27.46,26.77
B+ on TOP (solid shape): 204.99,17.82 204.99,16.05 203.09,16.05 202.58,16.55 202.58,17.89 202.83,18.14 204.67,18.14
B+ on TOP (solid shape): 133.41,142.7 133.41,141.09 133.3,140.98 132.06,140.98 131.83,141.21 131.83,142.67 132.03,142.87 133.24,142.87
B+ on TOP (solid shape): 165.06,6.18 165.06,5.43 165.25,5.24 165.25,1.36 165.17,1.28 163.29,1.28 163,1.56 163,6.18 163.08,6.25 164.98,6.25
B+ on TOP (solid shape): 247.62,5.18 247.62,4.23 244.66,1.27 241.18,1.27 240.94,1.5 240.94,3.85 241.11,4.03 242.68,4.03 245.54,6.89 245.92,6.89
B+ on TOP (solid shape): 96.28,119.26 95.52,119.26 95.07,118.82 95.07,117.36 94.83,117.12 88.53,117.12 87.96,116.55 86.82,116.55 86.25,117.12 86.25,119.79 87.25,120.78 96.28,120.78
B+ on TOP (solid shape): 247.54,45.74 247.54,37.51 246.58,36.56 241.61,36.56 238.53,39.64 238.53,44.76 238.81,45.04 241.83,45.04 242.46,44.41 242.46,42.89 242.77,42.57 244.17,42.57 244.43,42.82 244.43,45.87 244.62,46.06 247.22,46.06
B+ on TOP (solid shape): 54.11,29.83 54.11,29.51 53.56,29.51 53.56,29 54.05,29 54.11,28.94 54.11,28.43 53.88,28.2 52.96,28.2 52.66,27.9 52.66,26.83 52.47,26.63 50.54,26.63 50.35,26.82 50.35,27.45 50.19,27.62 49.3,27.62 49.09,27.82 49.09,28.48 49.65,28.48 49.65,29 49.1,29 49.1,29.57 49.34,29.81 51.57,29.81 51.72,29.95 53.99,29.95
B+ on TOP (solid shape): outline of 138 points within 118.88,149.59 122.06,155.92
B+ on TOP (solid shape): outline of 809 points within 60.9,15.04 79.51,58.41
B+ on BOTTOM (solid shape): 133.3,142.58 133.3,141.06 133.17,140.93 132.48,140.93 132.22,141.18 132.22,142.45 132.48,142.71 133.17,142.71
B+ on BOTTOM (solid shape): 243.16,44.53 243.16,40.93 241.92,39.7 239.05,39.7 238.06,40.69 238.06,44.84 238.43,45.21 242.47,45.21
B+ on BOTTOM (solid shape): 246.89,4.1 246.89,2.88 245.76,1.75 241.21,1.75 241,1.97 241,4.91 241.59,5.51 245.48,5.51
B+ on BOTTOM (solid shape): 78.33,55.36 78.33,50.72 77.87,50.25 75.35,50.25 73.67,51.94 73.67,55.27 74.24,55.84 74.7,56.31 77.38,56.31
B+ on BOTTOM (solid shape): 162.96,147.28 163.46,147.28 163.46,147.85 163.72,147.85 163.72,145.88 162.7,145.88 162.51,146.07 162.51,147.79 162.57,147.85 162.96,147.85
B+ on BOTTOM (solid shape): 97.17,119.49 97.17,115.99 95.39,115.99 94.63,116.76 90.63,116.76 89.67,115.8 89.67,111.3 89.55,111.17 88.83,111.17 88.81,111.19 88.81,111.73 88.83,111.74 88.6,111.74 88.59,111.75 88.3,111.75 88.3,111.17 87.64,111.17 87.45,110.98 87.45,109.84 84.21,109.84 83.9,110.15 83.9,116.44 87.77,120.31 96.34,120.31
B+ on BOTTOM (solid shape): 63.47,45.07 63.47,41.26 63.32,41.11 59.3,41.11 58.91,41.5 58.82,41.5 58.69,41.63 58.69,42.2 59.22,42.2 59.58,42.56 59.22,42.91 58.68,42.91 58.68,43.68 59.25,44.25 59.25,44.26 60.16,45.16 63.38,45.16
B+ on BOTTOM (solid shape): outline of 2307 points within 73.17,1.17 152.85,17.48
B+ on IN1 (solid shape): 88.78,3.44 88.78,1.42 88.6,1.23 82.96,1.23 82.71,1.48 82.71,3.1 83.27,3.65 88.57,3.65
B+ on IN1 (solid shape): outline of 1183 points within 103.46,1.17 244.55,7.33
B+ on IN2 (solid shape): 52.52,29.48 52.52,27.45 51.83,26.76 49.73,26.76 49.16,27.33 49.16,29.74 49.35,29.93 52.07,29.93
B+ on IN2 (solid shape): 88.78,3.44 88.78,1.42 88.6,1.23 82.96,1.23 82.71,1.48 82.71,3.1 83.27,3.65 88.57,3.65
B+ on IN2 (solid shape): 114.12,3.47 114.12,1.7 113.59,1.17 112.29,1.17 111.75,1.54 111.1,1.67 107.1,1.67 106.47,1.55 105.94,1.2 103.78,1.2 103.46,1.52 103.46,3.11 104.09,3.75 104.71,3.75 105.39,4.42 113.17,4.42
B+ on IN2 (solid shape): outline of 162 points within 138.69,1.18 168.05,5.47
B+ on IN2 (solid shape): outline of 396 points within 178.56,1.19 244.55,6.58
B+ on IN3 (solid shape): 88.78,3.44 88.78,1.42 88.6,1.23 82.96,1.23 82.71,1.48 82.71,3.1 83.27,3.65 88.57,3.65
B+ on IN3 (solid shape): 114.12,3.47 114.12,1.7 113.59,1.17 112.29,1.17 111.75,1.54 111.1,1.67 107.1,1.67 106.47,1.55 105.94,1.2 103.78,1.2 103.46,1.52 103.46,3.11 105.03,4.69 112.9,4.69
B+ on IN3 (solid shape): outline of 153 points within 138.69,1.18 170.76,5.47
B+ on IN3 (solid shape): outline of 401 points within 179.58,1.19 244.55,6.58
B+ on IN3 (solid shape): outline of 2508 points within 48.21,26.19 67.45,44.86
B+ on IN4 (solid shape): 88.78,3.44 88.78,1.42 88.6,1.23 82.96,1.23 82.71,1.48 82.71,3.1 83.27,3.65 88.57,3.65
B+ on IN4 (solid shape): 114.12,3.47 114.12,1.7 113.59,1.17 112.29,1.17 111.75,1.54 111.1,1.67 107.1,1.67 106.47,1.55 105.94,1.2 103.78,1.2 103.46,1.52 103.46,3.11 104.09,3.75 104.71,3.75 105.65,4.69 112.9,4.69
B+ on IN4 (solid shape): outline of 154 points within 138.69,1.18 170.76,5.48
B+ on IN4 (solid shape): outline of 424 points within 178.37,1.19 244.55,6.58
B+ on IN4 (solid shape): outline of 2410 points within 49.23,26.19 67.45,44.79
B+ on IN5 (solid shape): 76.5,17.07 76.5,16.63 76.5,16.63 76.47,16.6 76.47,13.73 75.77,13.03 74.15,13.03 72.97,14.2 72.97,17.06 73.33,17.41 76.15,17.41
B+ on IN5 (solid shape): 88.78,3.44 88.78,1.42 88.6,1.23 82.96,1.23 82.71,1.48 82.71,2.99 83.37,3.64 85,3.64 85.01,3.65 88.57,3.65
B+ on IN5 (solid shape): 114.12,3.47 114.12,1.7 113.59,1.17 112.29,1.17 111.75,1.54 111.1,1.67 107.1,1.67 106.47,1.55 105.94,1.2 103.78,1.2 103.46,1.52 103.46,3.11 104.09,3.75 104.71,3.75 105.65,4.69 112.9,4.69
B+ on IN5 (solid shape): outline of 331 points within 138.69,1.17 167.87,5.48
B+ on IN5 (solid shape): outline of 902 points within 179.01,1.19 249.38,45.11
B+_BIAS on TOP (solid shape): 48.59,12.38 48.59,7.2 48.34,6.95 46.81,6.95 46.47,7.29 46.47,12.17 46.99,12.69 48.27,12.69
B+_BIAS on TOP (solid shape): 19.67,15.18 19.67,14.58 19.7,14.55 21.05,14.55 21.1,14.5 21.1,13.68 21.03,13.61 19.46,13.61 18.55,14.52 18.55,15.16 18.68,15.28 19.57,15.28
B+_BIAS on IN4 (solid shape): 47.56,12.5 47.56,11.45 47.31,11.19 45.08,11.19 44.6,11.68 44.6,12.63 44.67,12.69 47.37,12.69
B+_BIAS on IN4 (solid shape): 21.12,14.99 21.12,14.1 20.82,13.8 18.81,13.8 18.55,14.05 18.55,15.16 18.68,15.28 20.83,15.28
B+_VCCIO on TOP (solid shape): 89.86,108.44 89.86,107.49 89.67,107.3 87.77,107.3 87.71,107.36 87.71,109.01 87.77,109.07 89.23,109.07
B+_VCCIO on BOTTOM (solid shape): 90.69,110.9 90.69,107.99 90.94,107.74 90.94,106.26 90.87,106.19 90.11,106.19 90.04,106.26 90.04,107.06 89.8,107.3 88.09,107.3 87.95,107.43 87.95,109.21 89.32,109.21 89.32,109.15 89.33,109.1 89.34,109.05 89.37,109 89.4,108.96 89.43,108.92 89.48,108.89 89.52,108.86 89.57,108.84 89.62,108.83 89.68,108.82 89.73,108.83 89.78,108.84 89.83,108.86 89.88,108.89 89.92,108.92 89.96,108.96 89.99,109 90.01,109.05 90.02,109.1 90.03,109.15 90.03,109.21 90.02,109.26 90.01,109.31 89.99,109.36 89.96,109.4 89.92,109.44 89.88,109.48 89.83,109.5 89.78,109.52 89.73,109.53 89.68,109.54 89.62,109.53 89.57,109.52 89.52,109.5 89.48,109.48 89.43,109.44 89.4,109.4 89.37,109.36 89.34,109.31 89.33,109.26 89.32,109.21 87.95,109.21 87.95,110.78 87.96,110.79 87.96,110.89 88.05,110.98 90.61,110.98
BATT+ on BOTTOM (solid shape): 72.16,28.02 72.16,21.21 71.38,20.43 71.38,18.15 71.3,18.07 67.35,18.07 67.12,18.3 67.12,25.29 67.34,25.5 67.9,25.5 68.25,25.86 67.9,26.22 67.38,26.22 67.35,26.24 67.35,27.08 67.35,27.09 67.35,27.29 67.18,27.46 67.18,28.09 67.22,28.12 72.05,28.12
BATT+ on IN5 (solid shape): 71.15,24.75 71.15,19.8 70.33,18.97 68.1,18.97 67.18,19.89 67.18,21.27 67.15,21.3 67.15,24.62 67.79,25.26 70.64,25.26
BATT++ on BOTTOM (solid shape): outline of 227 points within 60.78,9.06 66.88,24.14
BATT++ on IN4 (solid shape): 66.88,23.09 66.88,15.84 66.44,15.39 66.44,13.11 65.63,12.31 62.96,12.31 62.3,12.97 62.3,19.13 63.33,20.16 63.33,21.63 64.68,21.63 64.69,21.57 64.7,21.52 64.72,21.47 64.74,21.43 64.78,21.38 64.82,21.35 64.86,21.32 64.91,21.29 64.96,21.28 65.01,21.27 65.07,21.27 65.12,21.28 65.17,21.29 65.22,21.32 65.26,21.35 65.3,21.38 65.33,21.43 65.36,21.47 65.38,21.52 65.39,21.57 65.4,21.63 65.39,21.68 65.38,21.73 65.36,21.78 65.33,21.83 65.3,21.87 65.26,21.91 65.22,21.94 65.17,21.96 65.12,21.97 65.07,21.98 65.01,21.98 64.96,21.97 64.91,21.96 64.86,21.94 64.82,21.91 64.78,21.87 64.74,21.83 64.72,21.78 64.7,21.73 64.69,21.68 64.68,21.63 63.33,21.63 63.33,23.14 63.57,23.38 66.59,23.38
BATT++ on IN5 (solid shape): 64.69,21.56 64.89,21.3 65.22,21.32 66.37,21.32 66.83,20.86 66.83,16.61 66.45,16.24 63.73,16.24 63.33,16.63 63.33,20.8 63.33,20.81 63.33,21.52 63.74,21.93 64.31,21.93
BOOT_1.2V on TOP (solid shape): 63.96,50.65 65.1,50.65 65.31,50.44 65.4,50.44 65.41,50.43 65.41,49.79 65.36,49.74 64.58,49.74 63.69,50.62 62.44,50.62 62.4,50.66 62.4,50.78 62.45,50.83 63.78,50.83
BST_1.2V on TOP (solid shape): 65.46,48.99 65.46,47.2 65.38,47.12 64.53,47.12 64.47,47.18 64.47,48.99 64.52,49.04 65.41,49.04
BST_3V on BOTTOM (solid shape): 36.26,31.2 36.26,30.56 36.2,30.49 35.92,30.49 35.02,29.59 35.02,28.7 34.96,28.64 34.87,28.64 34.81,28.7 34.81,29.88 35.16,30.23 35.16,31.08 35.35,31.27 36.2,31.27
BST_5V on BOTTOM (solid shape): 35.01,26.41 35.01,25.33 36.08,24.26 36.08,23.69 36.04,23.65 35.05,23.65 35,23.7 35,24.16 34.8,24.36 34.8,26.41 34.84,26.45 34.98,26.45
BST_+1VALWP on TOP (solid shape): 211.85,19.15 211.85,17.63 211.02,16.81 210.32,16.81 210.26,16.87 210.26,17.82 210.9,18.46 210.9,19.12 211.05,19.27 211.73,19.27
BST_VCCIO on BOTTOM (solid shape): 90.94,105.93 90.94,105.77 89.55,104.37 88.34,104.37 88.21,104.5 88.21,105.26 88.34,105.39 89.42,105.39 90.04,106.01 90.87,106.01
BTST_CHG on TOP (solid shape): 58.51,33.29 58.51,32.01 58.34,31.84 58.34,30.69 58.29,30.64 57.42,30.64 57.37,30.69 57.37,31.26 57.42,31.31 57.87,31.31 58.03,31.46 58.03,31.84 58.29,32.11 58.29,33.27 58.36,33.33 58.47,33.33
CHG_B+ on TOP (solid shape): 54.94,29.76 54.94,29.26 55.11,29.08 56.63,29.08 56.92,28.79 56.92,28.1 57.16,27.86 57.16,25.42 57.61,24.97 60.62,24.97 60.83,24.76 60.83,20.73 60.46,20.36 56.46,20.36 56.46,23.46 54.48,25.44 54.48,27.95 54.3,28.13 54.3,29.82 54.37,29.89 54.82,29.89
CPU_B+ on TOP (solid shape): 127.96,135.62 127.96,133.84 127.66,133.53 127.05,133.53 126.97,133.62 123.13,133.62 123.08,133.67 123.08,135.64 123.1,135.67 126.49,135.67 126.54,135.72 127.86,135.72
CPU_B+ on TOP (solid shape): 136.28,135.65 136.28,134.03 135.79,133.54 131.38,133.54 131.3,133.62 131.3,134.2 131.31,134.31 131.3,134.41 131.3,135.59 131.36,135.65 132.89,135.65 132.99,135.56 134.72,135.56 134.91,135.74 136.19,135.74
CPU_B+ on TOP (solid shape): 119.84,135.57 119.84,133.97 119.33,133.46 114.93,133.46 114.81,133.58 114.81,134.08 114.85,134.24 114.81,134.41 114.81,135.53 114.89,135.61 116.43,135.61 116.63,135.41 118.16,135.41 118.41,135.67 119.74,135.67
CPU_B+ on TOP (solid shape): 144.73,135.62 144.73,134.03 144.16,133.46 142.03,133.46 141.96,133.47 141.88,133.46 141.38,133.46 141.31,133.47 141.09,133.47 141.02,133.46 140.74,133.46 140.66,133.47 140.59,133.46 140.3,133.46 140.23,133.47 140.01,133.47 139.94,133.46 139.83,133.46 139.78,133.51 139.78,134.06 139.83,134.26 139.78,134.45 139.78,135.57 139.79,135.58 143.2,135.58 143.29,135.68 144.67,135.68
CPU_B+ on TOP (solid shape): 153.97,135.24 154,135.24 154.25,134.98 156.6,134.98 158.91,132.67 158.91,130.05 160.35,128.61 160.35,127.53 160.18,127.36 157.43,127.36 157.3,127.23 157.3,124.82 157.17,124.68 156.23,124.68 156.1,124.82 156.1,125.44 156.16,125.53 156.27,125.5 156.89,125.74 156.27,125.98 156.16,125.95 156.1,126.05 156.1,126.49 156.16,126.58 156.27,126.56 156.89,126.8 156.27,127.03 156.16,127.01 156.1,127.1 156.1,127.23 156.22,127.36 156.22,128.95 156.1,129.08 156.1,132.49 155.44,133.14 151.52,133.14 151.17,133.49 149.99,133.49 149.92,133.49 149.85,133.49 149.34,133.49 149.27,133.49 149.06,133.49 148.98,133.49 148.69,133.49 148.62,133.49 148.55,133.49 148.26,133.49 148.19,133.49 147.98,133.49 147.87,133.49 147.74,133.61 147.74,134.09 147.8,134.28 147.74,134.47 147.74,134.76 147.99,135.01 147.99,135.5 148.1,135.61 149.54,135.61 149.8,135.34 149.8,135.34 151.5,135.34 151.59,135.43 151.59,135.68 151.75,135.85 153.36,135.85
CPU_B+ on BOTTOM (solid shape): 157.94,128.44 157.94,127.42 157.75,127.23 155.65,127.23 155.65,128.44 156.29,128.44 156.48,128.63 157.75,128.63
CPU_B+ on BOTTOM (solid shape): 119.84,135.87 119.84,133.9 119.49,133.56 117.86,133.56 117.75,133.67 115.17,133.67 115.11,133.73 115.11,134.87 116.51,134.87 116.63,135 116.63,135.89 116.89,136.14 119.57,136.14
CPU_B+ on BOTTOM (solid shape): 144.67,135.84 144.67,133.93 144.19,133.46 142.38,133.46 142.16,133.68 140.15,133.68 140.09,133.74 140.09,134.88 141.49,134.88 141.61,135.01 141.61,135.9 141.87,136.15 144.35,136.15
CPU_B+ on BOTTOM (solid shape): 128.09,135.79 128.09,134.09 127.52,133.52 126.5,133.52 126.27,133.75 123.5,133.75 123.44,133.82 123.44,134.96 124.84,134.96 124.96,135.09 124.96,135.98 125.22,136.23 127.65,136.23
CPU_B+ on BOTTOM (solid shape): 153.05,135.83 153.05,133.84 152.91,133.7 148.12,133.7 148.05,133.77 148.05,134.91 149.45,134.91 149.58,135.04 149.58,135.93 149.83,136.18 152.7,136.18
CPU_B+ on BOTTOM (solid shape): 110.12,128.17 110.12,126.39 109.04,125.31 109.02,125.31 104.28,120.57 101.93,120.57 100.98,119.61 100.98,116.06 98.18,116.06 97.93,116.31 97.93,119.87 97.1,120.69 97.1,123.81 97.99,124.69 103.14,124.69 105.1,126.66 105.1,128.31 105.36,128.57 109.72,128.57
CPU_B+ on BOTTOM (solid shape): 136.41,135.82 136.41,134.03 136.11,133.73 131.58,133.73 131.57,133.74 131.57,134.87 131.63,134.94 132.96,134.94 133.09,135.06 133.09,135.95 133.35,136.21 136.02,136.21
CPU_B+ on IN2 (solid shape): outline of 3982 points within 106.37,125.39 152.99,136.61
CPU_B+ on IN4 (solid shape): outline of 2841 points within 107.68,125.5 153.81,138.07
DH_1.2V on TOP (solid shape): 66.93,51.77 66.93,51.01 66.74,50.81 66.11,50.81 65.92,51.01 65.92,51.74 66.13,51.96 66.74,51.96
DH_1.2V on TOP (solid shape): 64.3,49.82 64.3,49.56 64.19,49.44 63.97,49.44 63.45,49.96 63.45,50.04 63.31,50.18 62.45,50.18 62.4,50.23 62.4,50.38 62.45,50.43 63.69,50.43
DH_1.2V on IN1 (solid shape): 66.87,51.83 66.87,50.18 66.17,49.48 64.01,49.48 63.44,50.05 63.44,50.31 63.57,50.43 64.46,50.43 64.58,50.31 65.79,50.31 65.98,50.5 65.98,51.83 66.11,51.96 66.74,51.96
DH_CHG on TOP (solid shape): 60.88,19.34 60.88,17.88 60.74,17.75 59.96,17.75 59.8,17.91 59.8,19.41 59.99,19.6 60.62,19.6
DH_CHG on TOP (solid shape): 58.92,33.29 58.92,31.81 58.95,31.77 58.95,30.94 58.84,30.83 58.6,30.83 58.49,30.94 58.49,31.79 58.7,32 58.7,33.29 58.75,33.34 58.86,33.34
DH_CHG on IN5 (solid shape): 60.62,19.04 60.86,18.8 60.86,17.86 60.73,17.74 59.96,17.74 59.85,17.84 59.85,19.2 59.96,19.3 60.62,19.3
DH_CHG on IN5 (solid shape): 58.95,31.73 58.95,30.56 59.41,30.1 59.41,29.28 58.79,29.28 58.37,29.7 58.37,31.76 58.47,31.86 58.83,31.86
DL_1.2V on TOP (solid shape): 73.19,48.69 73.19,47.83 73.13,47.77 72.31,47.77 72.2,47.87 72.2,48.69 72.29,48.78 73.11,48.78
DL_1.2V on TOP (solid shape): 62.93,49.13 62.93,48.41 62.75,48.23 62.56,48.23 62.01,48.78 62.01,49.57 62.06,49.62 62.44,49.62
DL_1.2V on IN1 (solid shape): 73.22,48.66 73.22,47.89 72.46,47.13 71.38,47.13 71.25,47.26 71.25,47.83 71.57,48.15 71.89,48.15 72.52,48.78 73.09,48.78
DL_1.2V on IN1 (solid shape): 63.66,48.41 63.66,47.97 63.4,47.71 62.96,47.71 62.85,47.82 62.85,47.93 62.34,48.45 62.34,49.11 62.52,49.3 62.77,49.3
DL_CHG on TOP (solid shape): 52.66,26.02 52.66,25.06 52.65,25.06 52.65,23.92 52.53,23.79 52.27,23.79 51.51,24.55 51.51,25.98 51.65,26.12 52.55,26.12
DL_CHG on TOP (solid shape): 57.72,33.29 57.72,32.23 56.79,31.3 56.57,31.3 56.48,31.39 56.48,31.71 56.98,32.21 57.22,32.21 57.5,32.49 57.5,33.3 57.54,33.34 57.67,33.34
DL_CHG on IN5 (solid shape): 52.67,26.97 52.67,25.57 52.54,25.44 51.71,25.44 51.59,25.57 51.59,26.9 51.97,27.29 52.35,27.29
DL_CHG on IN5 (solid shape): 57.35,32.05 57.35,31.86 56.15,30.65 56.08,30.65 55.64,30.21 55.51,30.21 55.07,30.65 55.07,30.97 55.64,31.54 56.02,31.54 56.72,32.24 57.16,32.24
ECAGND on TOP (solid shape): 99.59,22.2 99.59,20.42 99.74,20.27 99.74,19.93 99.65,19.84 99.29,19.84 99.17,19.95 99.17,20.24 99.37,20.43 99.37,22.18 99.44,22.26 99.53,22.26
GPU_B+ on TOP (solid shape): 243.16,52.67 244.81,52.67 245.25,52.22 245.25,47.2 244.93,46.89 239.92,46.89 239.79,47.01 239.79,48.92 239.92,49.05 242.52,49.05 242.58,49.11 242.58,50.57 242.39,50.76 239.85,50.76 239.73,50.89 239.73,52.79 239.98,53.05 242.77,53.05
ISENSEP_L_R on TOP (solid shape): 25.63,28.12 25.63,27.96 25.32,27.65 25.32,27.13 25.27,27.08 24.7,27.08 24.64,27.13 24.64,27.72 24.56,27.8 24.56,28.16 24.72,28.32 25.43,28.32
ISENSEP_L_R on BOTTOM (solid shape): 32.33,15.73 32.33,13.63 32.21,13.51 31,13.51 30.75,13.76 30.17,13.76 30.05,13.89 30.05,14.65 30.11,14.71 30.68,14.71 30.87,14.9 30.87,15.86 30.94,15.92 32.14,15.92
ISENSEP_L_R on IN1 (solid shape): 25.63,28.11 25.63,26.93 25.37,26.68 24.79,26.68 24.56,26.9 24.56,28.1 24.73,28.26 25.48,28.26
ISENSEP_L_R on IN1 (solid shape): 32.33,14.39 32.33,13.63 32.21,13.51 30.05,13.51 30.05,13.76 30.81,14.52 32.21,14.52
ISENSEP_L_R on IN1 (solid shape): 25.1,24.54 25.1,23.63 25.07,23.62 24.87,23.29 25.07,22.97 25.1,22.96 25.1,22.25 25.07,22.24 24.87,21.91 25.07,21.59 25.1,21.58 25.1,20.87 25.07,20.85 24.87,20.53 25.07,20.21 25.1,20.2 25.1,19.49 25.07,19.47 24.87,19.15 25.07,18.83 25.1,18.82 25.1,17.3 24.78,16.98 24.02,16.98 23.89,17.11 23.89,17.61 24.08,17.8 24.08,18.89 24.2,19.15 24.08,19.42 24.08,20.27 24.2,20.53 24.08,20.8 24.08,21.65 24.2,21.91 24.08,22.18 24.08,23.03 24.2,23.29 24.08,23.56 24.08,24.09 24.02,24.15 24.02,24.41 24.4,24.79 24.84,24.79
ISENSEP_R_R on TOP (solid shape): 21.4,28.13 21.4,27.95 20.98,27.53 20.98,27.1 20.95,27.08 20.4,27.08 20.39,27.28 20.27,27.44 20.27,28.1 20.45,28.28 21.25,28.28
ISENSEP_R_R on TOP (solid shape): 24.48,13.77 24.48,12.78 24.59,12.68 24.59,11.85 24.4,11.66 21.41,11.66 21.35,11.73 21.35,12.43 21.48,12.55 22.94,12.55 23.19,12.81 23.19,12.81 23.81,12.81 23.9,12.9 23.9,13.77 23.98,13.84 24.41,13.84
ISENSEP_R_R on IN1 (solid shape): 24.22,13.69 24.22,11.98 24.02,11.78 23.38,11.78 23.18,11.98 23.18,13.76 23.38,13.97 23.94,13.97
ISENSEP_R_R on IN1 (solid shape): 21.41,28.09 21.41,27.65 21.79,27.27 21.79,27.08 21.29,26.57 21.03,26.57 20.41,27.18 20.36,27.33 20.27,27.44 20.27,28.09 20.4,28.22 21.28,28.22
ISUMP_SA on TOP (solid shape): 160.1,123.66 160.1,123.15 160.03,123.09 159.27,123.09 159.15,122.96 159.15,122.77 159.08,122.71 158.51,122.71 158.45,122.77 158.45,123.79 159.97,123.79
LG_3V on TOP (solid shape): 46.56,33.83 46.56,32.94 46.43,32.81 45.48,32.81 45.3,32.99 45.3,34.36 45.41,34.47 45.92,34.47
LG_3V on BOTTOM (solid shape): 37.1,29.44 37.1,28.87 36.46,28.24 35.7,28.24 35.57,28.36 35.57,28.49 36.65,29.57 36.97,29.57
LG_3V on IN2 (solid shape): 46.56,33.83 46.56,32.94 46.43,32.81 45.1,32.81 44.72,33.19 44.72,33.76 44.91,33.95 46.43,33.95
LG_3V on IN2 (solid shape): 39,30.27 39,29.95 37.73,28.68 36.84,28.68 36.65,28.49 36.27,28.49 36.14,28.62 36.14,29.06 36.65,29.57 37.22,29.57 38.18,30.52 38.75,30.52
LG_5V on TOP (solid shape): 40.84,27.98 40.84,26.65 40.72,26.52 40.14,26.52 39.83,26.84 39.83,27.6 39.7,27.73 39.7,27.98 39.89,28.17 40.65,28.17
LG_5V on BOTTOM (solid shape): 36.65,26.65 37.1,26.65 37.29,26.46 37.29,26.14 37.16,26.02 36.21,26.02 35.64,26.59 35.61,26.61 35.61,26.79 35.68,26.86 36.44,26.86
LG_5V on IN5 (solid shape): 40.84,28.05 40.84,27.03 40.27,26.46 39.89,26.46 39.7,26.65 39.7,27.98 39.89,28.17 40.72,28.17
LG_5V on IN5 (solid shape): 38.62,26.33 38.62,25.82 38.43,25.63 37.22,25.63 36.91,25.95 36.33,25.95 36.14,26.14 36.14,26.59 36.27,26.71 38.24,26.71
LG_+1VALWP on TOP (solid shape): 211.85,21.76 211.85,21.09 211.73,20.97 210.99,20.97 210.71,21.25 210.71,21.76 210.83,21.89 211.72,21.89
LG_+1VALWP on BOTTOM (solid shape): 207.34,20.68 207.34,19.92 207.21,19.79 206.32,19.79 206.2,19.92 206.2,20.68 206.38,20.86 207.16,20.86
LG_+1VALWP on IN2 (solid shape): 211.85,21.76 211.85,21.32 211.72,21.19 210.45,21.19 209.05,19.79 206.39,19.79 206.2,19.98 206.2,20.49 206.58,20.87 209.05,20.87 210.07,21.89 211.72,21.89
LX_1.0VS_VGAP on BOTTOM (solid shape): 163.59,152.25 163.59,152.13 162.81,151.34 162.64,151.34 162.44,151.55 162.44,151.99 162.76,152.32 163.52,152.32
LX_1.0VS_VGAP on BOTTOM (solid shape): 168.97,153.75 168.97,151.16 167.59,149.78 166.13,149.78 166,149.9 166,151.87 165.75,152.13 165.75,152.63 165.87,152.76 166.91,152.76 167.3,153.15 167.3,153.83 167.33,153.86 167.35,153.86 168.06,153.86 168.08,153.88 168.84,153.88
LX_3V on TOP (solid shape): 51.16,38.75 51.16,36.92 50.56,36.32 50.2,36.32 50.11,36.24 47.89,36.24 47.7,36.43 47.7,37.42 47.5,37.61 46.73,37.61 45.99,36.87 45.99,35.26 45.63,34.9 43.42,34.9 43.23,35.09 43.23,35.57 43,35.79 40.84,35.79 40.72,35.92 40.72,38.72 41.73,39.73 50.18,39.73
LX_3V on BOTTOM (solid shape): 34.75,30.08 34.62,29.95 34.62,28.7 34.56,28.64 34.47,28.64 34.4,28.71 34.4,29.66 34.05,30.02 34.05,31.35 34.11,31.41 34.75,31.41
LX_3V on BOTTOM (solid shape): 49.48,38.46 49.48,38.21 49.73,37.95 50.88,37.95 51.19,37.64 51.19,31.79 50.94,31.54 48.4,31.54 47.45,32.49 47.45,37.06 47.07,37.45 47.07,38.46 47.26,38.65 49.29,38.65
LX_3V on IN5 (solid shape): 35.64,31.54 35.64,30.4 34.94,29.7 34.3,29.7 34.18,29.83 34.18,30.59 35.25,31.67 35.51,31.67
LX_3V on IN5 (solid shape): 47.57,38.7 47.57,37.64 47.45,37.51 46.37,37.51 46.3,37.57 46.3,38.4 46.43,38.52 46.43,38.52 46.79,38.89 47.39,38.89
LX_5V on TOP (solid shape): 44.46,24.24 45.97,24.24 46.13,24.09 46.13,22.22 45.61,21.7 40.33,21.7 40.02,22.01 40.02,25.63 40.39,25.99 42.71,25.99
LX_5V on BOTTOM (solid shape): 47.51,27.48 47.51,22.46 46.68,21.63 42.95,21.63 42.45,22.13 42.45,25.91 44.08,27.54 47.45,27.54
LX_5V on BOTTOM (solid shape): 34.62,26.4 34.62,24.35 34.86,24.11 34.86,23.64 34.79,23.56 34.23,23.56 34.16,23.63 34.16,25.11 34.39,25.34 34.39,26.4 34.45,26.46 34.56,26.46
LX_5V on IN5 (solid shape): 35.51,24.62 35.51,23.98 35.32,23.79 34.68,23.79 34.18,24.3 34.18,25.13 34.37,25.32 34.81,25.32
LX_5V on IN5 (solid shape): 43.16,23.28 43.16,22.58 42.97,22.39 42.01,22.39 41.76,22.64 41.76,23.28 41.89,23.4 43.03,23.4
LX_+1.8VGS on BOTTOM (solid shape): 237.95,151.98 238.84,151.98 238.9,151.92 238.9,151.28 238.84,151.22 238.01,151.22 237.71,150.91 237.71,149 237.66,148.95 237.1,148.95 237.06,149 237.06,149.78 236.55,150.29 236.55,152.3 236.62,152.36 237.57,152.36
LX_CHG on TOP (solid shape): 59.32,33.27 59.32,32.17 59.92,31.58 59.92,30.55 59.85,30.49 59.25,30.49 59.09,30.64 59.09,33.29 59.13,33.33 59.26,33.33
LX_CHG on TOP (solid shape): 55.42,23.01 55.42,20.03 55.89,19.56 59.19,19.56 59.38,19.37 59.38,16.44 59.23,16.28 55.21,16.28 52.12,19.37 49.62,19.37 49.42,19.57 49.42,20.91 49.58,21.08 51.6,21.08 51.77,21.25 51.77,23.3 52.01,23.54 54.89,23.54
LX_CHG on BOTTOM (solid shape): 48.91,25.41 49.04,25.39 49.16,25.41 49.17,25.41 52.66,25.41 52.78,25.29 52.81,25.24 52.84,25.2 52.87,25.13 52.84,25.06 52.85,24.56 53.35,24.55 53.42,24.58 53.49,24.55 53.53,24.52 53.58,24.49 53.67,24.4 55.58,24.4 55.92,24.05 55.92,21.3 56.68,20.55 59.3,20.55 59.5,20.34 59.5,17.88 59.28,17.66 56.35,17.66 55.54,18.47 53.41,18.47 52.21,19.67 48.8,19.67 48.46,20 48.46,25.1 48.77,25.41 48.9,25.41
LX_CHG on IN5 (solid shape): 60.76,31.01 60.76,30.85 60.12,30.22 59.09,31.25 59.09,31.93 59.26,32.1 59.66,32.1
LX_CHG on IN5 (solid shape): 59.67,17.91 59.67,17.26 59.89,17.04 59.89,16.34 56.65,16.34 56.28,16.71 56.28,18.02 56.41,18.15 59.42,18.15
LX_VCCIO on BOTTOM (solid shape): 91.72,105.6 91.72,102.45 92.09,102.09 94.95,102.09 95.07,101.96 95.07,101.01 94.88,100.82 93.36,100.82 92.4,99.87 92.4,99.42 92.02,99.04 89.04,99.04 88.72,99.36 88.72,100.98 90.5,102.76 90.5,104.03 90.94,104.47 90.94,105.55 91.08,105.68 91.63,105.68
LX_VCCIO on IN5 (solid shape): 91.3,109.88 91.3,104.72 91.7,104.33 91.7,104 91.49,103.8 90.49,103.8 90.29,104 90.29,109.79 90.5,110.01 91.18,110.01
NVVDD_B+ on TOP (solid shape): outline of 265 points within 191.15,38.57 238.33,53.49
NVVDD_B+ on BOTTOM (solid shape): 241.25,52.6 241.25,48.67 241,48.41 228.36,48.41 227.98,48.79 227.98,52.16 228.68,52.86 241,52.86
NVVDD_B+ on BOTTOM (solid shape): 194.64,47.71 194.64,43.71 194.58,43.65 194.07,43.65 194.01,43.71 194.01,44.41 193.82,44.6 192.36,44.6 191.91,44.15 191.91,42.64 192.17,42.38 194.32,42.38 194.58,42.12 194.58,38.06 194.51,38 194.13,38 193.12,39.01 191.78,39.01 190.83,39.97 190.83,41.55 190.44,41.95 190.44,48.04 190.68,48.28 194.07,48.28
NVVDD_B+ on BOTTOM (solid shape): 208.04,47.46 208.04,46.7 208.17,46.57 210.33,46.57 210.64,46.25 210.64,36.83 211.87,35.6 211.87,34.55 211.67,34.36 210.59,34.36 210.5,34.45 210.5,35.12 210.22,35.39 207.06,35.39 206.92,35.53 206.92,36.27 207.08,36.42 207.08,37.55 207.47,37.94 207.47,42.57 208.61,42.57 208.61,41.43 208.87,41.17 209.75,41.17 210.14,41.55 210.14,42.57 209.88,42.82 208.87,42.82 208.61,42.57 207.47,42.57 207.47,47.46 207.53,47.52 207.98,47.52
NVVDD_B+ on IN4 (solid shape): outline of 87 points within 191.15,38.57 235.54,53.49
NVVDD_BST1 on BOTTOM (solid shape): 203.91,32.66 203.91,32.03 203.79,31.9 201.31,31.9 201.25,31.96 201.25,32.09 201.88,32.73 203.85,32.73
NVVDD_BST2 on BOTTOM (solid shape): 197.63,32.35 198.71,32.35 198.9,32.16 198.9,31.96 198.83,31.9 196.23,31.9 196.17,31.96 196.17,32.54 196.23,32.6 197.37,32.6
NVVDD_HG1 on BOTTOM (solid shape): 209.77,48.09 209.77,47.32 209.51,47.07 208.81,47.07 208.62,47.26 208.62,48.15 208.75,48.28 209.58,48.28
NVVDD_HG1 on BOTTOM (solid shape): 209.96,42.5 209.96,41.67 209.65,41.36 208.99,41.36 208.81,41.54 208.81,42.56 208.94,42.69 209.77,42.69
NVVDD_HG1 on BOTTOM (solid shape): 203.34,31.65 203.34,31.33 203.28,31.27 202.45,31.27 202.26,31.46 201.31,31.46 201.25,31.52 201.25,31.65 201.31,31.71 202.26,31.71 202.33,31.77 203.21,31.77
NVVDD_HG1 on IN1 (solid shape): 204.1,32.85 204.1,32.16 203.28,31.33 202.39,31.33 202.26,31.46 202.26,31.71 203.72,33.17 203.79,33.17
NVVDD_HG1 on IN1 (solid shape): 209.85,48.16 209.85,46.95 209.66,46.76 208.83,46.76 208.64,46.95 208.64,48.16 208.77,48.28 209.72,48.28
NVVDD_HG1 on IN1 (solid shape): 209.96,43.39 209.96,41.42 209.7,41.16 209.07,41.16 208.81,41.42 208.81,43.7 209.07,43.96 209.39,43.96
NVVDD_HG2 on BOTTOM (solid shape): 194.13,37.62 194.13,37.36 194.01,37.24 193.18,37.24 192.55,37.87 192.55,38.31 192.74,38.51 193.24,38.51
NVVDD_HG2 on BOTTOM (solid shape): 193.31,43.9 193.31,43.08 193.12,42.89 192.29,42.89 192.17,43.01 192.17,43.71 192.61,44.16 193.05,44.16
NVVDD_HG2 on BOTTOM (solid shape): 197.88,31.71 198.83,31.71 198.9,31.65 198.9,31.52 198.83,31.46 197.94,31.46 197.75,31.27 196.93,31.27 196.8,31.39 196.8,31.65 196.93,31.77 197.82,31.77
NVVDD_HG2 on IN1 (solid shape): 193.31,43.2 193.31,42 192.99,41.68 192.86,41.68 192.17,42.38 192.17,43.2 192.36,43.39 193.12,43.39
NVVDD_HG2 on IN1 (solid shape): 194.01,38.66 194.01,37.71 194.51,37.2 194.51,36.63 194.13,36.25 193.88,36.25 192.99,37.14 192.99,38.6 193.24,38.85 193.82,38.85
NVVDD_HG2 on IN1 (solid shape): 197.88,32.79 197.88,31.39 197.75,31.27 196.93,31.27 196.8,31.39 196.8,32.85 196.93,32.98 197.69,32.98
NVVDD_LG1 on BOTTOM (solid shape): 204.12,48.15 204.12,47.96 203.86,47.71 203.86,47.2 203.67,47.01 203.15,47.01 203.01,47.14 203.01,48.17 203.15,48.31 203.96,48.31
NVVDD_LG1 on BOTTOM (solid shape): 204.18,42.5 204.18,42.31 203.93,42.05 203.93,41.55 203.73,41.36 203.21,41.36 202.96,41.61 202.96,42.51 203.1,42.66 204.02,42.66
NVVDD_LG1 on BOTTOM (solid shape): 201.18,34.5 201.18,33.68 200.99,33.49 200.93,33.49 200.61,33.17 200.61,32.47 200.55,32.41 200.42,32.41 200.36,32.47 200.36,33.3 200.67,33.62 200.67,34.5 200.8,34.63 201.06,34.63
NVVDD_LG1 on IN1 (solid shape): 202.2,35.14 202.2,34.63 201.06,33.49 200.8,33.49 200.67,33.62 200.67,34.5 201.5,35.33 202.01,35.33
NVVDD_LG1 on IN1 (solid shape): 204.12,48.15 204.12,46.69 203.86,46.44 203.1,46.44 202.97,46.56 202.97,48.21 203.1,48.34 203.93,48.34
NVVDD_LG1 on IN1 (solid shape): 203.93,43.45 204.18,43.2 204.18,41.23 203.86,40.91 203.29,40.91 202.97,41.23 202.97,43.9 203.16,44.09 203.93,44.09
NVVDD_LG2 on BOTTOM (solid shape): 199,38.25 199,37.36 198.88,37.24 197.99,37.24 197.86,37.36 197.86,37.74 198.24,38.12 198.24,38.31 198.43,38.51 198.75,38.51
NVVDD_LG2 on BOTTOM (solid shape): 199.02,43.9 199.02,43.01 198.9,42.89 198.01,42.89 197.88,43.01 197.88,43.39 198.26,43.78 198.26,43.97 198.45,44.16 198.77,44.16
NVVDD_LG2 on BOTTOM (solid shape): 199.53,34.44 199.53,33.62 199.79,33.36 199.79,32.47 199.72,32.41 199.59,32.41 199.53,32.47 199.53,33.17 199.02,33.68 199.02,34.44 199.15,34.57 199.4,34.57
NVVDD_LG2 on IN1 (solid shape): 198.96,38.31 198.96,36.6 198.71,36.35 198.2,36.35 197.88,36.66 197.88,38.44 198.01,38.57 198.71,38.57
NVVDD_LG2 on IN1 (solid shape): 199.02,43.27 199.02,42.12 198.64,41.74 198.13,41.74 197.88,42 197.88,43.27 198.01,43.39 198.9,43.39
NVVDD_LG2 on IN1 (solid shape): 199.59,35.46 199.59,33.62 199.47,33.49 198.77,33.49 198.58,33.68 198.58,35.39 198.83,35.65 199.4,35.65
NVVDD_SW1 on TOP (solid shape): 206.71,36.41 206.71,35.14 206.64,35.08 205.25,35.08 205.12,35.2 205.12,36.35 205.25,36.47 206.64,36.47
NVVDD_SW1 on BOTTOM (solid shape): 209.56,52.79 209.56,49.43 208.93,48.79 208.17,48.79 206.9,47.52 206.9,36.47 205.75,35.33 204.42,35.33 204.17,35.58 202.96,35.58 202.52,35.14 202.52,33.81 201.12,32.41 200.8,32.41 200.74,32.47 200.74,33.11 200.86,33.23 201.06,33.23 201.82,34 201.82,35.77 202.52,36.47 203.4,36.47 204.17,37.24 204.17,42 204.36,42.19 204.36,42.63 204.23,42.76 204.23,47.59 204.36,47.71 204.36,48.25 203.21,49.39 203.21,52.6 203.85,53.24 209.12,53.24
NVVDD_SW1 on IN2 (solid shape): 207.73,49.37 207.73,35.41 207.42,35.1 204.61,35.1 203.67,36.05 203.67,41.93 203.7,42.01 203.79,42.03 204.21,42.38 203.79,42.73 203.7,42.75 203.67,42.83 203.67,47.64 203.7,47.72 203.79,47.74 204.2,48.15 203.69,48.41 203.65,48.39 203.65,49.32 204.03,49.69 207.41,49.69
NVVDD_SW1 on IN3 (solid shape): 207.73,49.23 207.73,35.41 207.42,35.1 204.61,35.1 203.67,36.05 203.67,41.93 203.7,42.01 203.79,42.03 204.21,42.38 203.79,42.73 203.7,42.75 203.67,42.83 203.67,47.79 204.21,48.09 203.67,48.4 203.67,49.09 204.13,49.55 207.41,49.55
NVVDD_SW1 on IN4 (solid shape): 207.55,48.65 207.55,35.92 206.93,35.29 204.42,35.29 203.67,36.05 203.67,41.93 203.7,42.01 203.79,42.03 204.21,42.38 203.79,42.73 203.7,42.75 203.67,42.83 203.67,47.25 203.72,47.3 203.72,47.76 204.21,48.09 203.72,48.43 203.72,48.94 204.28,49.5 206.7,49.5
NVVDD_SW1 on IN5 (solid shape): 207.73,49.16 207.73,35.41 207.42,35.1 204.61,35.1 203.67,36.05 203.67,41.93 203.7,42.01 203.79,42.03 204.21,42.38 203.79,42.73 203.7,42.75 203.67,42.83 203.67,47.79 204.21,48.09 203.67,48.4 203.67,49.28 203.83,49.44 207.45,49.44
NVVDD_SW2 on TOP (solid shape): 197.82,36.35 197.82,35.2 197.69,35.08 195.91,35.08 195.72,35.27 195.72,36.28 195.91,36.47 197.69,36.47
NVVDD_SW2 on BOTTOM (solid shape): 199.15,52.92 199.15,49.62 197.88,48.35 197.88,43.71 197.69,43.52 197.69,42.95 197.88,42.76 197.88,38.06 197.69,37.87 197.69,37.24 198.9,36.03 198.9,33.62 199.4,33.11 199.4,32.47 199.34,32.41 199.09,32.41 198.2,33.3 198.2,35.27 197.75,35.71 196.04,35.71 195.21,36.54 195.21,47.78 193.05,49.94 193.05,52.73 193.63,53.3 198.77,53.3
NVVDD_SW2 on IN2 (solid shape): 198.24,48.95 198.24,43.6 198.21,43.53 198.14,43.5 197.78,43.14 198.14,42.78 198.21,42.75 198.24,42.68 198.24,37.95 198.21,37.87 198.13,37.85 197.76,37.49 198.13,37.13 198.21,37.11 198.24,37.03 198.24,36.01 197.88,35.66 194.97,35.66 194.45,36.18 194.45,48.73 195.01,49.29 197.91,49.29
NVVDD_SW2 on IN3 (solid shape): 198.24,48.83 198.24,43.6 198.21,43.53 198.14,43.5 197.78,43.14 198.14,42.78 198.21,42.75 198.24,42.68 198.24,37.95 198.21,37.87 198.13,37.85 197.76,37.49 198.13,37.13 198.21,37.11 198.24,37.03 198.24,36.01 197.88,35.66 194.97,35.66 194.45,36.18 194.45,49 194.74,49.29 197.78,49.29
NVVDD_SW2 on IN4 (solid shape): 198.24,49.09 198.24,43.6 198.21,43.53 198.14,43.5 197.78,43.14 198.14,42.78 198.21,42.75 198.24,42.68 198.24,37.95 198.21,37.87 198.13,37.85 197.76,37.49 198.13,37.13 198.21,37.11 198.24,37.03 198.24,36.01 197.88,35.66 194.97,35.66 194.45,36.18 194.45,48.73 195,49.27 198.06,49.27
NVVDD_SW2 on IN5 (solid shape): 198.24,48.87 198.24,43.6 198.21,43.53 198.14,43.5 197.78,43.14 198.14,42.78 198.21,42.75 198.24,42.68 198.24,37.95 198.21,37.87 198.13,37.85 197.76,37.49 198.13,37.13 198.21,37.11 198.24,37.03 198.24,36.01 197.88,35.66 194.97,35.66 194.45,36.18 194.45,48.86 194.86,49.26 197.84,49.26
NVVDDS_B+ on TOP (solid shape): 235.54,47.71 238.14,47.71 238.27,47.59 238.27,45.68 238.14,45.55 231.03,45.55 229.88,46.7 223.47,46.7 221.88,45.11 221.88,39.84 221.5,39.46 217.57,39.46 217.37,39.65 217.37,43.01 218.39,43.01 218.39,42.63 218.58,42.44 219.6,42.44 219.79,42.63 219.79,43.01 219.6,43.2 218.58,43.2 218.39,43.01 217.37,43.01 217.37,47.71 217.5,47.84 220.3,47.84 221.2,48.74 221.22,48.72 221.26,48.69 221.31,48.67 221.36,48.65 221.41,48.64 221.47,48.64 221.52,48.65 221.57,48.66 221.62,48.68 221.67,48.71 221.71,48.75 221.74,48.79 221.77,48.84 221.79,48.89 221.8,48.94 221.81,48.99 221.8,49.05 221.79,49.1 221.77,49.15 221.76,49.17 234.08,49.17
NVVDDS_B+ on BOTTOM (solid shape): 226.46,50.89 226.46,48.03 225.95,47.52 223.66,47.52 221.88,45.74 221.88,38.23 221.14,37.49 219.87,37.49 219.76,37.37 219.76,35.85 219.53,35.62 216.37,35.62 216.28,35.71 216.28,37.27 217.18,38.17 217.18,42.25 217.25,42.32 217.76,42.32 217.95,42.12 217.95,41.62 218.2,41.36 219.72,41.36 219.91,41.55 219.91,43.2 219.72,43.39 217.37,43.39 217.18,43.59 217.18,47.71 217.25,47.78 217.76,47.78 217.82,47.71 217.82,47.08 218.01,46.89 219.28,46.89 219.85,47.46 219.85,50.17 220.31,50.17 220.31,48.98 220.67,48.62 221.63,48.62 221.65,48.65 221.66,48.65 222.13,49.11 222.13,50.18 222.04,50.27 222.04,50.29 222.01,50.29 221.99,50.32 220.46,50.32 220.43,50.29 220.38,50.29 220.38,50.24 220.31,50.17 219.85,50.17 219.85,50.64 220.29,51.08 226.26,51.08
NVVDDS_B+ on IN4 (solid shape): 235.55,47.59 235.55,45.81 235.3,45.55 231.03,45.55 229.88,46.7 223.47,46.7 221.88,45.11 221.88,39.84 221.5,39.46 217.57,39.46 217.37,39.65 217.37,43.01 218.39,43.01 218.39,42.63 218.58,42.44 219.6,42.44 219.79,42.63 219.79,43.01 219.6,43.2 218.58,43.2 218.39,43.01 217.37,43.01 217.37,47.71 217.5,47.84 220.3,47.84 221.2,48.74 221.22,48.72 221.26,48.69 221.31,48.67 221.36,48.65 221.41,48.64 221.47,48.64 221.52,48.65 221.57,48.66 221.62,48.68 221.67,48.71 221.71,48.75 221.74,48.79 221.77,48.83 221.79,48.88 221.8,48.94 221.81,48.99 221.81,49.04 221.79,49.1 221.77,49.15 221.76,49.17 221.85,49.17 233.97,49.17
NVVDDS_BST1 on BOTTOM (solid shape): 216.87,32.54 216.87,31.69 216.86,31.68 215.92,31.68 215.83,31.77 214.26,31.77 214.2,31.84 214.2,32.09 214.33,32.22 215.34,32.22 215.72,32.6 216.8,32.6
NVVDDS_HG1 on BOTTOM (solid shape): 219.47,48.35 219.47,47.59 219.22,47.33 218.52,47.33 218.33,47.52 218.33,48.41 218.45,48.54 219.28,48.54
NVVDDS_HG1 on BOTTOM (solid shape): 219.66,42.87 219.66,42.05 219.41,41.79 218.71,41.79 218.52,41.99 218.52,42.94 218.64,43.06 219.47,43.06
NVVDDS_HG1 on BOTTOM (solid shape): 215.83,31.55 216.27,31.55 216.3,31.52 216.3,31.26 216.11,31.08 215.42,31.08 215.17,31.33 214.26,31.33 214.2,31.39 214.2,31.52 214.26,31.58 215.79,31.58
NVVDDS_HG1 on IN1 (solid shape): 219.47,48.41 219.47,47.2 219.28,47.01 218.45,47.01 218.26,47.2 218.26,48.41 218.39,48.54 219.34,48.54
NVVDDS_HG1 on IN1 (solid shape): 216.93,32.28 216.93,31.84 216.16,31.06 215.3,31.06 215.22,31.15 215.22,31.71 216.36,32.85
NVVDDS_HG1 on IN1 (solid shape): 219.66,43.78 219.66,41.81 219.41,41.55 218.77,41.55 218.52,41.81 218.52,44.09 218.77,44.35 219.09,44.35
NVVDDS_LG1 on BOTTOM (solid shape): 213.82,48.41 213.82,48.22 213.56,47.97 213.56,47.46 213.37,47.27 212.85,47.27 212.6,47.52 212.6,48.43 212.74,48.57 213.66,48.57
NVVDDS_LG1 on BOTTOM (solid shape): 213.88,42.87 213.88,42.68 213.63,42.43 213.63,41.92 213.44,41.73 212.91,41.73 212.66,41.99 212.66,42.89 212.8,43.03 213.72,43.03
NVVDDS_LG1 on BOTTOM (solid shape): 213.82,34.25 213.82,33.38 213.56,33.12 213.56,32.35 213.5,32.28 213.37,32.28 213.31,32.35 213.31,34.21 213.48,34.38 213.69,34.38
NVVDDS_LG1 on IN1 (solid shape): 213.82,48.35 213.82,46.89 213.56,46.63 212.8,46.63 212.68,46.76 212.68,48.41 212.8,48.54 213.63,48.54
NVVDDS_LG1 on IN1 (solid shape): 213.88,33.43 213.69,33.23 213.37,33.23 213.25,33.36 213.25,34.06 212.87,34.44 212.87,35.2 213.88,35.2
NVVDDS_LG1 on IN1 (solid shape): 213.63,43.59 213.88,43.33 213.88,41.36 213.56,41.05 212.99,41.05 212.68,41.36 212.68,44.03 212.87,44.22 213.63,44.22
NVVDDS_SW1 on TOP (solid shape): 215.47,36.16 215.47,33.74 215.34,33.62 214.77,33.62 214.64,33.74 214.64,36.16 214.77,36.28 215.34,36.28
NVVDDS_SW1 on BOTTOM (solid shape): 219.66,52.86 219.66,49.87 219.09,49.3 218.14,49.3 216.68,47.84 216.68,38.06 216.49,37.87 215.98,37.87 215.47,37.36 215.47,35.84 215.19,35.56 215.19,33.46 214.01,32.28 213.76,32.28 213.69,32.35 213.69,33.04 213.95,33.3 213.95,34.38 213.89,34.44 213.89,37.99 213.88,38 213.88,42 214.07,42.19 214.07,43.01 213.88,43.2 213.88,47.78 214.01,47.9 214.01,48.92 213.44,49.49 213.44,52.79 213.88,53.24 219.28,53.24
NVVDDS_SW1 on IN2 (solid shape): 217.19,49 217.19,33.98 216.56,33.35 214.54,33.35 213.9,33.99 213.91,34.02 213.89,34.27 213.71,34.45 213.68,34.46 213.68,42.42 213.72,42.43 213.98,42.77 213.72,43.12 213.68,43.13 213.68,47.95 213.92,48.28 213.68,48.62 213.68,49.01 214.09,49.42 216.77,49.42
NVVDDS_SW1 on IN3 (solid shape): 217.19,49.02 217.19,33.74 216.8,33.35 214.54,33.35 213.9,33.99 213.91,34.02 213.89,34.27 213.71,34.45 213.68,34.46 213.68,42.42 213.72,42.43 213.98,42.77 213.72,43.12 213.68,43.13 213.68,47.95 213.92,48.28 213.68,48.62 213.68,49 214.12,49.44 216.77,49.44
NVVDDS_SW1 on IN4 (solid shape): 216.93,48.94 216.93,34.18 216.1,33.35 214.54,33.35 213.9,33.99 213.91,34.02 213.89,34.27 213.71,34.45 213.68,34.46 213.68,42.42 213.72,42.43 213.98,42.77 213.72,43.12 213.68,43.13 213.68,47.95 213.92,48.28 213.68,48.62 213.68,48.96 213.99,49.26 216.6,49.26
NVVDDS_SW1 on IN5 (solid shape): 216.93,48.99 216.93,34.18 216.1,33.35 214.54,33.35 213.9,33.99 213.91,34.02 213.89,34.27 213.71,34.45 213.68,34.46 213.68,42.42 213.72,42.43 213.98,42.77 213.72,43.12 213.68,43.13 213.68,47.95 213.92,48.28 213.68,48.62 213.68,49.21 213.97,49.5 216.42,49.5
ON/OFF# on TOP (solid shape): 173.01,162.53 173.01,160.34 172.98,160.33 172.86,160.25 172.78,160.11 172.77,159.91 172.88,159.73 172.91,159.66 172.89,159.58 172.79,159.43 172.78,159.26 172.8,159.18 172.85,159.1 172.86,159 172.77,158.94 172.76,158.94 172.44,158.61 172.7,158.24 172.8,158.23 172.89,158.24 172.97,158.22 173.01,158.14 173.01,156.52 172.8,156.31 172.53,156.31 172.34,156.5 172.34,157.97 172.2,158.11 172.2,160.21 172.32,160.33 172.32,161.72 171.98,162.06 171.37,162.06 171.32,162.11 171.32,162.61 171.41,162.7 172.84,162.7
OUT_A on TOP (solid shape): 28.22,18.08 28.22,17.27 29.12,16.37 29.12,16.08 29.04,16 28.63,16 28,16.62 28,18.08 28.05,18.13 28.17,18.13
OUT_A on BOTTOM (solid shape): 29,18.58 29,17.66 28.91,17.58 28.73,17.58 28.58,17.42 28.58,16.91 29.21,16.27 29.21,15.3 29.86,14.65 29.86,13.82 29.79,13.76 28.52,13.76 28.33,13.95 28.33,15.94 27.79,16.48 27.79,17.7 28.26,18.17 28.26,18.57 28.33,18.64 28.94,18.64
OUT_B on TOP (solid shape): 27.02,18.06 27.02,17.26 28.53,15.74 28.81,15.74 29.17,15.38 29.17,12.98 28.49,12.98 28.35,13.12 28.35,14.6 28.06,14.9 27.51,14.9 27.36,15.05 27.36,16.21 27.13,16.44 27.13,16.83 26.81,17.14 26.81,18.06 26.86,18.11 26.97,18.11
OUT_C on TOP (solid shape): 25.01,18.07 25.01,17.13 24.52,16.64 24.52,15.05 24.42,14.95 24.09,14.95 23.75,14.6 23.75,13.05 23.7,13 23.19,13 23.13,13.07 23.13,14.8 23.49,15.16 23.49,15.93 24.81,17.25 24.81,18.07 24.86,18.12 24.96,18.12
OUT_D on TOP (solid shape): 23.82,18.09 23.82,17.16 23.88,17.1 23.88,16.54 23.35,16 23.04,16 22.92,16.13 22.92,16.39 23.61,17.08 23.61,18.09 23.65,18.12 23.78,18.12
OUT_D on BOTTOM (solid shape): 23.82,16.81 23.82,16.49 23.31,15.97 22.82,15.97 22.56,15.71 22.56,13.74 22.32,13.51 21.92,13.51 21.79,13.63 21.79,16.68 22.11,17 23.63,17
P1 on TOP (solid shape): 51.95,47.59 51.96,47.59 52.27,47.27 52.27,46 53.22,45.06 53.22,42.69 52.9,42.37 50.8,42.37 48.77,44.4 48.77,47.32 48.9,47.45 49.92,47.45 50.23,47.77 51.77,47.77
P1 on BOTTOM (solid shape): 51.31,47.58 53.03,47.58 53.19,47.41 53.19,46.81 53.19,46.78 53.19,46.74 53.19,42.81 52.75,42.37 51.95,42.37 51.44,42.88 50.8,42.88 50.68,43 50.68,43.64 50.23,44.08 50.23,44.97 49.66,45.54 48.9,45.54 48.77,45.67 48.77,48.66 48.9,48.78 50.11,48.78
P1 on IN1 (solid shape): 53.22,47.26 53.22,46.92 53.19,46.78 53.22,46.64 53.22,42.69 52.9,42.37 50.8,42.37 48.77,44.4 48.77,47.32 49.22,47.77 52.71,47.77
P1 on IN2 (solid shape): 53.22,47.26 53.22,46.92 53.19,46.78 53.22,46.64 53.22,42.69 52.9,42.37 50.8,42.37 48.77,44.4 48.77,47.32 49.22,47.77 52.71,47.77
P1 on IN3 (solid shape): 53.22,47.26 53.22,46.92 53.19,46.78 53.22,46.64 53.22,42.69 52.9,42.37 50.8,42.37 48.77,44.4 48.77,47.32 49.22,47.77 52.71,47.77
P1 on IN4 (solid shape): 53.22,47.26 53.22,46.92 53.19,46.78 53.22,46.64 53.22,42.69 52.9,42.37 50.8,42.37 49.04,44.14 49.04,47.2 49.61,47.77 52.71,47.77
P1 on IN5 (solid shape): 53.22,47.26 53.22,46.92 53.19,46.78 53.22,46.64 53.22,42.69 52.9,42.37 50.8,42.37 48.77,44.4 48.77,47.32 49.22,47.77 52.71,47.77
P2 on BOTTOM (solid shape): 54.48,49.42 54.56,49.39 54.59,49.31 54.94,48.94 55.3,49.31 55.33,49.39 55.4,49.42 56.77,49.42 56.78,49.37 57.13,49.04 57.49,49.37 57.49,49.42 58.42,49.42 58.56,49.28 58.56,46.63 58.74,46.44 58.74,44.46 57.73,43.45 57.73,42.91 57.14,42.91 56.78,42.56 57.14,42.2 57.73,42.2 57.73,41.67 57.54,41.48 54.61,41.48 53.98,42.12 53.98,48.97 54.42,49.42
PQ703_S on TOP (solid shape): 63.17,27.62 63.17,25.1 63.44,24.83 64.91,24.83 65.03,24.72 65.03,23.95 64.84,23.76 64.46,23.76 64.15,23.46 64.15,22.41 62.96,21.22 61.81,21.22 61.48,21.55 61.48,27.2 61.99,27.71 63.07,27.71
PQ703_S on BOTTOM (solid shape): 66.18,27.4 66.18,27.03 66.36,26.85 66.36,26.22 65.82,26.22 65.46,25.86 65.82,25.5 66.42,25.5 66.43,25.5 66.43,24.65 66.11,24.34 63.51,24.34 63.2,24.02 63.2,21.61 62.71,21.13 57.32,21.13 56.94,21.51 56.94,26.54 57.2,26.79 57.27,26.82 57.35,26.79 57.78,26.72 57.95,27.13 57.97,27.22 58.05,27.26 58.75,27.26 58.83,27.22 58.85,27.13 59.19,26.68 59.54,27.13 59.55,27.22 59.64,27.26 61.89,27.26 62.37,27.73 62.62,27.73 62.62,27.99 63.17,28.54 65.05,28.54
PWR_B# on TOP (solid shape): 170.97,162.63 170.97,156.49 170.8,156.32 170.5,156.32 170.32,156.49 170.32,158.84 170.5,159.01 170.51,159.16 170.51,159.24 170.5,159.28 170.5,159.4 170.26,159.64 170.26,162.62 170.35,162.71 170.88,162.71
PWR_G# on TOP (solid shape): 171.99,161.77 171.99,159.09 171.95,159.01 171.87,158.99 171.45,158.64 171.87,158.29 171.95,158.26 171.99,158.19 171.99,156.49 171.8,156.31 171.52,156.31 171.32,156.5 171.32,157.91 171.17,158.06 171.17,160.11 171.32,160.26 171.32,161.77 171.46,161.91 171.85,161.91
PWR_R# on TOP (solid shape): 170,162.62 170,159.7 170.37,159.33 170.37,159.07 170,158.7 170,156.54 169.79,156.32 169.51,156.32 169.27,156.57 169.27,162.61 169.37,162.71 169.91,162.71
PWR_VGA_CORE_BOOT1 on TOP (solid shape): 253.13,61.03 253.13,60.22 252.93,60.03 252.93,60.02 252.9,59.98 252.9,58.47 252.87,58.44 252.25,58.44 252.19,58.51 252.19,60.49 252.78,61.09 253.07,61.09
PWR_VGA_CORE_BOOT1_1 on TOP (solid shape): 251.55,59.36 251.55,58.55 251.47,58.48 249.47,58.48 249.39,58.56 249.39,59.36 249.46,59.43 251.48,59.43
PWR_VGA_CORE_BOOT2 on TOP (solid shape): 253,65.94 253,64.29 253.13,64.15 253.13,63.33 253.08,63.27 252.93,63.27 252.24,63.97 252.24,65.94 252.3,66 252.93,66
PWR_VGA_CORE_BOOT2_1 on TOP (solid shape): 251.6,65.94 251.6,65.18 251.54,65.11 250.9,65.11 250.84,65.18 249.7,65.18 249.63,65.24 249.63,65.87 249.76,66 251.54,66
PWR_VGA_CORE_LGATE1 on TOP (solid shape): 238.27,60.98 238.27,59.71 238.14,59.59 237.31,59.59 237.12,59.78 237.12,60.79 237.38,61.05 238.2,61.05
PWR_VGA_CORE_LGATE1 on TOP (solid shape): 252.73,61.83 252.73,61.73 252.67,61.67 251.65,61.67 251.09,61.11 249.82,61.11 249.76,61.17 249.76,61.75 249.9,61.88 252.67,61.88
