# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CALDERA_RST#: length 315.2
  TOP w0.114: v2(68.85,2.42) 68.55,2.42 68.15,2.82 UE6.16
  IN4 w0.137: v2(147.97,12.85) 147.97,13.22 148.56,13.81 150.88,13.81 151.59,14.51 151.59,33.29 150.82,34.06 150.82,42.82 151.14,43.15 151.14,48.67 152.98,50.51 152.98,55.64 151.53,57.1 151.53,67.1 153.45,69.02 153.45,82.55 157.98,87.08 161.09,87.08 164.95,90.94 169.1,90.94 170.77,92.61 170.77,100.67 169.56,101.88 169.56,139.41 ; v2(129.68,165.18) 130.2,164.65 131.46,164.65 133,163.12 136.12,163.12 137.36,164.35 142.99,164.35 144.25,163.09 145.81,163.09 146.76,162.14 162.84,162.14 164.59,163.89 167.2,163.89 168.19,162.9 171.96,162.9 175.91,158.95 175.91,154.07 176.86,153.12 176.86,146.71
  IN4 w0.147: 169.56,139.41 176.86,146.71
  IN5 w0.097: v2(68.85,2.42) 68.96,2.42 70.25,3.71 71.9,3.71 73.46,2.14 79.46,2.14 83.73,6.41 93.71,6.41 94.82,7.52 100.02,7.52 100.74,8.23 110.48,8.23 112.44,10.18 121.55,10.18 121.93,10.57 121.93,12.34 122.64,13.04 122.64,15.87 122.86,16.09 124.35,16.09 125.27,17.01 145.81,17.01 147.97,14.86 v2(147.97,12.85)
  BOTTOM w0.114: UM3.1 129.41,166 RM6.2 129.5,165.9 129.5,165.35 v2(129.68,165.18)
CAPS: length 4.8
  BOTTOM w0.114: JKB.3 v1(180.5,12.95) 180.8,13.25 180.8,15.77 RE639.1
CAPS_LED: length 107.5
  TOP w0.114: v2(177.26,12.61) v1(177.26,11.92) ; v2(94.08,11.39) 94.08,12.4 93.81,12.66 93.81,16.97 92.91,17.88 91.74,17.88 90.67,18.95 UE5.91
  IN3 w0.124: v2(177.26,12.61) 175.34,10.69 162.13,10.69 158.57,14.25 150.83,14.25 150.19,13.61 147.89,13.61 145.54,11.26 140.73,11.26 136.69,7.23 130.47,7.23 129.68,6.44 99.2,6.44 94.25,11.39 v2(94.08,11.39)
  BOTTOM w0.114: v2(177.26,12.61) 177.26,12.66 178.69,14.09 178.69,15.79 RE640.1
CDR_BTN#: length 212.8
  TOP w0.114: UE5.120 87.92,10.54 88.15,10.78 88.15,10.92 89.12,11.89 89.56,11.89 89.95,12.28 v2(89.95,12.85)
  IN5 w0.097: v2(131.13,166.75) 130.16,165.79 128.06,165.79 127.39,165.12 127.39,165.11 127.33,165.05 127.33,165.03 127.32,165.03 127.32,164.66 122.85,160.18 117.35,160.18 109.8,152.63 109.8,151.59 108.33,150.11 108.17,150.11 105.57,147.52 89.22,147.52 87.48,145.78 85.99,145.78 84.07,143.86 84.07,93.61 82.57,92.12 82.57,61.81 76.79,56.03 76.79,51.6 74.3,49.11 74.3,22.41 77.03,19.68 80.56,19.68 82.32,17.93 82.91,17.93 83.17,18.19 85.8,18.19 88.79,15.2 88.79,14.46 89.95,13.29 v2(89.95,12.85)
  BOTTOM w0.114: JCDRA.26 129.85,169.75 v1(130.81,168.79) 130.81,168.36 RM17.2 130.37,167.76 130.63,167.49 131,167.49 131.13,167.37 v2(131.13,166.75)
CDR_I2C_CLK: length 15.7
  TOP w0.114: RM97.2 144.81,167.47 144.92,167.47 145.18,167.73 145.18,168.54 144.76,168.96 141.46,168.96 140.12,170.29 138.55,170.29 138.17,169.91 138.17,169.54 v2(138,169.38)
  BOTTOM w0.114: JCDRA.45 137.7,170.06 138.07,169.69 138.07,169.45 v2(138,169.38) 138.04,169.38 138.23,169.19 138.23,168.95 137.86,168.58 v4(136.83,168.58) 136.58,168.58 136.26,168.26 136.26,167.98 135.78,167.5 RM89.2
CDR_I2C_DAT: length 14.5
  TOP w0.114: v2(138.63,169.38) 138.38,169.63 138.38,169.82 138.63,170.08 140.03,170.08 141.37,168.74 144.67,168.74 144.96,168.45 144.96,167.83 144.83,167.7 144.58,167.7 RM98.2
  BOTTOM w0.114: RM90.2 136.67,167.73 136.48,167.92 136.48,168.17 136.64,168.34 137.11,168.34 137.14,168.36 137.99,168.36 v4(138.24,168.62) 138.44,168.82 138.44,169.19 v2(138.63,169.38) 138.34,169.67 138.34,169.79 138.5,169.95 JCDRA.46
CDR_ON_ELC: length 295.2
  TOP w0.114: v2(260.26,43.38) UE1.27
  IN2 w0.097: v2(124.82,142.9) 127.73,139.99 150.62,139.99 152.79,137.82 v2(152.79,137.37)
  IN3 w0.124: v2(152.79,137.37) 157.68,142.26 172.68,142.26 175.11,144.69 189.16,144.69 189.46,144.38 197.41,144.38 198.41,143.38 233.42,143.38 237.02,146.99 237.02,152.77 237.56,153.3 237.56,155.76 237.9,156.11 243.66,156.11 246.06,153.71 246.06,103.29 246.42,102.94 246.42,94.44 245.98,94 245.98,90.98 247.71,89.25 247.71,88.75 249.38,87.08 249.38,72.35 253.06,68.67 255.92,68.67 258.28,66.31 258.28,63.26 ; 266.02,51.27 259.7,57.59
  IN3 w0.137: 266.02,51.27 266.02,49.14 v2(260.26,43.38) ; 258.28,63.26 256.79,61.78 256.79,59.03 258.24,57.59 259.7,57.59
  IN5 w0.097: v2(124.82,142.9) 124.82,143.33 122.18,145.97 120.79,145.97 116.3,150.45 116.3,151.8 v2(116.97,152.48)
  BOTTOM w0.114: v2(116.97,152.48) 115.89,152.48 114.84,153.53 v1(114.84,158.49) 114.84,162.38 117.81,165.36 UM7.4
CDR_TXRX_GOOD: length 228
  TOP w0.114: UE6.18 69.15,3.69 v2(68.91,3.45)
  IN4 w0.137: v2(116.51,168.53) 116.41,168.43 116.41,167.69 113.87,165.15 113.87,160.69 106.33,153.15 106.33,147.89 104.38,145.95 100.15,145.95 99.26,145.06 99.26,143.47 98.82,143.03 97.44,143.03 v2(97.03,143.44) ; v2(90.06,24.24) 90.81,23.48 90.81,21.56 89.83,20.58 89.83,16.58 90.64,15.77 90.64,12.98 90,12.34 90,11.11 89.27,10.38 88.38,10.38 86.72,8.71 81.49,8.71 77.86,5.09 70.88,5.09 69.24,3.45 v2(68.91,3.45)
  IN5 w0.097: v2(97.03,143.44) 94.61,143.44 94.24,143.81 92.78,143.81 92.22,143.25 87.67,143.25 87.09,142.66 87.09,141.74 86.15,140.81 86.15,91.82 84.68,90.36 84.68,60.76 78.87,54.94 78.87,49.41 76.37,46.91 76.37,23.36 77.18,22.55 87.76,22.55 89.44,24.24 v2(90.06,24.24)
  BOTTOM w0.114: UM7.1 v2(116.51,168.53) ; v2(90.06,24.24) v1(90.66,24.24)
CDRA_LED RED: length 8.3
  BOTTOM w0.114: QM3.1 132.33,163.83 131.54,164.61 v1(131.54,165) 131.54,167.44 131.15,167.84 131.15,169.01 130.65,169.5 JCDRA.28
CDRA_LED RED_MOS: length 207.8
  TOP w0.114: UE5.126 88.14,8.14 88.34,8.34 89.21,8.34 89.82,8.95 89.82,10.2 89.94,10.32 89.94,11.96 90.39,12.41 90.39,13.66 v2(89.21,14.84)
  IN5 w0.097: v2(89.21,14.84) 89.21,15.09 85.92,18.38 83.3,18.38 81.6,20.08 77.37,20.08 74.72,22.73 74.72,47.84 77.27,50.38 77.27,55.87 83,61.6 83,91.2 84.47,92.67 84.47,143.55 86.16,145.24 87.6,145.24 89.34,146.98 106.88,146.98 109.04,149.14 110.18,149.14 115.53,154.49 115.53,155.41 115.8,155.68 116.22,155.68 117.46,156.92 120.26,156.92 122.88,159.54 122.88,159.65 125.63,162.41 128.36,162.41 128.69,162.08 v2(128.69,161.34)
  BOTTOM w0.114: v2(128.69,161.34) 128.91,161.12 QM2.5 ; v2(89.21,14.84) 89.21,14.85 v1(88.8,15.26)
CDRA_LED RED_R: length 4.7
  BOTTOM w0.114: RM93.2 132.23,160.83 131.96,161.1 QM3.3 131.13,161.1 130.43,160.4 v1(130.43,159.37)
CDRA_LED WHITE: length 13.4
  IN1 w0.097: v2(125.71,165.77) 125.71,166.17 126.25,166.71 126.63,166.71 127.9,167.98 127.9,170.9 v2(129.18,172.18)
  BOTTOM w0.114: v2(125.71,165.77) 126.01,165.77 126.46,165.33 v1(126.46,165.26) 126.46,164.95 125.67,164.16 QM1.1 ; v2(129.18,172.18) 129.91,172.18 130.25,171.83 JCDRA.27
CDRA_LED WHITE_MOS: length 215.7
  TOP w0.114: v2(96.98,14.48) 97.08,14.48 97.49,14.07 97.49,13.5 96.88,12.9 96.88,8.31 96.67,8.1 UE5.21
  IN5 w0.097: v2(96.98,14.48) 96.88,14.48 96.85,14.5 90.12,14.5 86.04,18.58 83.42,18.58 81.72,20.28 77.49,20.28 74.99,22.78 74.99,47.74 77.48,50.24 77.48,55.77 83.2,61.48 83.2,91.08 84.69,92.57 84.69,143.11 86.6,145.02 87.68,145.02 89.42,146.76 106.98,146.76 109.11,148.89 110.25,148.89 115.91,154.55 v2(115.91,155.15)
  BOTTOM w0.114: QM2.2 128.91,162.42 128.62,162.71 126.49,162.71 126.28,162.5 118.21,162.5 116.47,160.76 116.47,155.71 v2(115.91,155.15) ; v1(96.98,14.98) 96.98,14.48 v2(96.98,14.48)
CDRA_LED WHITE_R: length 4.1
  BOTTOM w0.114: v1(123.1,162.14) 123.24,162.28 124.25,162.28 124.71,161.82 QM1.3 124.71,160.03 RM91.2
CDRA_RST#: length 3.3
  BOTTOM w0.114: JCDRA.22 128.25,169.05 v1(127.99,168.79) 127.44,168.24 127.38,168.24 127.13,167.98 UM3.4
CFG0: length 52.5
  TOP w0.114: v2(81.66,74.44) 80.36,74.44 79.94,74.86 74.62,74.86 73.97,74.21 JPCMC.1
  IN2 w0.089: 102.73,89.66 103.01,89.94 103.01,90.49 102.73,90.77 102.73,97.4 102.56,97.58 102.56,100.92 103.7,102.06 104.27,102.06 105.11,102.9 v2(105.11,102.95)
  IN2 w0.097: v2(81.66,74.44) 81.66,74.46 85.23,78.03 90.82,78.03 91.18,78.38 91.92,78.38 100.1,86.57 100.1,87.03 102.73,89.66
  BOTTOM w0.076: CPU1.BN25 104.79,102.63 v2(105.11,102.95)
CFG1: length 48.8
  TOP w0.114: JPCMC.3 74.87,73.14 74.87,73.5 v2(75.01,73.64)
  IN2 w0.089: v2(105.11,104.53) 105.11,104.06 104.5,103.46 103,103.46 102.56,103.01 101.79,103.01 100.49,101.72
  IN2 w0.097: 100.49,101.72 99.03,100.25 99.03,94.71 93.83,89.5 88.8,89.5 87.71,88.41 87.44,88.14 84.51,85.21 84.51,82.99 75.17,73.64 v2(75.01,73.64)
  BOTTOM w0.076: CPU1.BN27 104.79,104.2 v2(105.11,104.53)
CFG2: length 47.3
  TOP w0.089: v2(104.46,102.95) 104.25,103.16 RH184.1
  TOP w0.114: JPCMC.5 75.73,73.08 76.2,73.55 v2(76.2,73.61)
  IN2 w0.089: v2(104.46,102.95) 104.34,102.95 103,101.61 101.8,101.61
  IN2 w0.097: v2(76.2,73.61) 76.2,74.11 84.91,82.82 84.91,85.05 87.84,87.97 88.97,89.1 93.99,89.1 99.43,94.54 99.43,99.78 101.27,101.61 101.8,101.61
  BOTTOM w0.076: v2(104.46,102.95) 104.79,103.28 CPU1.BN26
CFG3: length 63.2
  TOP w0.114: JPCMC.7 76.98,73.03 v2(77.16,73.03) ; v2(73.48,66.84) JPCMC.23
  IN2 w0.097: v2(73.48,66.84) 73.83,66.84 74.44,66.23 75.21,66.23 77.6,68.62 77.6,72.58 v2(77.16,73.03) 77.01,73.18 74.94,73.18 74.63,73.49 74.63,73.94 75.07,74.38 75.34,74.38 84.11,83.16 84.11,85.38 87.03,88.3 87.31,88.58 87.65,88.92 87.65,88.92 88.63,89.9 93.66,89.9 98.27,94.52 98.27,100.07 99.03,100.82 99.03,101.4 101.5,103.88 104.04,103.88 104.53,104.37 v2(104.53,104.53)
  BOTTOM w0.076: v2(104.53,104.53) 104.79,104.79 CPU1.BN28
  BOTTOM w0.114: v2(77.16,73.03) v1(77.83,73.03)
CFG4: length 43.4
  TOP w0.114: JPCMC.9 77.4,72.19 78.19,72.19 v2(78.41,72.4)
  IN2 w0.089: v2(100.91,96.18) 100.91,92.22
  IN2 w0.097: 100.91,92.22 100.07,91.37 100.07,89.82 98.32,88.07 98.32,87.05 91.25,79.99 90.51,79.99 90.16,79.63 84.56,79.63 79.65,74.72 79.65,73.59 78.47,72.4 v2(78.41,72.4)
  BOTTOM w0.076: RH185.1 100.35,96.94 101.85,98.44 102.49,98.44 102.68,98.25 103.39,98.25 103.49,98.34 CPU1.BR20
  BOTTOM w0.089: RH185.1 100.35,96.74 v2(100.91,96.18)
CFG5: length 51.4
  TOP w0.089: v1(106.43,97.49) RH186.1
  TOP w0.114: RH186.1 105.11,97.61 v2(105.11,98.23) ; JPCMC.11 77.76,71.33 78.56,71.33 78.71,71.48 80.49,71.48 81.75,70.23 v2(81.75,70)
  IN2 w0.089: v2(105.11,98.23) 105.11,97.29 104.57,96.74 104.57,92.48 105.22,91.83 105.22,90.56 104.32,89.66 104.32,84.61 101.63,81.92
  IN2 w0.097: v2(81.75,70) 81.79,70.05 81.79,70.62 86.39,75.22 92.87,75.22 97.84,80.19 100.82,80.19 101.63,80.99 101.63,81.92
  BOTTOM w0.076: v2(105.11,98.23) 105.44,98.55 CPU1.BM20
CFG6: length 45.9
  TOP w0.114: v2(78.49,70.37) JPCMC.13
  IN2 w0.089: v2(100.91,98.38) 100.91,97.93 100.73,97.74 100.73,97.05 102.12,95.66 102.12,95.46
  IN2 w0.097: v2(78.49,70.37) 78.4,70.46 78.4,71.77 80.05,73.42 80.05,74.56 84.73,79.23 90.32,79.23 90.68,79.59 91.42,79.59 98.72,86.89 98.72,87.04 99.91,88.23 99.91,89.04 101.15,90.29 101.15,90.82 101.54,91.21 101.99,91.21 102.18,91.4 102.18,94.45 102.12,94.51 102.12,95.46
  BOTTOM w0.076: CPU1.BT20 v1(101.46,98.62) 101.16,98.62 v2(100.91,98.38) 100.83,98.38 100.35,97.89 RH187.1
CFG7: length 47.2
  TOP w0.114: JPCMC.15 v2(78.45,69.48)
  IN2 w0.089: v2(101.43,99.41) 100.55,98.53 100.55,93.43
  IN2 w0.097: v2(78.45,69.48) 78,69.93 78,72.54 79.25,73.78 79.25,74.89 84.4,80.03 89.99,80.03 90.35,80.39 91.08,80.39 97.91,87.22 97.91,88.24 99.61,89.93 99.61,91.68 100.55,92.62 100.55,93.43
  BOTTOM w0.076: CPU1.BP20 103.84,98.92 103.61,98.92 103.41,99.12 102.58,99.12 102.46,98.99 101.85,98.99 v2(101.43,99.41)
CFG8: length 47.9
  TOP w0.114: v2(78.45,74.45) 78.44,74.44 74.79,74.44 74.45,74.1 JPCMC.2
  IN2 w0.089: v2(101.1,100.36) 100.11,99.38 100.11,94.68
  IN2 w0.097: 100.11,94.68 100.11,93.32 98.44,91.65 98.44,89.9 97.11,88.57 97.11,87.55 90.75,81.19 90.01,81.19 89.66,80.84 84.06,80.84 78.45,75.22 v2(78.45,74.45)
  BOTTOM w0.076: v2(101.1,100.36) 101.1,101.04 101.43,101.38 103.09,101.38 CPU1.BR23
CFG9: length 50.4
  TOP w0.114: JPCMC.4 75.24,72.9 75.31,72.97 75.31,73.3 76.03,74.02 81.15,74.02 v2(82.04,73.13)
  IN2 w0.089: v2(103.8,99.84) 103.76,99.84 103.09,99.18 103.09,97.8 103.27,97.62 103.27,90.98 103.59,90.66 103.59,84.92 100.83,82.16
  IN2 w0.097: 100.83,82.16 97.54,82.16 92.56,77.18 91.68,77.18 91.32,76.82 85.73,76.82 v2(82.04,73.13)
  BOTTOM w0.089: CPU1.BR22 103.49,100.15 v2(103.8,99.84)
CFG10: length 44
  TOP w0.114: JPCMC.6 75.99,72.64 76.95,73.6 v2(77.78,73.6)
  IN2 w0.089: 100.56,100.33 101.21,100.99 v2(101.68,100.99)
  IN2 w0.097: v2(77.78,73.6) 77.79,73.61 77.79,75.13 86.69,84.03 86.69,86.26 89.13,88.7 94.16,88.7 99.83,94.37 99.83,99.61 100.56,100.33
  BOTTOM w0.076: CPU1.BT23 v2(101.68,100.99)
CFG11: length 43.6
  TOP w0.114: v2(78.36,73.64) 77.33,72.61 77.21,72.61 JPCMC.8
  IN2 w0.089: 100.36,93.5 100.37,93.51 100.37,99.05 101.22,99.9 101.54,99.9 101.67,100.03 v2(101.92,100.03)
  IN2 w0.097: v2(78.36,73.64) 78.85,74.12 78.85,75.05 84.23,80.43 89.82,80.43 90.18,80.79 90.92,80.79 97.51,87.39 97.51,88.4 99.21,90.1 99.21,91.85 100.36,93 100.36,93.5
  BOTTOM w0.089: CPU1.BT22 102.66,100.03 v2(101.92,100.03)
CFG12: length 51.6
  TOP w0.114: v1(82.34,71.84) 82.17,71.67 v2(82.17,70.46) 82.11,70.46 80.48,72.09 78.68,72.09 78.36,71.77 77.61,71.77 77.28,71.44 JPCMC.10
  IN2 w0.089: 101.01,79.81 101.81,80.61 101.81,81.85 104.49,84.53 104.49,89.58 105.4,90.49 105.4,91.9 104.74,92.56 104.74,96.67 105.76,97.69 v2(105.76,98.23)
  IN2 w0.097: 101.01,79.81 100.63,79.43 97.65,79.43 93.03,74.82 86.56,74.82 82.2,70.46 v2(82.17,70.46)
  BOTTOM w0.076: v2(105.76,98.23) 105.44,97.91 CPU1.BM19
CFG13: length 44.3
  TOP w0.114: v2(78.89,70.89) 78.37,70.89 78.3,70.82 77.66,70.82 77.56,70.71 JPCMC.12
  IN2 w0.089: v2(101.43,97.05) 102.37,96.11 102.37,95.85
  IN2 w0.097: v2(78.89,70.89) 78.89,71.69 80.45,73.25 80.45,74.39 84.89,78.83 90.49,78.83 90.85,79.19 91.58,79.19 99.12,86.72 99.12,86.87 100.09,87.85 100.09,88.97 101.34,90.21 101.34,90.74 101.61,91.02 102.06,91.02 102.37,91.33 102.37,95.85
  BOTTOM w0.076: v2(101.43,97.05) 101.82,97.44 102.48,97.44 102.58,97.34 103.11,97.34 103.49,97.71 CPU1.BR19
CFG14: length 49.2
  TOP w0.114: v2(81.31,69.56) 81.3,69.56 81.01,69.56 80.64,69.93 JPCMC.14
  IN2 w0.097: v2(81.31,69.56) 81.3,69.57 81.3,70.7 86.23,75.62 92.7,75.62 98.04,80.96 100.41,80.96 101.44,81.99 101.44,81.99 104.14,84.69 104.14,89.73 105.04,90.64 105.04,91.75 104.38,92.41 104.38,97.64 v2(103.83,98.19)
  BOTTOM w0.076: v2(103.83,98.19) 104.14,97.89 CPU1.BP19
  BOTTOM w0.114: v1(81.1,70.19) 81.31,69.99 v2(81.31,69.56)
CFG15: length 45.2
  TOP w0.114: JPCMC.16 77.57,69.05 78,69.05 v2(78.19,68.86)
  IN2 w0.089: 102.5,96.99 102.5,97.38 102.11,97.77 v2(102.11,98.06)
  IN2 w0.097: v2(78.19,68.86) 78.44,68.86 79.29,69.72 79.29,71.53 80.86,73.09 80.86,74.22 85.06,78.43 90.66,78.43 91.01,78.78 91.75,78.78 99.52,86.55 99.52,86.71 102.82,90.01 102.82,90.42 102.55,90.69 102.55,91.27 102.55,96.94 102.5,96.99
  BOTTOM w0.089: v2(102.11,98.06) 102.35,98.06 102.57,97.84 CPU1.BT19
CFG16: length 52.4
  TOP w0.114: JPCMC.21 v2(76.53,66.69)
  IN2 w0.089: 103.23,89.53 103.23,90.52 102.91,90.84 102.91,97.47 102.74,97.65 102.74,100.6 103.52,101.38 v2(103.81,101.38)
  IN2 w0.097: v2(76.53,66.69) 76.53,66.98 77.85,68.3 78.45,68.3 79.7,69.55 79.7,71.36 81.26,72.92 81.26,73.49 85.39,77.63 90.99,77.63 91.35,77.98 92.22,77.98 101.51,87.27 102.5,87.27 103.23,88 103.23,89.53
  BOTTOM w0.076: CPU1.BP23 104.14,101.05 v2(103.81,101.38)
CFG17: length 53.3
  TOP w0.114: JPCMC.17 77.84,68.45 v2(79.25,68.45)
  IN2 w0.089: 103.09,87.22 103.41,87.55 103.41,90.59 103.09,90.91 103.09,97.55 102.91,97.72 102.91,100.53 103.24,100.85 103.95,100.85 104.46,101.36 v2(104.46,101.38)
  IN2 w0.097: 103.09,87.22 103.09,84.67 100.98,82.56 97.37,82.56 92.39,77.58 91.51,77.58 91.16,77.22 85.56,77.22 81.66,73.32 81.66,72.75 80.1,71.19 80.1,68.73 79.81,68.45 v2(79.25,68.45)
  BOTTOM w0.076: CPU1.BN23 104.79,101.05 v2(104.46,101.38)
  BOTTOM w0.114: v2(79.25,68.45) 79.25,69.06 v1(79.2,69.11)
CFG18: length 54.2
  TOP w0.114: JPCMC.20 76.65,67.77 77.34,67.08 v2(78.05,67.08)
  IN2 w0.089: 103.47,97.93 103.47,98.34 103.72,98.59 104.74,98.59 104.91,98.76 104.91,99.53 105.16,99.77 v2(105.16,99.8)
  IN2 w0.097: v2(78.05,67.08) 79.58,67.08 80.9,68.4 80.9,70.86 86.06,76.02 92.53,76.02 97.87,81.36 100.55,81.36 101.26,82.06 101.26,82.07 103.95,84.77 103.95,89.81 104.86,90.71 104.86,91.67 104.2,92.33 104.2,95.27 104.09,95.38 104.09,97.31 103.47,97.93
  BOTTOM w0.076: CPU1.BN22 105.16,99.82 v2(105.16,99.8)
CFG19: length 51.4
  TOP w0.114: v2(78.71,68) 77.69,68 77.27,68.42 JPCMC.18
  IN2 w0.089: v2(104.43,99.84) 104.43,99.56 103.27,98.4 103.27,97.87 103.45,97.69 103.45,91.06 103.77,90.74 103.77,84.84 100.69,81.76
  IN2 w0.097: v2(78.71,68) 79.93,68 80.5,68.57 80.5,71.03 85.89,76.42 92.37,76.42 97.71,81.76 100.69,81.76
  BOTTOM w0.076: CPU1.BP22 104.14,100.13 v2(104.43,99.84)
CFG_RCOMP: length 3.4
  BOTTOM w0.076: RH59.1 100.35,101.01 100.84,101.5 100.84,101.93 101.06,102.15 v1(101.39,102.15) 101.81,102.57 102.83,102.57 CPU1.BT25
CHG_B+:
  vias: v1(55.82,25.53)
CLK_PCI_LPC: length 123.3
  TOP w0.114: RE89.2 93.07,4.64 UE5.12 93.07,9.64 93.87,10.44 v2(93.87,10.81)
  IN2 w0.097: 184.56,35.72 184.46,35.63 178.72,35.63 178.13,35.03 177.2,35.03 177.01,34.84 177.01,32.68 174.88,30.56 174.88,30.26 174.96,30.18 174.96,28.84 174.36,28.24 ; 184.56,42.12 184.46,42.12 184.16,41.83 184.16,38.57 184.56,38.18
  IN2 w0.104: 184.56,35.72 185.18,36.34 185.18,37.55 184.56,38.18 ; v2(186.96,42.46) 186.62,42.12 184.56,42.12 ; 174.36,28.24 173.54,27.43 173.54,26.88 173.13,26.47 172.7,26.47 171.65,25.42 169.57,25.42 168.86,24.72 157.63,24.72 154.85,21.93 150.8,21.93 148.14,19.28 144.71,19.28 143,17.57 139.25,17.57 138.33,16.65 119.15,16.65 118.16,15.66 116.86,15.66 113.86,12.66 110.22,12.66 109.43,11.88 105.62,11.88 105.06,11.32 100.07,11.32 99.31,12.08 95.38,12.08 94.12,10.81 v2(93.87,10.81)
  BOTTOM w0.114: RH89.1 186.21,42.46 v2(186.96,42.46)
CLK_PCIE_DGPU#_C: length 58.2
  IN5 w0.104: v2(132.27,168.21) 132.03,168.45 132.03,168.63 131.76,168.91 130.99,168.91 130.62,168.53 130.62,167.99 129.26,166.63 127.48,166.63 126.36,165.5 126.36,164.94 126.25,164.84 126.25,164.81 124.47,163.03 124.39,163.03 124.31,163.03 118.26,163.03 111.3,156.06 111.22,156.06 110.96,156.06 107.13,152.24 107.05,152.24 100.68,152.24 97.43,155.48 93.15,155.48 v2(92.96,155.68)
  BOTTOM w0.114: v2(92.96,155.68) 92.78,155.5 91.41,155.5 90.87,156.04 88.03,156.04 87.71,155.73 87.71,155.49 CM99.2 ; JCDRA.34 133.05,169.67 132.06,168.68 132.06,168.42 v2(132.27,168.21)
CLK_PCIE_DGPU_C: length 57.5
  IN5 w0.104: v2(92.96,155.09) 93.15,155.29 97.35,155.29 100.6,152.04 106.97,152.04 107.21,152.04 111.04,155.87 111.14,155.87 111.38,155.87 118.34,162.84 124.23,162.84 124.31,162.84 124.55,162.84 126.45,164.73 126.45,164.76 126.55,164.86 126.55,165.42 127.56,166.43 129.34,166.43 130.81,167.91 130.81,168.45 131.07,168.71 131.68,168.71 131.84,168.55 131.84,168.36 v2(131.69,168.21)
  BOTTOM w0.114: JCDRA.33 132.65,169.96 132.75,169.86 132.75,169.68 131.84,168.77 131.84,168.36 v2(131.69,168.21) ; v2(92.96,155.09) 92.78,155.27 91.32,155.27 90.78,155.82 88.12,155.82 87.93,155.63 87.93,155.49 CM98.2
CLK_PCIE_N1: length 101.5
  IN5 w0.089: 170.42,28.24 170.42,30.04 170.22,30.24 170.22,30.86 169.3,31.78 169.3,37.4 167.88,38.83 167.88,41.18 166.25,42.81 166.25,45.09 163.99,47.35 163.99,49.71 164.12,49.84 164.3,49.84 164.43,49.71 164.43,49.53 v2(164.41,49.51)
  IN5 w0.104: 170.42,28.24 170.42,23.61 173.15,20.88 176.72,20.88 178.09,19.51 179.89,19.51 181.73,17.66 183.31,17.66 184.53,18.89 189.09,18.89 195.32,12.66 203.86,12.66 204.07,12.88 209.89,12.88 214.61,17.59 214.61,18.44 216.99,20.82 216.99,26.07 221.48,30.56 221.48,31.2 222.15,31.86 222.49,31.86 222.64,32.01 v2(222.64,32.09)
  BOTTOM w0.089: UH1.L7 164.63,49.85 164.41,49.63 v2(164.41,49.51)
  BOTTOM w0.114: JSSD1.53 223.11,32.05 222.94,31.88 222.76,31.88 222.64,32.01 v2(222.64,32.09)
CLK_PCIE_N2: length 117.9
  IN5 w0.104: v2(228.28,8.19) 228.09,7.99 227.98,7.99 225.41,8 222.65,5.23 218.71,5.23 217.88,6.06 215.54,6.06 214.89,5.4 200.53,5.4 200.39,5.55 186.62,5.55 182.6,9.56 175.48,9.56 173.07,11.97 164.95,11.97 160.35,16.57 160.35,24.43 157.5,27.29 157.5,33.23 157.45,33.28 157.45,33.79 157.56,33.9 157.56,33.92 157.94,34.3 157.94,38.26 158.26,38.57 158.26,46.32 160.16,48.22 162.21,48.22 162.64,48.65 162.64,50.82 163.02,51.21 163.02,51.92 162.72,52.22 162.31,52.22 162.11,52.03 v2(161.8,52.03)
  BOTTOM w0.089: v2(161.8,52.03) 161.8,51.68 UH1.D3
  BOTTOM w0.114: v2(228.28,8.19) 228.14,8.04 227.96,8.04 227.85,8.15 JSSD2.53
CLK_PCIE_N3: length 140.4
  TOP w0.089: UT1.T19 v2(152.75,153.89)
  IN5 w0.104: v2(163.33,49.89) 163.96,50.52 163.96,55.85 162.21,57.6 162.21,71.6 162.82,72.22 162.82,76.84 165.01,79.03 165.01,80.75 165.62,81.36 165.62,84.64 170.57,89.59 170.57,110.55 172.25,112.23 172.25,142.26 174.37,144.38 174.37,147.22 172.37,149.22 168.59,149.22 166.8,151.01 166.8,153.06 163.95,155.92 161.01,155.92 158.57,158.35 158.57,159.66 158.27,159.97 158.27,159.97 157.87,160.36 156.61,160.36 155.91,159.66 155.91,158.05 155.34,157.49 155.34,154.1 154.76,153.52 153.23,153.52 153.07,153.68 152.96,153.68 v2(152.75,153.89)
  BOTTOM w0.089: UH1.E5 162.46,50.51 162.46,50.24 162.68,50.02 163.21,50.02 v2(163.33,49.89)
CLK_PCIE_N4: length 126.4
  IN4 w0.089: 160.66,51.64 160.66,51.36 160.72,51.3
  IN4 w0.097: 160.72,51.3 161.37,50.65 161.53,50.65 161.78,50.9 v2(161.78,51.06)
  IN4 w0.147: 160.66,51.64 162.64,53.62 162.64,78.69 166.83,82.88 166.83,84.56 169.29,87.02 170.08,87.02 174.87,91.82 174.87,96.37 173.9,97.35 173.9,102.37 172.99,103.28 172.99,136.76 179.51,143.28 193.68,143.28 195.28,144.88 195.28,145.96 v2(195.48,146.16)
  BOTTOM w0.101: v2(161.78,51.06) 161.53,50.81 UH1.D5
  BOTTOM w0.114: v2(195.48,146.16) 195.12,146.52 195.12,146.74 195.57,147.2 196.21,147.2 197.14,148.13 197.57,148.13 197.74,147.97 UL1.32
CLK_PCIE_N5: length 197.1
  IN4 w0.089: 164.94,28.27 164.94,28.24
  IN4 w0.097: v2(161.93,49.51) 161.68,49.51 161.56,49.38 161.56,49.23 161.8,48.98 163.51,48.98 163.95,48.54 164.65,48.54 165.03,48.16 165.03,45.48 165.81,44.7 165.81,43.25 165.23,42.67 165.23,40.72 166.12,39.83 166.12,38.62 165.92,38.43 165.92,34.62 164.86,33.55 164.86,28.36 164.94,28.27
  IN4 w0.147: v2(295.78,61.99) 295.69,61.89 295.58,61.88 294.54,61.88 293.43,60.77 293.43,58.88 279.55,45 277.08,45 275.17,43.1 272.48,43.1 272.42,43.1 272.42,43.1 272.25,43.1 268.64,39.49 265.22,39.49 264.68,38.96 251.03,38.96 236.56,24.49 232.83,24.49 230.05,21.72 227.63,21.72 226.72,20.81 225.35,20.81 224.51,19.97 219.15,19.97 215.07,15.88 212.32,15.88 208.91,12.47 194.87,12.47 192.78,14.56 175.62,14.56 174.63,15.55 168.2,15.55 166.34,17.41 166.34,24.2 164.94,25.6 164.94,28.24
  BOTTOM w0.089: UH1.D8 161.72,49.3 v2(161.93,49.51)
  BOTTOM w0.114: v2(295.78,61.99) 295.97,61.81 300.56,61.81 300.75,62 JWLAN.41
CLK_PCIE_N6: length 187
  IN1 w0.104: v2(90.81,146.02) 90.88,146.02 91.01,145.9 91.01,145.87 91.13,145.74 91.13,143.01 92.01,142.13 108.28,142.13 110.7,139.72 129.03,139.72 129.45,139.3 136.2,139.3 137.62,137.88 143.61,137.88 143.91,138.18 145.62,138.18 146.04,137.76 156.95,137.76 160.18,134.54 160.18,120.44 161.62,118.99 161.62,115.45 158.78,112.61 157.18,112.61 153.94,109.37 153.94,106.64 151.91,104.61 151.91,79.56 154.64,76.82 154.64,70.53 157.11,68.05 157.11,65.46 156.22,64.57 156.22,51.21 156.92,50.51 156.92,46.71 157.71,45.92 161.45,45.92 161.81,45.55 164.16,45.55 166,47.4 166,48.75 166.13,48.88 166.32,48.88 166.44,48.75 v2(166.44,48.72)
  BOTTOM w0.089: v2(166.44,48.72) 166.44,48.95 166.57,49.08 UH1.R8
  BOTTOM w0.114: v2(90.81,146.02) 90.87,146.02 91,145.9 91,145.36 90.77,145.14 UM4.3
CLK_PCIE_P1: length 101.7
  IN5 w0.089: v2(164.41,50.2) 164.23,50.01 164.05,50.01 163.82,49.78 163.82,47.27 166.07,45.01 166.07,42.73 167.7,41.11 167.7,38.75 169.13,37.32 169.13,31.71 170.04,30.79 170.04,30.17 170.25,29.97 170.25,28.33 170.24,28.32 170.24,28.27 170.23,28.26 170.23,28.24
  IN5 w0.104: 170.23,28.24 170.23,23.53 173.07,20.68 176.64,20.68 178.01,19.31 179.81,19.31 181.65,17.47 183.39,17.47 184.61,18.69 189.01,18.69 195.24,12.47 203.94,12.47 204.15,12.69 209.97,12.69 214.8,17.51 214.8,18.36 217.18,20.74 217.18,25.99 221.68,30.48 221.68,31.12 222.23,31.67 222.48,31.67 v2(222.64,31.51)
  BOTTOM w0.089: UH1.L5 164.47,50.2 v2(164.41,50.2)
  BOTTOM w0.114: JSSD1.55 223.06,31.55 222.96,31.65 222.78,31.65 v2(222.64,31.51)
CLK_PCIE_P2: length 117.7
  IN5 w0.104: v2(228.28,7.61) 228.09,7.8 227.9,7.8 227.9,7.8 225.49,7.8 222.73,5.04 218.63,5.04 217.8,5.86 215.62,5.86 214.97,5.21 200.45,5.21 200.31,5.35 186.54,5.35 182.52,9.37 175.4,9.37 172.99,11.78 164.87,11.78 160.16,16.49 160.16,24.35 157.31,27.21 157.31,33.15 157.25,33.2 157.25,33.87 157.37,33.98 157.37,34 157.75,34.38 157.75,38.34 158.06,38.65 158.06,46.4 160.08,48.41 162.13,48.41 162.44,48.73 162.44,50.9 162.83,51.29 162.83,51.84 162.64,52.03 162.39,52.03 162.26,51.9 162.26,51.56 v2(162.25,51.55)
  BOTTOM w0.089: UH1.F2 v2(162.25,51.55)
  BOTTOM w0.114: JSSD2.55 227.85,7.65 227.96,7.75 228.14,7.75 v2(228.28,7.61)
CLK_PCIE_P3: length 140.1
  TOP w0.094: v2(152.75,153.24) 152.42,152.92 UT1.V19
  IN5 w0.104: v2(163.04,50.42) 163.2,50.26 163.43,50.26 163.77,50.6 163.77,55.77 162.02,57.52 162.02,71.68 162.63,72.3 162.63,76.92 164.82,79.11 164.82,80.83 165.43,81.44 165.43,84.72 170.38,89.67 170.38,110.63 172.06,112.31 172.06,142.34 174.18,144.46 174.18,147.14 172.29,149.03 168.51,149.03 166.61,150.93 166.61,152.98 163.87,155.72 160.93,155.72 158.38,158.27 158.38,159.58 158.07,159.89 158.07,159.89 157.79,160.17 156.69,160.17 156.1,159.58 156.1,157.97 155.53,157.41 155.53,154.02 154.85,153.33 153.15,153.33 152.99,153.49 152.88,153.49 152.75,153.36 v2(152.75,153.24)
  BOTTOM w0.089: v2(163.04,50.42) 163.04,50.34 162.9,50.2 162.76,50.2 162.64,50.31 162.64,50.8 162.76,50.93 UH1.G4
CLK_PCIE_P4: length 126.5
  IN4 w0.089: 160.49,51.8 160.48,51.8 160.48,51.75 160.45,51.72 160.45,51.55 160.48,51.52 160.48,51.29 160.53,51.23 160.53,51.23 160.57,51.19 160.57,51.19 160.58,51.17
  IN4 w0.097: 160.58,51.17 160.64,51.12 161.29,50.47 161.59,50.47 v2(161.73,50.32)
  IN4 w0.147: 160.49,51.8 162.41,53.72 162.41,55.13 162.37,55.17 162.37,78.81 166.55,82.99 166.55,84.67 169.18,87.3 169.96,87.3 174.6,91.93 174.6,96.26 173.62,97.24 173.62,102.25 172.71,103.16 172.71,136.88 179.39,143.55 193.56,143.55 195,145 195,146.05 v2(194.89,146.16)
  BOTTOM w0.089: UH1.E6 162.14,50.32 v2(161.73,50.32)
  BOTTOM w0.114: UL1.33 197.74,148.37 197.73,148.35 197.05,148.35 196.12,147.42 195.48,147.42 194.89,146.83 v2(194.89,146.16)
CLK_PCIE_P5: length 197.2
  IN4 w0.097: v2(161.16,49.49) 161.37,49.28 161.37,49.15 161.73,48.8 163.43,48.8 163.87,48.36 164.57,48.36 164.84,48.08 164.84,45.4 165.62,44.62 165.62,43.33 165.04,42.75 165.04,40.65 165.93,39.75 165.93,38.7 165.74,38.5 165.74,34.69 164.67,33.62 164.67,28.24
  IN4 w0.147: v2(295.78,61.41) 295.58,61.61 294.65,61.61 293.7,60.66 293.7,58.76 279.67,44.73 277.19,44.73 275.29,42.82 272.37,42.82 268.76,39.22 265.33,39.22 264.8,38.68 251.14,38.68 236.67,24.22 232.94,24.22 230.17,21.45 227.75,21.45 226.83,20.53 225.46,20.53 224.62,19.69 219.27,19.69 215.18,15.61 212.43,15.61 209.02,12.2 194.76,12.2 192.67,14.29 175.51,14.29 174.52,15.28 168.09,15.28 166.07,17.3 166.07,24.09 164.67,25.49 164.67,28.24
  BOTTOM w0.089: UH1.D7 161.52,49.79 161.22,49.49 v2(161.16,49.49)
  BOTTOM w0.114: JWLAN.39 300.75,61.5 300.66,61.59 295.96,61.59 v2(295.78,61.41)
CLK_PCIE_P6: length 186.7
  IN1 w0.104: v2(91.39,146.02) 91.33,145.96 91.33,143.09 92.09,142.33 108.36,142.33 110.78,139.92 129.11,139.92 129.53,139.49 136.28,139.49 137.7,138.07 143.53,138.07 143.83,138.38 145.7,138.38 146.12,137.95 157.03,137.95 160.37,134.62 160.37,120.52 161.81,119.07 161.81,115.37 158.86,112.42 157.26,112.42 154.13,109.29 154.13,106.56 152.1,104.53 152.1,79.64 154.83,76.9 154.83,70.61 157.31,68.13 157.31,65.38 156.42,64.49 156.42,51.29 157.12,50.59 157.12,46.79 157.79,46.11 161.53,46.11 161.89,45.75 164.08,45.75 165.81,47.48 165.81,48.83 166.05,49.07 166.32,49.07 166.45,49.2 166.45,49.38 v2(166.36,49.47)
  BOTTOM w0.089: UH1.R7 166.72,49.84 v2(166.36,49.47)
  BOTTOM w0.114: v2(91.39,146.02) 91.22,145.85 91.22,145.36 91.42,145.15 UM4.2
CLK_PEG_GPU: length 59.2
  IN4 w0.089: v2(165.37,48.6) 165.51,48.74 165.51,48.92 165.38,49.05 164.99,49.05 164.81,49.23 164.81,50.88 163.32,52.36 163.32,55.1 163.27,55.15 163.27,55.17
  IN4 w0.147: v2(175.15,96.86) 175.4,96.61 175.4,91.6 170.3,86.49 169.51,86.49 167.76,84.75 167.76,82.3 163.27,77.81 163.27,55.17
  BOTTOM w0.089: UH1.N8 165.55,48.92 165.37,48.74 v2(165.37,48.6)
  BOTTOM w0.114: v2(175.15,96.86) 175.27,96.99 177.12,96.99 177.5,97.37 178.08,97.37 UG9.BM26
CLK_PEG_GPU#: length 59.1
  IN4 w0.089: v2(165.42,49.41) 165.24,49.23 165.06,49.23 164.99,49.3 164.99,50.95 163.5,52.44 163.5,55.1 163.55,55.15 163.55,55.17
  IN4 w0.147: 163.55,55.17 163.55,77.7 168.04,82.19 168.04,84.63 169.62,86.22 170.41,86.22 175.68,91.48 175.68,96.72 175.55,96.84 175.55,97.03 175.46,97.12 175.46,97.13 v2(175.15,97.45)
  BOTTOM w0.089: UH1.N7 165.59,49.41 v2(165.42,49.41)
  BOTTOM w0.114: v2(175.15,97.45) 175.38,97.21 177.02,97.21 177.4,97.59 178.04,97.59 UG9.BM27
CLK_SMB: length 6.8
  TOP w0.114: v2(60.02,8.98) 59.96,8.91 59.7,8.91 59.32,8.53 59.32,8.26 PR19.1
  BOTTOM w0.114: v2(60.02,8.98) 60.02,9.04 59.85,9.22 PBATT1.4
CLKREQ#_DGPU: length 297.5
  TOP w0.114: v2(168.54,17.74) v3(169.37,18.57) 169.55,18.74 175.24,18.74 176.14,19.65 179.66,19.65 180.05,20.04 180.05,21.7 180.54,22.19 180.54,27.06 183.59,30.1 183.59,32.56 183.4,32.75 183.4,36.11 183.91,36.62 v2(184.68,36.62) ; UE5.19 95.87,6.7 96.06,6.88 96.06,9.45 94.9,10.61 94.9,12.88 94.53,13.25 94.53,14.85 95.05,15.37 95.05,17.34 94.65,17.73 v2(94.65,20.08)
  IN1 w0.097: v2(168.54,17.74) 168.07,17.74 166.74,19.07 165.24,19.07 160.42,23.9 160.42,23.9 156.36,23.9 154.92,25.35 143.74,25.35 142.99,24.59 129.67,24.59 128.95,23.87 119.2,23.87 118.56,24.5 106.59,24.5 105.98,23.89 103.27,23.89 102.9,24.26 99.31,24.26 95.13,20.08 v2(94.65,20.08)
  IN2 w0.089: v2(176.51,37.09) 176.99,36.61 182.01,36.61 182.27,36.87 184.43,36.87 v2(184.68,36.62)
  IN5 w0.097: v2(94.65,20.08) 93.29,21.44 93.29,23.35 93.02,23.62 92.07,23.62 91.03,24.66 89.36,24.66 87.45,22.75 77.26,22.75 76.57,23.44 76.57,46.83 79.07,49.32 79.07,54.86 84.88,60.68 84.88,90.27 86.35,91.74 86.35,140.72 87.29,141.66 87.29,142.58 87.73,143.03 92.77,143.03 v2(93.17,143.43)
  BOTTOM w0.089: v2(176.51,37.09) 177.06,37.09 UH1.AT33
  BOTTOM w0.114: v2(93.17,143.43) 93.17,145.4 90.12,148.44 UM4.17
  BOTTOM w0.127: v2(184.68,36.62) 185.03,36.62 185.09,36.56 RP5.5
CLKREQ#_GPU: length 37.3
  IN4 w0.137: v2(180.78,64.05) 180.83,64.1 181.2,64.1 181.96,63.34 181.96,56.7 182.72,55.94 182.72,52.84 183.75,51.81 183.75,50.49 184.29,49.94 184.29,46.5 184.75,46.05 184.75,44.55 184.16,43.97 184.16,40.54 183.78,40.16 v2(183.66,40.16)
  BOTTOM w0.089: UH1.BC24 181.03,41.2 181.19,41.05 181.49,41.05 181.7,41.27 181.96,41.27 182.12,41.43 182.72,41.43 183.02,41.13 183.02,40.53 183.4,40.16 v2(183.66,40.16)
  BOTTOM w0.114: v2(180.78,64.05) 180.88,64.05 v1(181.22,64.39) 182.83,66 182.83,66.32 183.79,67.27 QG510.1 ; v2(183.66,40.16) 184.27,39.54 RP3.5
CLKREQ_PCIE#1: length 104.9
  TOP w0.089: 184.56,40.3 184.23,40.63 184.23,41.11 183.91,41.43 181.51,41.43 181.43,41.34 180.57,41.34 180.3,41.08 179.15,41.08 v1(179.03,40.95) 178.53,40.46 v2(178.46,40.46)
  TOP w0.114: 184.56,40.3 184.67,40.18 v2(184.67,40.12)
  IN2 w0.097: v2(184.67,40.12) 184.67,39.16 185.88,37.95 185.88,29.74 192.05,23.58 192.05,14.04 194.87,11.21 208.86,11.21 212.44,14.79 215.6,14.79 216.91,16.11 220.6,16.11 221.46,16.97 234.26,16.97 236.55,19.26 v2(236.55,31.47)
  BOTTOM w0.089: UH1.AW24 178.87,40.76 178.76,40.76 v2(178.46,40.46)
  BOTTOM w0.114: RP3.6 184.75,40.04 v2(184.67,40.12) ; JSSD1.52 235.73,32.3 v2(236.55,31.47)
CLKREQ_PCIE#2: length 100.8
  TOP w0.089: 184.56,41.16 184.09,41.63 v1(180.89,41.63) 180.6,41.63 180.22,41.25 178.83,41.25 178.39,40.82 177.52,40.82 v2(177.16,40.46)
  TOP w0.114: v2(184.71,40.73) 184.71,41.01 184.56,41.16
  IN2 w0.104: v2(188.48,23.84) 188.26,23.62 188.26,19.35 189.85,17.76 189.85,13.31 194.02,9.14 201.79,9.14 203.55,7.37 211.91,7.37 212.22,7.68 213.46,7.68 218.48,12.7 224.66,12.7 225.01,12.35 232.01,12.35 232.69,11.66 235.76,11.66 v2(236.99,12.9)
  IN5 w0.097: v2(188.48,23.84) 188.79,24.16 188.79,24.6 188.67,24.73 188.67,34.58 188.5,34.76 186.25,34.76 185.69,35.32 185.69,36.6 185.11,37.17 185.11,40.33 v2(184.71,40.73)
  BOTTOM w0.089: UH1.AT24 177.6,40.92 177.16,40.49 v2(177.16,40.46)
  BOTTOM w0.114: v2(236.99,12.9) 236.99,8.93 236.46,8.4 JSSD2.52
  BOTTOM w0.127: v2(184.71,40.73) 184.9,40.54 RP3.7
CLKREQ_PCIE#3: length 155
  TOP w0.114: v2(160.73,149.51) 160.73,148.98 v1(160.35,148.6) 160.35,147.17 159.97,146.79 159.97,145.44 159.27,144.74 159.27,144.63 158.74,144.11 143.65,144.11 142.83,143.28 v2(142.83,142.59)
  IN1 w0.089: 179.63,55.17 180.67,54.13 181.26,54.13
  IN1 w0.097: v2(160.73,149.51) 160.73,149.31 160.92,149.12 163.7,149.12 166.45,146.37 166.45,144.79 171.9,139.34 171.9,130.26 172.61,129.56 172.61,113.06 171.7,112.16 171.7,94.2 167.11,89.61 167.11,78.68 168.35,77.44 168.35,74.13 169.05,73.43 169.05,68 177.64,59.41 177.64,57.6 178.2,57.05 179.21,57.05 179.53,56.73 179.53,55.27 179.63,55.17 ; 181.26,54.13 181.73,53.65 181.73,44.29 181.24,43.8 181.24,42.14 v2(182.32,41.06)
  BOTTOM w0.089: v2(182.32,41.06) 181.77,41.06 181.35,40.64 UH1.BD25
  BOTTOM w0.114: RT24.1 RT2.2 145.75,142.67 145.13,142.05 143.18,142.05 142.83,142.4 v2(142.83,142.59)
CLKREQ_PCIE#3_R: length 9.1
  TOP w0.089: UT1.AC5 145.95,150.21
  TOP w0.102: v2(143.75,146.75) v1(144.11,147.11) 144.53,147.53 144.53,148.83 144.87,149.17 144.92,149.17 145.95,150.21
  BOTTOM w0.114: v2(143.75,146.75) 145.45,146.75 145.69,146.51 145.69,144.84 RT2.1 146.36,144.78 RT20.2
CLKREQ_PCIE#4: length 156.6
  IN2 w0.097: v2(199.83,152.98) 198.51,151.66 194.77,151.66 192.48,149.38 192.48,146.9 189.63,144.04 179.91,144.04 179.02,143.15 179.02,140.8 175.75,137.53 175.75,136.77 175.02,136.04 v2(174.26,136.04)
  IN5 w0.097: v2(183.54,40.69) 184.06,41.21 184.06,42.87 183.67,43.27 177.04,43.27 175.59,44.72 174.49,44.72 174.03,45.17 171.37,45.17 170.88,45.66 170.88,47.59 170.36,48.12 170.36,54.3 165.16,59.5 165.16,65.01 165.7,65.55 165.7,77.8 167.74,79.84 167.74,84.72 171.77,88.75 171.77,110 174.28,112.51 174.28,136.02 v2(174.26,136.04)
  BOTTOM w0.089: v2(183.54,40.69) 183.34,40.9 183.34,41.26 182.99,41.6 182.04,41.6 181.89,41.45 181.64,41.45 181.53,41.55 181.53,41.55 181.22,41.55 181.18,41.51 180.7,41.51 UH1.BB24
  BOTTOM w0.114: v2(199.83,152.98) 200.12,152.69 200.13,152.69 200.29,152.53 UL1.4 ; v2(183.54,40.69) v1(184.06,40.69) 184.61,41.24 184.79,41.24 185,41.04 RP3.8
CLKREQ_PCIE#5: length 200.6
  IN2 w0.104: v2(304.12,52.36) 304.81,51.67 304.81,42.07 298.79,36.05 290.66,36.05 290.07,35.46 283.55,35.46 280.52,38.49 270.39,38.49 270.38,38.5 248.71,38.5 241.44,31.22 241.44,16.71 236.18,11.45 232.55,11.45 231.85,12.15 224.91,12.15 224.57,12.48 218.57,12.48 213.56,7.47 212.3,7.47 211.99,7.17 203.47,7.17 201.7,8.93 193.92,8.93 189.64,13.21 189.64,17.66 187.95,19.35 187.95,23.96 v2(188.42,24.42)
  IN5 w0.097: v2(188.42,24.42) 188.42,34.4 188.29,34.53 186.18,34.53 185.49,35.23 185.49,36.5 v2(184.61,37.38)
  BOTTOM w0.089: 184.56,38.49 184.56,38.62 v1(183.8,39.38) 182.5,40.67 181.8,40.67 UH1.BE25
  BOTTOM w0.114: 184.56,38.49 184.61,38.44 v2(184.61,37.38) 184.68,37.31 184.91,37.31 185.16,37.06 RP5.6 ; JWLAN.45 302.75,63 303.29,62.46 303.29,53.19 v2(304.12,52.36)
CLKRUN#: length 7.6
  TOP w0.089: 184.56,41.56 184.29,41.82 182.32,41.82 v1(182.22,41.92) 180.64,41.92 180.26,41.54 179.52,41.54 v2(179.44,41.61)
  TOP w0.114: 184.69,41.42 184.56,41.56
  TOP w0.127: 184.69,41.42 185.42,40.7 RH85.1
  BOTTOM w0.089: UH1.AW22 179.13,41.93 v2(179.44,41.61)
CMSRC_CHG: length 3.6
  TOP w0.114: PR706.2 v1(62.3,32.27)
  TOP w0.203: PU700.3 61.38,34.53 62.3,33.62 PR706.2
CODEC_MUTE#: length 28.4
  TOP w0.114: v2(29.18,24.34) 28.64,24.34 28.51,24.47 UA4.15 ; v2(29.53,48.26) DA3.1
  IN5 w0.097: v2(29.18,24.34) 29.18,26.32 28.02,27.47 28.02,29.51 27.88,29.65 27.88,34.37 29.35,35.84 29.35,42.84 29.6,43.1 29.6,48.19 v2(29.53,48.26)
  BOTTOM w0.114: RA70.2 28.56,24.07 28.91,24.07 v2(29.18,24.34) 29.55,24.34 v1(29.68,24.47)
CPU_24MHZ_N: length 79.1
  IN2 w0.089: 147.84,106.82 147.82,106.82 147.81,106.83 144.86,106.83 144.54,106.51 143.06,106.51 142.83,106.75 142.83,107.66 142.22,108.26 141.11,108.26 140.92,108.08 140.92,107.33 v2(141.18,107.07)
  IN2 w0.104: 147.84,106.82 147.89,106.82 149.87,104.84 149.87,98.57 150.55,97.9 150.55,92.17 149.24,90.86 149.24,79.94 151.1,78.07 151.1,74.66 150.04,73.59 150.04,63.11 150.28,62.87 150.71,62.87 150.89,62.69 v2(150.89,62.62)
  BOTTOM w0.089: v2(141.18,107.07) 141.51,107.41 CPU1.D31
  BOTTOM w0.102: UH1.F1 162.52,52.47 162.7,52.47 162.83,52.6 162.83,52.86 162.42,53.27 162.42,55.16 162.43,55.17
  BOTTOM w0.114: v2(150.89,62.62) 151.03,62.76 151.21,62.76 152.1,61.87 153.52,61.87 155.01,60.38 v4(156.25,60.38) 156.62,60.38 157.17,60.93 161.73,60.93 162.43,60.23 162.43,55.17
CPU_24MHZ_P: length 79.4
  IN2 w0.089: 147.84,107.02 147.82,107.02 147.81,107.01 144.78,107.01 144.47,106.69 143.13,106.69 143,106.82 143,107.73 142.29,108.44 141.04,108.44 140.74,108.15 140.74,107.29 v2(140.53,107.08)
  IN2 w0.104: 147.84,107.02 147.97,107.02 150.07,104.92 150.07,98.65 150.74,97.98 150.74,92.09 149.43,90.78 149.43,80.02 151.29,78.15 151.29,74.58 150.23,73.51 150.23,63.19 150.36,63.07 150.75,63.07 v2(150.89,63.21)
  BOTTOM w0.089: v2(140.53,107.08) 140.86,107.41 CPU1.E31
  BOTTOM w0.102: UH1.G1 163.02,52.54 163.02,52.94 162.61,53.35 162.61,55.08 162.62,55.09 162.62,55.12 162.65,55.16 162.65,55.17
  BOTTOM w0.114: 162.65,55.17 162.65,60.33 161.83,61.15 157.08,61.15 156.55,60.62 155.98,60.62 155.96,60.6 155.11,60.6 153.61,62.1 152.19,62.1 151.3,62.99 151.11,62.99 v2(150.89,63.21)
CPU_B+: length 14.2
  TOP w0.254: v2(106.82,133.58) 106.82,133.07 103.14,129.39 100.83,129.39 99.22,127.78 96.43,127.78 95.88,128.33 PR506.1
  vias: v2(108.28,127.62) v2(108.28,126.98) v2(108.28,126.35) v2(108.85,127.93) v2(108.85,127.3) v2(108.85,126.66) v2(109.36,127.62) v2(109.36,126.98) v2(109.36,126.35) v2(109.87,127.93) v2(109.87,127.3) v2(109.87,126.66) v2(118.43,134.61) v2(118.43,134.03) v2(118.99,134.35) v2(118.99,133.77) v2(119.57,134.63) v2(119.57,134.05) v2(126.69,134.69) v2(126.69,134.11) v2(127.2,134.41) v2(127.2,133.77) v2(127.71,134.73) v2(127.71,134.09) v2(134.9,134.69) v2(134.9,134.09) v2(135.48,134.54) v2(135.48,133.96) v2(136.05,134.69) v2(136.05,134.11) v2(143.38,134.58) v2(143.38,133.99) v2(143.91,134.31) v2(143.91,133.73) v2(144.43,134.63) v2(144.43,134.05) v2(151.66,134.61) v2(151.65,133.97) v2(152.2,134.85) v2(152.18,134.26) v2(152.72,134.54) v2(152.7,133.94) v2(157.68,128.25) v2(157.68,127.62) v3(155.78,134.31)
CPU_DDC1CLK: length 141.8
  TOP w0.102: UT1.Y5 v2(146.24,151.94)
  IN1 w0.097: v2(158.51,147.09) 158.33,147.27 158.33,147.87 158.83,148.36 162.36,148.36 164.27,146.46 164.8,146.46 165.62,145.63 165.62,144.62 171.2,139.05 171.2,129.97 171.91,129.27 171.91,113.35 170.34,111.79 170.34,93.84 164.79,88.28 164.79,78.39 166.88,76.3 166.88,74.62 168.35,73.14 168.35,67.56 173.24,62.67 173.78,62.13 173.78,60.76 174.92,59.62 174.92,57.21 177.12,55.01 177.18,55.01 180.42,51.77 180.42,51.58 180.74,51.26 180.74,50.51 v2(180.48,50.25)
  IN2 w0.097: v2(158.51,147.09) 158.32,147.28 158.32,147.79 157.81,148.3 146.38,148.3 144.12,150.55 144.12,153.47 144.25,153.6 144.57,153.6 145.05,153.12 145.05,151.92 145.43,151.54 145.76,151.54 146.17,151.94 v2(146.24,151.94)
  BOTTOM w0.089: v2(180.48,50.25) 180.25,50.25 UH1.BA5
  BOTTOM w0.114: v2(158.51,147.09) RPT1.3
CPU_DDC1DATA: length 140.4
  TOP w0.089: UT1.R4 145.28,154.22 v2(145.61,154.55)
  IN1 w0.097: v2(181.3,50.88) 181.05,50.88 180.92,51 180.92,51.33 180.6,51.65 180.6,51.85 175.15,57.3 175.15,59.71 174,60.86 174,62.23 173.44,62.8 168.58,67.65 168.58,73.23 167.1,74.71 167.1,76.4 165.01,78.48 165.01,88.19 170.57,93.74 170.57,111.7 172.13,113.26 172.13,129.36 171.42,130.06 171.42,139.14 165.85,144.72 165.85,145.72 164.89,146.68 164.36,146.68 162.45,148.59 158.74,148.59 158.11,147.96 158.11,147.27 v2(157.93,147.09)
  IN2 w0.097: v2(145.61,154.55) 145.36,154.3 144.77,154.3 144.29,153.82 144.16,153.82 143.9,153.56 143.9,150.46 146.29,148.07 157.72,148.07 158.1,147.69 158.1,147.26 v2(157.93,147.09)
  BOTTOM w0.089: v2(181.3,50.88) 181.2,50.98 UH1.BC4
  BOTTOM w0.114: RPT1.4 158.01,147.17 v2(157.93,147.09)
CPU_DDC2CLK: length 137.3
  TOP w0.089: v2(148.21,153.24) 147.72,153.24 147.52,153.04 147.52,151.92 UT1.Y8
  IN1 w0.097: v2(159.73,147.09) 159.55,147.27 159.55,147.49 159.72,147.66 161.77,147.66 164.15,145.28 164.15,145.11 170.5,138.76 170.5,129.68 171.21,128.98 171.21,114.06 169.64,112.5 169.64,95.61 168.83,94.8 166.66,94.8 165.21,93.35 165.21,91.18 164.09,90.06 164.09,78.05 166.18,75.97 166.18,68.75 172.51,62.41 172.51,58.22 173.28,57.46 173.28,57.43 175.69,55.01 175.69,54.08 177.74,52.03 179.33,52.03 180.04,51.32 180.04,51.1 179.85,50.91 v2(179.8,50.91)
  IN2 w0.097: v2(148.21,153.24) 148.21,153.18 147.72,152.68 147.72,150.9 147.43,150.62 147.43,149.6 148,149.03 158.35,149.03 159.59,147.79 159.59,147.23 v2(159.73,147.09)
  BOTTOM w0.089: v2(179.8,50.91) 179.81,50.92 179.81,51.55 180.11,51.85 UH1.BB3
  BOTTOM w0.114: RPT1.1 159.51,147.3 v2(159.73,147.09)
CPU_DDC2DATA: length 138.6
  TOP w0.102: v2(145.6,155.19) UT1.N4
  IN1 w0.097: v2(180.37,50.89) 180.23,51.04 180.23,51.4 179.41,52.22 177.82,52.22 175.88,54.16 175.88,55.15 173.5,57.53 173.5,57.55 172.73,58.32 172.73,62.51 166.4,68.84 166.4,76.06 164.31,78.14 164.31,89.96 165.43,91.08 165.43,93.26 166.75,94.58 168.92,94.58 169.87,95.52 169.87,112.41 171.43,113.97 171.43,129.07 170.72,129.77 170.72,138.85 164.37,145.2 164.37,145.38 161.86,147.89 159.62,147.89 159.32,147.59 159.32,147.27 v2(159.14,147.09)
  IN2 w0.097: v2(145.6,155.19) 146.01,154.78 146.01,154.16 147.49,152.68 147.49,150.99 147.21,150.71 147.21,149.5 147.91,148.8 158.26,148.8 159.37,147.7 159.37,147.31 159.15,147.09 v2(159.14,147.09)
  BOTTOM w0.089: UH1.BD6 180.88,50.39 v2(180.37,50.89)
  BOTTOM w0.114: RPT1.2 159.01,147.37 159.14,147.24 v2(159.14,147.09)
CPU_DDI1HPD: length 141.3
  TOP w0.102: UT1.AA2 144.34,151.15 143.63,151.15 143.27,150.78
  TOP w0.127: RT38.1 141.37,149.6 v1(142.21,149.6) 142.46,149.6 v2(142.89,150.02) 143.27,150.4 143.27,150.78
  IN1 w0.097: v2(142.89,150.02) 143.29,150.43 153.2,150.43 153.87,149.76 153.87,149.25 154.76,148.37 154.76,147.26 155.34,146.68 156.89,146.68 157.12,146.45 160,146.45 160.51,146.96 161.47,146.96 162.47,145.97 162.47,145.83 169.82,138.48 169.82,129.4 170.53,128.7 170.53,114.34 168.86,112.68 168.86,97.14 167.77,96.05 164.06,96.05 161.56,93.55 161.56,89.87 162.82,88.61 162.82,78.04 165.3,75.55 165.3,67.73 167.85,65.18 167.85,61.84 167.85,61.84 167.85,61.22 174.37,54.7 174.37,54.68 174.37,52.59 176.23,50.74 178.24,50.74 v2(178.5,50.48)
  BOTTOM w0.089: v2(178.5,50.48) 179.14,51.12 UH1.AW4
CPU_DDI2HPD: length 135.7
  TOP w0.102: UT1.Y6 v2(146.89,151.94)
  IN1 w0.089: v2(178.76,51.5) 177.14,51.5 176.23,52.41 175.34,52.41 174.58,53.17 174.58,54.89 174.3,55.17
  IN1 w0.097: v2(146.89,151.94) 146.89,151.39 147.65,150.63 153.32,150.63 154.13,149.82 154.13,149.28 154.96,148.45 154.96,147.34 155.42,146.88 156.97,146.88 157.2,146.65 159.92,146.65 160.43,147.16 161.59,147.16 162.66,146.09 162.66,145.92 170.02,138.56 170.02,129.48 170.73,128.78 170.73,114.26 169.06,112.6 169.06,97 167.91,95.85 164.16,95.85 161.81,93.5 161.81,89.94 163.02,88.73 163.02,78.13 165.5,75.65 165.5,67.81 171.08,62.23 171.08,58.38 174.3,55.17
  BOTTOM w0.089: v2(178.76,51.5) 179.24,51.98 UH1.AY2
  BOTTOM w0.114: v1(146.06,150.58) RT39.1 146.89,151.94 v2(146.89,151.94)
CPU_DISPA_BCLK: length 83.2
  IN2 w0.097: v2(152.86,61.39) 155.75,61.39 156.47,62.11 156.47,63.04 156.84,63.42 157.96,63.42 158.3,63.07 164.78,63.07 167.2,60.65 170.08,60.65 171.06,59.67 174.34,59.67 175.28,58.73 175.62,58.73 v2(176.42,57.94)
  IN5 w0.097: v2(139.91,105.58) 138.38,104.05 138.38,96.41 139.09,95.69 142.8,95.69 143.2,95.29 143.2,86.96 146.74,83.43 146.74,76.82 150.4,73.15 150.4,69.32 152.86,66.86 v2(152.86,61.39)
  BOTTOM w0.076: v2(139.91,105.58) 139.91,104.71 CPU1.G27
  BOTTOM w0.114: RH38.1 176.42,57.34 v2(176.42,57.94) 176.95,57.94 v1(177.13,58.11)
CPU_DISPA_BCLK_R: length 4.8
  BOTTOM w0.089: UH1.AM2 175.4,52.02 175.76,52.38 175.76,52.94 175.52,53.18 175.52,54.26 176.14,54.88 176.14,55.05
  BOTTOM w0.114: 176.14,55.05 v1(176.14,55.27) 176.14,55.59 176.22,55.67 RH38.2
CPU_DISPA_SDI: length 74.2
  IN2 w0.089: 147.84,101.66 v2(145.53,103.97)
  IN2 w0.097: 147.84,101.66 148.03,101.47 148.03,98.77 149.94,96.86 v2(149.94,95.72)
  BOTTOM w0.076: RC66.2 145.53,104.52 v2(145.53,103.97)
  BOTTOM w0.089: UH1.AN2 175.88,52.25 175.99,52.35 175.99,52.97 175.71,53.25 175.71,54.13 176.54,54.97 176.54,55.17
  BOTTOM w0.114: v2(149.94,95.72) 150.61,95.05 150.61,82.78 v3(152.86,80.53) 152.86,72.73 158.83,66.76 161.39,66.76 167.72,60.44 169.59,60.44 170.03,59.99 176.96,59.99 177.56,59.4 177.56,58 176.73,57.17 176.73,55.7 176.54,55.51 176.54,55.17
CPU_DISPA_SDI_R: length 7.6
  BOTTOM w0.076: CPU1.G29 139.84,106.22 143.91,106.22 144.51,106.82 v1(145.29,106.82) 145.9,106.82 146.2,106.52 RC66.1
CPU_DISPA_SDO: length 71.5
  IN5 w0.097: v2(139.18,103.18) 138.56,102.56 138.56,97.02 139.11,96.46 142.99,96.46 143.46,95.99 143.46,87.08 146.94,83.61 146.94,76.9 150.62,73.21 150.62,69.52 152.09,68.05 v2(153.11,68.05)
  BOTTOM w0.076: v2(139.18,103.18) 139.56,102.8 CPU1.G25
  BOTTOM w0.114: RH39.1 174.86,59.56 174.64,59.78 169.94,59.78 169.5,60.22 167.63,60.22 161.34,66.51 158.78,66.51 157.23,68.05 v3(154.81,68.05) v2(153.11,68.05)
CPU_DISPA_SDO_R: length 7.7
  BOTTOM w0.089: UH1.AM1 175.5,52.74 175.34,52.9 175.34,54.39
  BOTTOM w0.114: 175.52,55.17 175.52,55.34 175.65,55.48 175.65,56.92 175.76,57.03 175.76,57.47 176.01,57.72 176.01,58.43 RH39.2 175.75,58.64 v1(175.32,59.08)
  BOTTOM w0.127: 175.34,54.39 175.52,54.56 175.52,55.17
CPU_DP1_AUXN: length 80.1
  IN5 w0.104: v2(160.9,145.03) 160.9,142.21 164.28,138.83 164.28,118.04 164.7,117.62 164.7,114.61 163.68,113.59 163.68,111.74 162.64,110.7 162,110.7 160.16,108.87 160.16,108.48 159.15,107.47 146.57,107.47 145.94,106.83 144.67,106.83 144.22,106.39 143.65,106.39 143.04,105.78 143.04,105.08 142.12,104.16 142.12,103.79 141.93,103.6 140.99,103.6 v2(140.56,103.96)
  BOTTOM w0.089: CPU1.E27 140.87,104.34 v2(140.56,103.96)
  BOTTOM w0.114: v2(160.9,145.03) 160.9,143.76 159.53,142.39 148.14,142.39 147.01,143.52 CT26.1
CPU_DP1_AUXN_C: length 9.1
  TOP w0.089: UT1.W11 v2(148.2,152.59)
  BOTTOM w0.114: v2(148.2,152.59) 148.03,152.42 147.78,152.42 147.38,152.02 147.38,150.37 147.33,150.32 v4(147.33,149.11) 147.33,148.49 147.02,148.18 147.02,145.51 RT76.1 147.15,145.24 147.15,144.91 CT26.2
CPU_DP1_AUXP: length 80.1
  IN5 w0.104: v2(160.16,145.03) 160.36,145.03 160.67,144.72 160.67,142.17 164.09,138.75 164.09,117.96 164.51,117.54 164.51,114.69 163.48,113.67 163.48,111.82 162.56,110.9 161.92,110.9 159.97,108.95 159.97,108.56 159.07,107.66 146.49,107.66 145.86,107.02 144.59,107.02 144.14,106.58 143.57,106.58 142.85,105.86 142.85,105.16 141.93,104.24 141.93,103.87 141.85,103.79 141.65,103.79 141.56,103.88 141.56,104.23 141.43,104.36 141.25,104.36 141.12,104.23 v2(141.12,103.97)
  BOTTOM w0.089: CPU1.D27 141.25,104.36 141.12,104.24 v2(141.12,103.97)
  BOTTOM w0.114: CT25.1 147.37,143.98 147.37,143.92 147.24,143.79 147.24,143.61 148.23,142.61 159.43,142.61 160.67,143.85 160.67,144.71 160.35,145.03 v2(160.16,145.03)
CPU_DP1_AUXP_C: length 9.1
  TOP w0.089: UT1.Y11 148.52,151.68 148.28,151.92 v2(148.2,151.92)
  BOTTOM w0.114: CT25.2 147.37,144.99 147.37,145.16 RT78.1 147.25,145.84 147.25,148.09 147.56,148.4 147.56,148.82 147.58,148.84 147.58,149.38 147.56,149.4 147.56,150.23 147.61,150.28 147.61,151.93 147.88,152.2 148.06,152.2 148.2,152.06 v2(148.2,151.92)
CPU_DP1_N0: length 72.2
  TOP w0.089: CT7.1 146.06,148.04 146.06,147.51 v2(146.22,147.35)
  IN5 w0.104: v2(137.29,112.72) 137.44,112.86 137.64,112.86 137.92,112.58 138.81,112.58 140.04,113.8 145.32,113.8 146.97,112.15 150.46,112.15 150.46,112.15 154.32,112.15 155.61,113.43 157.13,113.43 158.78,115.09 159.81,115.09 160.67,115.95 160.67,137.33 153.54,144.46 147.02,144.46 146.17,145.31 146.17,147.29 v2(146.22,147.35)
  BOTTOM w0.076: CPU1.K37 137.67,111.02 137.67,110.79 137.77,110.69 137.92,110.69 138.02,110.79 138.02,112.57 137.66,112.92 137.66,112.95 137.58,113.03 137.53,113.03 137.45,112.95 137.35,112.95 137.25,112.85 137.25,112.76 v2(137.29,112.72)
CPU_DP1_N0_C: length 2.7
  TOP w0.089: CT7.2 145.94,149 145.94,149.2 146.83,150.09 146.99,150.09 147.1,150.2 147.1,150.49 147.06,150.53 146.95,150.53 UT1.AC7
CPU_DP1_N1: length 73.9
  TOP w0.114: v2(155.97,145.5) 155.84,145.38 155.84,145 155.52,144.68 148.79,144.68 146.89,146.58 146.89,148.04 CT9.1
  IN5 w0.104: v2(138.89,109.43) 138.75,109.57 138.75,109.91 139.02,110.17 140.71,110.17 141.77,111.24 144.33,111.24 146.07,109.49 150.96,109.49 151.81,110.34 155.69,110.34 156.49,111.15 158.44,111.15 162.89,115.6 162.89,116.87 162.48,117.29 162.48,138.08 155.84,144.71 155.84,145.38 v2(155.97,145.5)
  BOTTOM w0.089: CPU1.J34 138.82,109.43 v2(138.89,109.43)
CPU_DP1_N1_C: length 2.6
  TOP w0.089: UT1.AC9 147.79,150.57 147.69,150.68 147.63,150.68 147.56,150.61 147.56,150.36 147.56,150.17 147.16,149.77 147.16,149.15 146.97,148.97 146.97,148.96 CT9.2
CPU_DP1_N2: length 74.5
  TOP w0.089: CT23.1 148.17,147.9 148.17,147.69 v2(147.87,147.39)
  IN4 w0.147: v2(144.73,146.32) 144.5,146.55 144.5,147.55 144.93,147.98 145.43,147.98 145.54,147.87 147.95,147.87 148.08,147.74 148.08,147.6 v2(147.87,147.39)
  IN5 w0.104: v2(139.6,114.29) 139.51,114.2 139.27,114.2 139.18,114.29 139.18,114.47 139.76,115.05 145.09,115.05 146,114.13 156.92,114.13 158.83,116.04 158.83,116.35 160.07,117.59 160.07,137.08 153.3,143.86 145.72,143.86 144.33,145.24 144.33,145.93 v2(144.73,146.32)
  BOTTOM w0.076: CPU1.H36 139.6,110.73 139.6,111.19 139.37,111.42 139.37,114.06 v2(139.6,114.29)
CPU_DP1_N2_C: length 2.4
  TOP w0.089: UT1.AC11 148.71,150.55 148.65,150.61 148.58,150.61 148.49,150.52 148.49,150.25 148.54,150.21 148.54,150.11 148.36,149.93 148.36,149.46 148.3,149.39 148.3,149.14 CT23.2
CPU_DP1_N3: length 82.2
  TOP w0.089: v2(148.99,147.63) 149.07,147.55 149.26,147.55 149.38,147.67 149.38,147.83 149.05,148.17 CT24.1
  IN4 w0.147: v2(140.85,146.63) 140.86,146.63 140.92,146.7 141.61,146.7 142.15,147.24 143.04,147.24 144.65,148.85 145.89,148.85 146.14,148.59 149.19,148.59 149.5,148.28 149.5,147.76 149.37,147.63 149,147.63 v2(148.99,147.63)
  IN5 w0.104: v2(140.85,146.63) 140.96,146.74 141.21,146.74 145.47,142.48 153.55,142.48 159.27,136.76 159.27,118.13 157.87,116.73 157.87,116.23 156.61,114.96 146.53,114.96 145.49,115.99 139.1,115.99 138.12,115.02 138.12,114.17 137.96,114.01 137.89,114.01 137.67,114.24 v2(137.67,114.3)
  BOTTOM w0.076: v2(137.67,114.3) 137.67,114.22 137.99,113.89 138.23,113.89 138.8,113.32 138.8,112.96 138.63,112.8 138.63,112.23 138.78,112.08 138.94,112.08 139.04,111.99 139.04,111.71 138.96,111.63 138.83,111.63 CPU1.J38
