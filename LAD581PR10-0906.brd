# Allegro board LAD581PR10-0906.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 161.68,53.43 161.68,52.4 161.39,52.11 161.39,51.17 161.32,51.1 161.06,50.82 161.31,50.52 161.33,50.36 161.41,50.22 161.43,50.15 161.39,50.1 161.33,50.05 161.29,49.98 161.27,49.96 161.25,49.95 161.04,49.94 160.86,49.82 160.85,49.81 160.8,49.81 160.75,49.83 160.7,49.85 160.38,50.17 160.35,50.26 160.28,50.34 160.28,50.36 160.44,50.76 160.07,50.96 159.97,51.05 159.97,52.42 159.76,52.64 159.76,52.95 160.4,53.59 161.52,53.59
GND on BOTTOM (solid shape): 178.35,81.22 178.42,81.19 178.44,81.17 178.47,81.1 178.44,81.03 178.43,80.48 178.98,80.49 179.1,80.49 179.16,80.42 179.16,80.37 179.14,80.33 179.12,79.79 179.66,79.77 179.77,79.79 179.83,79.7 179.83,79.11 179.67,78.94 179.67,78.57 179.35,78.26 177.95,78.26 177.69,78.51 177.69,80.86 177.91,81.08 178.11,81.08 178.28,81.19
GND on BOTTOM (solid shape): 110.2,168.98 113.35,165.32 109.85,162 106.05,162 106.05,173.3 106.29,173.86 106.85,174.1 109.4,174.1 109.75,174.15 110.07,174.3 110.2,174.3
GND on BOTTOM (solid shape): 154.48,7.82 158.45,11.3 162.42,7.82 163.18,2.01 163.42,0.2 162.32,0.2 162.17,0.24 161.8,0.61 161.45,0.7 155.45,0.7 155.1,0.61 154.73,0.24 154.58,0.2 153.48,0.2 153.72,2.01
GND on BOTTOM (solid shape): 196,91.67 196,91.53 195.82,91.2 196,90.87 196,90.8 195.84,90.49 196.03,90.19 196.03,90.14 195.99,90.12 195.95,90.09 195.95,89.5 195.97,89.44 195.94,89.38 195.82,89.03 196.05,88.65 195.95,88.55 195.65,88.55 195.4,88.8 195.4,88.81 195.34,88.93 195.25,89.01 195.25,89.17 195.32,89.23 195.43,89.35 195.43,89.57 195.25,89.75 195.25,89.89 195.34,89.96 195.39,90.06 195.4,90.07 195.4,90.15 195.4,90.2 195.4,90.8 195.4,90.8 195.38,90.97 195.28,91.1 195.28,91.3 195.35,91.38 195.4,91.49 195.4,91.5 195.65,91.75 195.93,91.75
GND on BOTTOM (solid shape): 191.1,70.18 191.1,67.96 191.18,67.87 191.18,63.56 191.02,63.4 189.8,63.4 189.16,62.76 189.16,62.47 188.94,62.25 188.71,62.25 188.55,62.08 188.55,55.4 188.48,55.33 187.78,55.33 187.66,55.46 187.66,57.39 187.66,57.4 187.7,57.56 187.66,57.71 187.66,57.72 187.66,60.29 187.76,60.54 187.66,60.79 187.66,63.65 188.48,64.48 188.48,67.2 188.51,67.21 188.69,67.44 188.64,67.72 188.57,67.8 188.48,67.85 188.47,67.86 188.39,67.88 188.3,67.88 188.27,67.88 187.83,68.32 187.83,69.02 187.97,69.15 188.13,69.15 188.39,69.05 188.64,69.16 189.42,69.16 190.03,69.1 189.79,69.66 189.79,70.04 189.94,70.19 191.09,70.19
GND on BOTTOM (solid shape): 212.9,99.4 212.97,99.36 213,99.28 213.11,99.01 213.4,98.96 213.44,98.98 213.71,98.7 213.42,98.4 213.02,98.4 212.74,98.12 212.67,98.15 212.63,98.15 212.6,98.17 212.58,98.2 212.32,98.51 211.92,98.41 211.85,98.38 211.78,98.41 211.61,98.52 211.41,98.52 211.31,98.55 211.29,98.66 211.32,98.78 211.31,98.92 211.31,98.95 211.33,98.98 211.41,99.03 211.46,99.1 211.55,99.15 211.64,99.1 211.98,98.96 212.2,99.24 212.2,99.27 212.33,99.4
GND on BOTTOM (solid shape): 210.54,116.38 210.65,116.41 210.71,116.31 210.71,115.81 210.62,115.72 210.62,115.07 210.51,114.95 210.49,114.95 210.21,114.72 210.35,114.39 210.4,114.3 210.35,114.21 210.27,114.15 210.22,114.07 210.21,114.05 210.08,114.03 209.73,113.75 209.89,113.33 209.93,113.25 209.89,113.17 209.85,113.14 209.82,113.11 209.75,113.08 209.68,113.11 209.57,113.19 209.45,113.23 209.42,113.24 209.4,113.28 209.36,113.41 209.25,113.51 209.2,113.6 209.25,113.69 209.36,113.79 209.4,113.94 209.4,113.96 209.66,114.21 209.66,114.71 210.3,115.36 210.3,116.15
GND on BOTTOM (solid shape): 155.46,156.04 155.46,152.74 153.43,150.71 152.41,150.71 152.22,150.9 152.22,151.6 152.16,151.66 151.91,151.66 151.84,151.73 151.84,152.17 151.72,152.3 151.33,152.3 151.21,152.42 151.21,152.74 151.33,152.87 151.72,152.87 151.78,152.93 151.78,153.57 151.72,153.63 151.42,153.63 151.21,153.84 151.21,154.01 151.33,154.14 151.53,154.14 151.59,154.21 151.6,154.21 151.71,154.28 151.78,154.39 151.79,154.4 151.84,154.46 152.48,154.46 152.58,154.35 152.61,154.27 152.39,153.93 152.5,153.64 152.53,153.57 152.5,153.5 152.75,152.89 153,153.5 152.97,153.57 153,153.64 153.09,153.79 153.1,153.96 153.11,154.02 153.15,154.06 153.22,154.14 153.64,154.14 153.75,154.24 153.75,155.8 153.75,155.98 154.19,156.42 155.08,156.42
GND on BOTTOM (solid shape): 201.37,111.2 201.43,111.17 201.46,111.14 201.48,111.11 201.47,111.08 201.44,110.7 201.75,110.48 201.8,110.43 201.84,110.29 201.95,110.19 202,110.1 201.95,110.01 201.8,109.78 201.9,109.52 201.92,109.5 201.92,109.43 201.89,109.43 201.41,108.95 201.34,108.95 201.26,109.03 201.23,109.1 201.26,109.17 201.38,109.41 201.32,109.66 201.31,109.69 201.33,109.73 201.48,110.12 201.19,110.42 201.01,110.48 201,110.49 201,110.51 200.95,110.63 200.85,110.71 200.8,110.8 200.85,110.89 200.93,110.95 200.98,111.03 200.99,111.05 201.23,111.13 201.3,111.18
GND on BOTTOM (solid shape): 214.64,115.18 214.64,113.88 214.52,113.75 214.33,113.75 214.26,113.82 213.95,113.82 213.88,113.88 213.88,114.01 213.96,114.09 213.96,114.11 213.97,114.14 213.79,114.58 213.32,114.51 213.25,114.48 213.18,114.51 212.8,114.62 212.53,114.34 212.49,114.24 212.4,114.18 212.33,114.09 212.25,114.05 212.17,114.09 212.12,114.17 212.04,114.22 212,114.3 212.04,114.38 212.13,114.45 212.19,114.54 212.29,114.58 212.58,114.97 212.25,115.33 212.22,115.36 212.18,115.51 212.07,115.62 212.07,115.86 212.25,116.03 212.41,116.07 212.69,116.25 212.72,116.58 212.73,116.67 212.82,116.71 213.11,116.71
GND on BOTTOM (solid shape): 211.68,100.78 211.95,100.78 212.01,100.72 212.41,100.53 212.73,100.83 212.73,100.84 212.77,100.89 212.85,100.82 213.35,100.82 213.54,100.62 213.42,100.5 213.07,100.5 212.77,100.21 212.74,100.22 212.43,100.2 212.3,99.91 212.27,99.84 212.2,99.8 212.17,99.8 211.92,99.55 211.9,99.55 211.75,99.51 211.64,99.4 211.55,99.35 211.46,99.4 211.41,99.46 211.35,99.51 211.3,99.6 211.35,99.69 211.43,99.75 211.48,99.82 211.49,99.84 211.59,99.88 211.83,100.44 211.22,100.51 211.15,100.48 211.08,100.51 211.05,100.54 211.02,100.57 210.97,100.65 211.02,100.73 211.13,100.85 211.18,101 211.2,101.03 211.23,101.05 211.28,101.06 211.34,101.08 211.37,101.09
GND on BOTTOM (solid shape): 209.45,97.05 209.54,97 209.6,96.92 209.67,96.87 209.69,96.86 209.8,96.61 209.93,96.51 209.99,96.43 209.95,96.34 209.92,96.31 209.85,96.28 209.78,96.31 209.38,96.41 209.12,96.1 209.1,96.07 209.07,96.05 208.94,96.01 208.84,95.9 208.75,95.85 208.66,95.9 208.42,96.05 208.16,95.94 208.09,95.9 208.01,95.93 207.76,96.18 207.7,96.28 207.63,96.36 207.63,96.54 207.67,96.57 207.74,96.6 207.81,96.57 208.1,96.43 208.4,96.56 208.47,96.59 208.54,96.57 208.91,96.48 209.17,96.76 209.21,96.86 209.23,96.87 209.3,96.92 209.36,97
GND on BOTTOM (solid shape): 210.48,94.53 210.56,94.48 210.82,94.28 211.14,94.35 211.18,94.37 211.21,94.35 211.24,94.28 211.22,94.21 211.16,94.13 211.09,93.94 211.07,93.93 210.9,93.66 211.05,93.39 211.1,93.3 211.05,93.21 210.97,93.15 210.92,93.06 210.9,93.02 210.79,93.06 210.78,93.08 210.46,93.25 210.2,93 210.2,92.98 210.15,92.94 210.1,92.99 210.1,93 210.05,93.12 209.95,93.21 209.9,93.3 209.95,93.39 210.1,93.67 209.92,93.93 209.89,93.94 209.88,94 209.81,94.17 209.67,94.29 209.61,94.37 209.65,94.46 209.68,94.49 209.75,94.52 209.82,94.49 210.11,94.37 210.39,94.5
GND on BOTTOM (solid shape): 199.47,114.76 199.47,114.39 199.66,114.2 199.66,113.97 199.61,113.92 199.71,113.69 199.92,113.57 199.96,113.56 199.96,113.44 200.42,112.97 200.46,112.94 200.5,112.92 200.5,112.77 200.46,112.74 200.44,112.7 200.35,112.65 200.26,112.7 200.18,112.79 200.08,112.84 200.05,112.85 200.03,112.92 199.36,113.11 199.63,112.48 199.7,112.47 199.72,112.44 199.77,112.35 199.85,112.29 199.9,112.2 199.85,112.11 199.78,112.05 199.72,111.98 199.72,111.96 199.46,111.85 199.36,111.72 199.28,111.66 199.19,111.7 199.16,111.73 199.13,111.8 199.16,111.87 199.26,112.27 198.95,112.53 198.92,112.54 198.9,112.57 198.88,112.66 198.84,112.74 199.13,113.04 199.13,113.29 199.16,113.3 199.38,113.59 199.27,113.92 199.14,114.05 199.14,114.74 199.21,114.82 199.4,114.82
GND on BOTTOM (solid shape): 211.5,88.57 211.58,88.53 211.86,88.36 212.18,88.47 212.25,88.5 212.32,88.47 212.6,88.2 213.38,88.2 213.46,88.11 213.46,88 213.35,87.88 212.99,87.88 212.83,87.72 212.47,87.72 212.31,87.61 212.22,87.43 212.21,87.39 212.09,87.39 211.62,86.93 211.6,86.9 211.58,86.87 211.5,86.83 211.42,86.86 211.39,86.89 211.35,86.91 211.3,87 211.35,87.09 211.43,87.15 211.48,87.22 211.49,87.24 211.59,87.28 211.77,87.92 211.13,87.74 211.09,87.64 211.07,87.63 211,87.57 210.94,87.5 210.85,87.45 210.76,87.5 210.7,87.57 210.63,87.63 210.61,87.64 210.52,87.87 210.42,87.97 210.37,88.05 210.42,88.13 210.46,88.16 210.54,88.19 210.61,88.14 211.09,87.97 211.32,88.42 211.32,88.46 211.34,88.48 211.38,88.51 211.42,88.54
GND on BOTTOM (solid shape): 211.7,96.6 211.94,96.6 211.97,96.57 212.35,96.3 212.72,96.59 212.79,96.63 212.87,96.6 213.4,96.6 213.55,96.44 213.42,96.3 213.02,96.3 212.74,96.02 212.71,96.03 212.46,96.02 212.31,95.83 212.3,95.79 212.09,95.79 211.62,95.33 211.6,95.3 211.58,95.27 211.5,95.23 211.42,95.26 211.39,95.29 211.35,95.31 211.3,95.4 211.35,95.49 211.44,95.56 211.49,95.66 211.5,95.68 211.61,95.73 211.75,96.39 211.12,96.15 211.1,96.04 211.07,96.03 211,95.97 210.94,95.9 210.85,95.85 210.76,95.9 210.7,95.97 210.63,96.03 210.61,96.04 210.5,96.29 210.37,96.39 210.31,96.47 210.35,96.56 210.38,96.59 210.45,96.62 210.52,96.59 210.92,96.49 211.18,96.8 211.23,96.85 211.29,96.86 211.35,96.89 211.39,96.91
GND on BOTTOM (solid shape): outline of 98 points within 146.65,156.23 152.03,161.44
GND on BOTTOM (solid shape): 181.45,84.45 181.54,84.4 181.6,84.32 181.68,84.27 181.71,84.26 181.72,84.2 181.98,83.88 182.38,83.99 182.45,84.02 182.52,83.99 182.65,83.9 182.8,83.87 182.87,83.84 182.9,83.79 182.95,83.67 183.05,83.59 183.1,83.5 183.05,83.41 182.95,83.32 182.9,83.19 182.89,83.16 182.62,83.08 182.51,83 182.06,83 181.95,83.41 181.54,83.3 181.45,83.25 181.1,83.45 180.75,83.25 180.66,83.3 180.6,83.38 180.52,83.43 180.49,83.44 180.48,83.5 180.42,83.65 180.32,83.77 180.27,83.85 180.32,83.93 180.35,83.96 180.38,83.99 180.45,84.02 180.52,83.99 180.92,83.88 181.18,84.2 181.19,84.26 181.22,84.27 181.3,84.32 181.36,84.4
GND on BOTTOM (solid shape): 201.54,114.76 201.54,114.43 201.85,114.12 201.83,114.09 201.85,113.78 202.13,113.65 202.21,113.62 202.24,113.55 202.24,113.51 202.5,113.26 202.5,113.24 202.53,113.12 202.6,113.02 202.64,112.95 202.61,112.87 202.6,112.86 202.6,112.77 202.56,112.74 202.54,112.7 202.45,112.65 202.36,112.7 202.3,112.78 202.2,112.84 202.18,112.84 202.17,112.9 201.51,113.11 201.76,112.47 201.81,112.46 201.82,112.43 201.87,112.35 201.95,112.29 202,112.2 201.95,112.11 201.85,112.03 201.8,111.91 201.8,111.88 201.53,111.79 201.46,111.75 201.39,111.72 201.33,111.75 201.31,111.77 201.27,111.86 201.31,111.93 201.46,112.4 201.04,112.63 201,112.64 200.98,112.66 200.96,112.7 200.94,112.74 201.23,113.04 201.23,113.36 201.27,113.37 201.57,113.75 201.25,114.12 201.25,114.72 201.42,114.88
GND on BOTTOM (solid shape): 203.64,114.76 203.64,114.36 203.92,114.08 203.91,114.05 203.96,113.76 204.23,113.65 204.31,113.62 204.34,113.55 204.34,113.51 204.59,113.26 204.6,113.24 204.67,113.05 204.85,112.95 204.87,112.95 204.91,112.9 204.86,112.85 204.85,112.85 204.73,112.8 204.64,112.7 204.55,112.65 204.46,112.7 204.4,112.77 204.33,112.83 204.31,112.84 204.27,112.94 203.63,113.12 203.81,112.48 203.91,112.44 203.92,112.42 203.97,112.35 204.05,112.29 204.1,112.2 204.05,112.11 203.97,112.05 203.92,111.98 203.91,111.96 203.66,111.85 203.56,111.72 203.48,111.66 203.39,111.7 203.36,111.73 203.33,111.8 203.36,111.87 203.46,112.27 203.15,112.53 203.12,112.54 203.1,112.58 203.09,112.64 203.06,112.7 203.04,112.73 203.35,113.05 203.35,113.3 203.57,113.76 203.14,114.03 203.11,114.03 203.08,114.06 203.05,114.12 203.36,114.42 203.36,114.71 203.53,114.88
GND on BOTTOM (solid shape): 182.15,94.95 182.24,94.9 182.3,94.82 182.38,94.77 182.41,94.76 182.42,94.71 182.68,94.39 183.08,94.49 183.15,94.52 183.5,94.37 183.85,94.52 183.92,94.49 183.95,94.46 183.99,94.43 184.03,94.35 183.99,94.27 183.9,94.18 183.77,93.93 183.76,93.92 183.6,93.65 183.75,93.39 183.8,93.3 183.75,93.21 183.67,93.15 183.62,93.06 183.59,93.03 183.56,93.03 183.49,93.04 183.48,93.07 183.2,93.25 182.92,93.06 182.89,93.03 182.86,93.03 182.79,93.04 182.78,93.07 182.73,93.15 182.65,93.21 182.6,93.3 182.65,93.39 182.8,93.67 182.62,93.93 182.59,93.94 182.58,93.99 182.32,94.31 181.92,94.21 181.85,94.18 181.78,94.21 181.75,94.24 181.72,94.27 181.67,94.35 181.72,94.43 181.83,94.55 181.89,94.76 181.92,94.77 182,94.82 182.06,94.9
GND on BOTTOM (solid shape): 182.15,92.85 182.24,92.8 182.3,92.72 182.38,92.67 182.41,92.66 182.42,92.61 182.68,92.29 183.08,92.39 183.15,92.42 183.5,92.27 183.85,92.42 183.92,92.39 183.95,92.36 183.99,92.33 184.03,92.25 183.99,92.17 183.9,92.08 183.77,91.83 183.76,91.82 183.6,91.55 183.75,91.29 183.8,91.2 183.75,91.11 183.67,91.05 183.62,90.96 183.59,90.93 183.56,90.93 183.49,90.94 183.48,90.97 183.2,91.15 182.92,90.96 182.89,90.93 182.86,90.93 182.79,90.94 182.78,90.97 182.73,91.05 182.65,91.11 182.6,91.2 182.65,91.29 182.8,91.57 182.62,91.83 182.59,91.84 182.58,91.89 182.32,92.21 181.92,92.11 181.85,92.08 181.78,92.11 181.75,92.14 181.72,92.17 181.67,92.25 181.72,92.33 181.83,92.45 181.89,92.66 181.92,92.67 182,92.72 182.06,92.8
GND on BOTTOM (solid shape): 182.15,90.75 182.24,90.7 182.3,90.62 182.38,90.57 182.41,90.56 182.42,90.51 182.68,90.19 183.08,90.29 183.15,90.32 183.5,90.17 183.85,90.32 183.92,90.29 183.95,90.26 183.99,90.23 184.03,90.15 183.99,90.07 183.9,89.98 183.77,89.73 183.76,89.72 183.6,89.45 183.75,89.19 183.8,89.1 183.75,89.01 183.67,88.95 183.62,88.86 183.59,88.83 183.56,88.83 183.49,88.84 183.48,88.87 183.2,89.05 182.92,88.86 182.89,88.83 182.86,88.83 182.79,88.84 182.78,88.87 182.73,88.95 182.65,89.01 182.6,89.1 182.65,89.19 182.8,89.47 182.62,89.73 182.59,89.74 182.58,89.79 182.32,90.11 181.92,90.01 181.85,89.98 181.78,90.01 181.75,90.04 181.72,90.07 181.67,90.15 181.72,90.23 181.83,90.35 181.89,90.56 181.92,90.57 182,90.62 182.06,90.7
GND on BOTTOM (solid shape): outline of 135 points within 187.25,88.52 187.95,106.45
GND on BOTTOM (solid shape): 217.28,102.57 220.08,102.57 220.12,102.56 220.16,102.53 220.24,102.45 220.21,102.42 220.14,102.1 220.36,101.86 220.4,101.85 220.4,101.52 220.23,101.35 220.13,101.33 220.06,101.4 219.64,101.66 219.36,101.25 219.36,101.23 219.21,101.07 218.98,101.07 218.9,101.11 218.89,101.2 218.58,101.65 218.19,101.27 218.19,101.25 218,101.07 217.74,101.07 217.71,101.12 217.71,101.18 217.56,101.63 217.09,101.59 217.02,101.56 216.95,101.59 216.57,101.66 216.32,101.35 216.28,101.17 216.23,101.12 216.03,101.12 215.95,101.15 215.93,101.24 215.82,101.57 215.49,101.68 215.46,101.67 215.23,101.9 214.92,101.9 214.85,101.94 214.83,102.02 214.83,102.09 214.83,102.16 214.85,102.24 214.93,102.28 215.48,102.28 215.57,102.26 215.66,102.28 215.98,102.28 215.99,102.24 216.49,101.96 216.7,102.49 216.71,102.59 216.79,102.64 217.21,102.64
GND on BOTTOM (solid shape): 193,113.39 193.03,113.38 193.1,113.35 193.23,113.3 193.21,113.24 193.19,113.23 192.98,112.83 193.28,112.51 193.4,112.47 193.41,112.45 193.67,112.25 193.96,112.4 194.05,112.45 194.14,112.4 194.2,112.32 194.29,112.27 194.33,112.25 194.29,112.14 194.27,112.13 194.1,111.84 194.29,111.57 194.33,111.55 194.29,111.44 194.27,111.43 194.2,111.37 194.14,111.3 194.05,111.25 193.96,111.3 193.66,111.45 193.41,111.23 193.05,111 193.14,110.57 193.17,110.5 193.14,110.43 193.11,110.4 193.08,110.36 193,110.32 192.92,110.36 192.82,110.47 192.59,110.56 192.58,110.58 192.53,110.65 192.45,110.71 192.4,110.8 192.45,110.89 192.51,110.93 192.56,111 192.58,111.02 192.64,111.02 193.06,111.27 192.9,111.73 192.85,111.8 192.88,111.88 192.96,112.28 192.65,112.53 192.62,112.54 192.6,112.58 192.59,112.64 192.57,112.69 192.55,112.73 192.86,113.03 192.86,113.3 192.92,113.33 192.97,113.38
GND on BOTTOM (solid shape): outline of 87 points within 124.27,148.93 127.77,152.82
GND on BOTTOM (solid shape): outline of 149 points within 204.35,88.52 205.13,106.47
GND on BOTTOM (solid shape): 211.55,83.05 211.64,83 211.69,82.93 211.75,82.89 211.8,82.8 211.75,82.71 211.67,82.65 211.62,82.58 211.61,82.56 211.51,82.52 211.33,81.88 211.97,82.06 212.01,82.16 212.03,82.17 212.16,82.3 212.2,82.48 212.23,82.55 212.3,82.58 213.6,82.58 213.67,82.56 213.7,82.49 213.74,82.3 213.88,82.17 213.91,82.16 213.93,82.06 213.89,82.05 213.78,81.98 213.7,81.87 213.69,81.82 213.59,81.86 213.58,81.88 213.29,82.06 213.02,81.86 213,81.82 212.89,81.86 212.88,81.88 212.78,82 212.63,82.05 212.41,81.99 212.3,81.8 212.26,81.75 212.2,81.73 211.97,81.65 211.83,81.44 211.79,81.34 211.68,81.26 211.61,81.14 211.6,81.12 211.49,81.16 211.48,81.18 211.22,81.35 210.94,81.2 210.85,81.15 210.76,81.2 210.71,81.26 210.65,81.31 210.6,81.4 210.65,81.49 210.8,81.8 210.55,82.05 210.54,82.05 210.49,82.1 210.54,82.15 210.55,82.15 210.72,82.24 210.8,82.41 210.8,82.42 210.85,82.47 210.86,82.47 211.07,82.58 211.18,82.79 211.18,82.8 211.23,82.85 211.24,82.85 211.37,82.9 211.46,83
GND on BOTTOM (solid shape): 196.15,111.05 196.24,111 196.47,110.85 196.73,110.95 197.09,110.95 197.12,110.8 197.25,110.56 197.5,110.47 197.57,110.44 197.6,110.39 197.85,110.15 198.16,110.3 198.25,110.35 198.34,110.3 198.4,110.22 198.48,110.17 198.51,110.16 198.52,110.06 198.49,110.03 198.31,109.84 198.35,109.58 198.35,109.48 198.26,109.43 197.74,109.43 197.29,108.98 197.11,108.98 196.71,109.38 196.6,109.38 196.6,109.46 196.63,109.47 196.72,109.54 196.78,109.63 196.79,109.66 196.85,109.67 197.07,110.32 196.42,110.1 196.41,110.04 196.38,110.03 196.2,109.82 196.28,109.55 196.29,109.44 196.2,109.38 195.56,109.38 195.14,108.95 195.06,108.95 195,109.02 194.97,109.09 195,109.16 195.13,109.46 194.99,109.75 194.96,109.82 194.98,109.89 195.02,109.93 195.1,109.98 195.18,109.93 195.59,109.78 195.88,110.1 195.89,110.16 195.92,110.17 196.1,110.45 195.91,110.73 195.88,110.76 195.89,110.86 195.92,110.87 196,110.92 196.06,111
GND on BOTTOM (solid shape): 210.21,106.14 210.22,106.12 210.27,106.05 210.35,105.99 210.4,105.9 210.35,105.81 210.2,105.5 210.45,105.25 210.46,105.25 210.53,105.19 210.75,104.77 211.03,104.71 211.12,104.68 211.14,104.58 211.09,104.44 211.07,104.43 211,104.37 210.94,104.3 210.85,104.25 210.76,104.3 210.7,104.37 210.63,104.43 210.61,104.44 210.57,104.54 210.3,104.82 209.92,104.71 209.85,104.68 209.78,104.71 209.38,104.81 209.12,104.5 209.1,104.47 209.07,104.45 208.93,104.4 208.82,104.28 208.82,104.26 208.7,104.22 208.68,104.26 208.62,104.36 208.53,104.43 208.51,104.44 208.47,104.54 208.2,104.82 207.82,104.71 207.75,104.68 207.68,104.71 207.6,104.79 207.6,104.93 207.68,104.99 207.74,105.07 208.05,105.39 208.05,105.93 208.11,106.02 208.21,106.01 208.34,105.95 208.48,105.96 208.5,105.96 208.75,105.71 208.77,105.67 208.73,105.63 208.72,105.62 208.53,104.98 209.18,105.17 209.21,105.26 209.23,105.27 209.4,105.51 209.3,105.78 209.27,105.85 209.3,105.92 209.32,105.94 209.32,106.03 209.34,106.06 209.36,106.1 209.45,106.15 209.54,106.1 209.82,105.95 210.08,106.14 210.1,106.18
GND on BOTTOM (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.24 205.92,168.24 205.77,168.39 205.14,168.18 204.53,168.43 197.52,168.43 196.67,168.2 195.99,168.77 191.06,168.77 191.06,168.75 190.22,167.6 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on BOTTOM (solid shape): outline of 105 points within 185.83,109.09 189.48,114.78
GND on BOTTOM (solid shape): outline of 105 points within 181.67,95.13 185.45,99.15
GND on BOTTOM (solid shape): outline of 92 points within 207.6,101.9 213.61,104.08
GND on BOTTOM (solid shape): outline of 165 points within 202.95,88.52 203.73,106.47
GND on BOTTOM (solid shape): outline of 182 points within 190.05,88.52 190.75,106.45
GND on BOTTOM (solid shape): outline of 163 points within 188.65,88.52 189.35,106.45
GND on BOTTOM (solid shape): outline of 166 points within 201.55,88.52 202.32,106.47
GND on BOTTOM (solid shape): outline of 168 points within 191.45,88.52 192.15,106.45
GND on BOTTOM (solid shape): outline of 173 points within 192.85,88.52 193.55,106.45
GND on BOTTOM (solid shape): outline of 184 points within 200.15,88.52 200.93,106.47
GND on BOTTOM (solid shape): outline of 178 points within 198.75,88.52 199.53,106.47
GND on BOTTOM (solid shape): outline of 187 points within 197.35,88.52 198.13,106.47
GND on BOTTOM (solid shape): outline of 175 points within 194.16,88.57 194.95,106.45
GND on BOTTOM (solid shape): outline of 146 points within 16.77,0.2 320.25,62.45
GND on BOTTOM (solid shape): outline of 170 points within 226.85,65.89 319.75,176.3
GND on BOTTOM (solid shape): outline of 236 points within 205.45,106.85 211.33,114.79
GND on BOTTOM (solid shape): outline of 215 points within 1.45,51.84 177.1,178.6
GND on BOTTOM (solid shape): outline of 594 points within 178.67,86.73 184.76,109.65
GND on BOTTOM (solid shape): outline of 8472 points within 181.68,77.73 214.67,88.65
GND on BOTTOM (solid shape): outline of 9890 points within 160.45,31.08 180.9,53.23
GND on IN1 (solid shape): 53.37,18.03 55.62,18.03 55.96,17.69 55.96,4.98 55.4,4.43 50.85,4.43 50.53,4.75 50.53,8.18 50.37,8.34 50.37,17.46 50.19,17.64 48.58,17.64 48.46,17.76 48.46,18.86 48.46,18.86 48.46,18.99 48.82,19.34 52.06,19.34
GND on IN1 (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.26 205.56,168.26 205.02,168.19 204.53,168.43 197.52,168.43 196.92,168.18 196.29,168.38 191,168.38 190.04,167.55 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on IN1 (solid shape): outline of 139 points within 16.77,0.2 320.25,62.45
GND on IN1 (solid shape): outline of 919 points within 226.85,65.89 319.75,176.3
GND on IN1 (solid shape): outline of 162 points within 1.45,51.84 177.1,178.6
GND on IN2 (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.26 205.56,168.26 205.02,168.19 204.53,168.43 197.52,168.43 196.92,168.18 196.29,168.38 191,168.38 190.04,167.55 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on IN2 (solid shape): outline of 137 points within 16.77,0.2 320.25,62.45
GND on IN2 (solid shape): outline of 919 points within 226.85,65.89 319.75,176.3
GND on IN2 (solid shape): outline of 174 points within 1.45,51.84 177.1,178.6
GND on IN3 (solid shape): 53.39,18.05 55.64,18.05 55.96,17.73 55.96,16.03 55.96,16.03 55.96,3.2 50.53,3.2 50.53,8.18 50.37,8.34 50.37,17.35 50.1,17.61 48.55,17.61 48.46,17.7 48.46,19.05 48.82,19.4 52.03,19.4
GND on IN3 (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.26 205.56,168.26 205.02,168.19 204.53,168.43 197.52,168.43 196.92,168.18 196.29,168.38 191,168.38 190.04,167.55 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on IN3 (solid shape): outline of 137 points within 16.77,0.2 320.25,62.45
GND on IN3 (solid shape): outline of 799 points within 199.07,32.44 213.21,49.28
GND on IN3 (solid shape): outline of 919 points within 226.85,65.89 319.75,176.3
GND on IN3 (solid shape): outline of 166 points within 1.45,51.84 177.1,178.6
GND on IN4 (solid shape): 53.37,18.05 55.7,18.05 55.96,17.79 55.96,16.03 55.96,16.03 55.96,3.28 50.53,3.28 50.53,8.18 50.37,8.34 50.37,17.45 50.2,17.61 48.64,17.61 48.47,17.79 48.47,18.58 49.28,19.39 52.02,19.39
GND on IN4 (solid shape): 203.36,48.93 203.36,48.54 203.33,48.47 203.25,48.44 202.87,48.09 203.25,47.73 203.33,47.7 203.36,47.63 203.36,42.83 203.33,42.75 203.25,42.73 202.87,42.37 203.25,42.02 203.33,41.99 203.36,41.91 203.36,35.88 204.25,34.99 207.13,34.99 208.4,36.26 209.99,36.26 210.83,37.09 210.83,47.22 211.42,47.81 213.05,47.81 213.45,47.41 213.45,43.08 213.4,43.05 213.36,43 213.28,42.97 213.2,43 212.57,42.77 213.2,42.54 213.28,42.58 213.36,42.54 213.4,42.5 213.45,42.46 213.45,35.01 212.8,34.36 201.29,34.36 201.28,34.4 200.93,34.73 200.57,34.4 200.57,34.36 199.65,34.36 199.64,34.4 199.54,34.6 199.33,34.69 199.31,34.7 198.94,35.07 198.94,37.19 199.11,37.49 198.94,37.79 198.94,42.83 199.13,43.14 198.94,43.46 198.94,48.86 199.52,49.44 202.85,49.44
GND on IN4 (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.26 205.56,168.26 205.02,168.19 204.53,168.43 197.52,168.43 196.92,168.18 196.29,168.38 191,168.38 190.04,167.55 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on IN4 (solid shape): outline of 136 points within 16.77,0.2 320.25,62.45
GND on IN4 (solid shape): outline of 168 points within 226.85,65.89 319.75,176.3
GND on IN4 (solid shape): outline of 165 points within 1.45,51.84 177.1,178.6
GND on IN4 (solid shape): outline of 36600 points within 177.9,71.97 245.24,143.09
GND on IN5 (solid shape): 192.92,176.8 193.49,176.56 193.72,176 193.72,175.07 193.72,174.6 194.07,173.75 194.92,173.4 195.62,173.4 196.19,173.16 196.42,172.6 196.42,169.14 196.77,168.7 197.28,168.94 204.77,168.94 205.28,168.7 205.63,169.14 205.63,172.6 205.86,173.16 206.43,173.4 206.62,173.4 207.48,173.75 207.83,174.6 207.83,175.8 208.06,176.36 208.62,176.6 209.55,176.6 209.76,176.51 209.85,176.3 209.85,168.23 209.34,168.23 209.34,168.26 205.56,168.26 205.02,168.19 204.53,168.43 197.52,168.43 196.92,168.18 196.29,168.38 191,168.38 190.04,167.55 188.87,168.04 188.11,168.04 188.11,168.55 189.18,168.55 189.19,168.51 189.97,168.06 190.55,168.75 190.55,175.07 190.55,176 190.79,176.56 191.35,176.8
GND on IN5 (solid shape): outline of 138 points within 16.77,0.2 320.25,62.45
GND on IN5 (solid shape): outline of 919 points within 226.85,65.89 319.75,176.3
GND on IN5 (solid shape): outline of 161 points within 1.45,51.84 177.1,178.6
GND on GND1: outline of 357 points within 1.15,0.2 320.25,178.6 ; 5 cut-outs
GND on GND2: outline of 357 points within 1.15,0.2 320.25,178.6 ; 1 cut-out
GND on VCC: outline of 234 points within 107.07,17.49 319.23,177.58 ; 1 cut-out
GND on VCC: 82.53,25.35 81.86,26.03 81.86,80.3 89.64,88.09 94.72,88.09 98.99,92.35 107.84,92.35 123.96,92.34 138.31,92.28 138.31,90.33 140.59,88.05 140.59,85.19 149.55,76.24 149.48,25.35
GND on VCC: 25.11,42.9 24.52,43.49 24.52,45.08 24.05,45.54 21.62,45.54 19.88,43.81 17.31,43.81 16.61,43.1 16.61,41.26 15,39.66 15,38.29 13.94,37.23 13.53,37.23 2.17,37.23 2.17,37.37 2.17,37.37 2.17,38.08 8.92,38.08 10.79,37.71 11.85,39.3 11.85,52.9 10.79,54.49 8.92,54.12 2.47,54.12 2.47,59.53 39.44,59.53 39.44,52.19 33.28,46.03 33.28,27.68 28.97,23.37 28.97,11.35 33.73,6.59 33.73,5.21 33.71,5.21 33.71,4.01 32.78,3.19 32.43,2 32.43,1.22 21.87,1.22 21.87,10.3 21.22,11.87 19.65,12.52 16.77,12.52 16.77,13.37 19.82,16.42 19.82,27.91 20.24,28.34 26.97,28.34 27.75,29.12 27.75,33.33 27.6,33.48 27.52,33.48 27.52,35.12 27.39,35.25 27.4,35.25 27.4,35.46 27.25,35.61 24.26,35.61 24.07,35.81 24.07,40.61 24.17,40.72 25,40.72 25.15,40.86 25.15,41.07 25.11,41.11
GND on GND3: outline of 359 points within 1.15,0.2 320.25,178.6 ; 2 cut-outs
GND on GND4: outline of 358 points within 1.15,0.2 320.25,178.6 ; 1 cut-out
GNDA on TOP (solid shape): 18.23,26.58 18.23,24.77 18.2,24.74 17.56,24.74 17.51,24.8 17.51,25.93 17.41,26.02 17.1,26.02 16.8,26.31 16.8,26.75 16.6,26.95 16.44,26.95 16.36,27.02 16.36,27.25 16.46,27.35 17.45,27.35
GNDA on GND1: outline of 86 points within 0.2,11.5 27.32,45.04
GNDA on GND2: outline of 85 points within 0.2,11.5 27.32,45.04
GNDA on VCC: 14.33,12.52 2.77,12.52 2.76,12.56 12.4,12.56 13.99,13.61 13.62,15.49 13.62,19.56 13.99,21.44 12.4,22.49 2.73,22.49 2.87,22.87 2.92,23.27 2.92,24.47 2.88,24.85 2.76,25.21 12.4,25.21 13.99,26.26 13.62,28.14 13.62,32.21 13.99,34.09 12.4,35.14 1.98,35.14 2.12,35.51 2.17,35.89 2.17,36.72 13.53,36.72 14.16,36.73 15.51,38.08 15.51,39.42 17.12,41.03 17.12,42.85 17.55,43.29 20.08,43.29 21.83,45.04 23.84,45.04 24.01,44.87 24.01,43.28 24.75,42.54 24.91,42.54 24.91,41.22 23.96,41.22 23.56,40.82 23.56,35.6 24.05,35.1 27.25,35.1 27.25,35.1 27.32,35.03 27.32,33.4 27.25,33.33 27.25,29.33 26.76,28.84 20.03,28.84 19.31,28.12 19.31,16.63 16.26,13.58 16.26,12.52 15.42,12.52
GNDA on GND3: outline of 85 points within 0.2,11.5 27.32,45.04
GNDA on GND4: outline of 85 points within 0.2,11.5 27.32,45.04
VIN on TOP (solid shape): 47.95,48.78 47.95,44.46 47.57,44.08 44.64,44.08 44.01,43.45 40.64,43.45 40.39,43.7 40.39,47.39 42.36,49.35 47.38,49.35
VIN on BOTTOM (solid shape): 47.69,50.34 47.69,49.66 47.92,49.42 48.19,49.42 48.34,49.27 48.34,44.73 47.5,43.89 45.09,43.89 42.23,41.04 39.18,41.04 38.99,41.23 38.99,47.2 39.37,47.58 41.34,47.58 41.66,47.89 41.66,54.12 42.31,54.76 43.26,54.76
+EC_VCCA on TOP (solid shape): 100.47,23.61 100.55,23.54 100.55,22.92 100.41,22.78 100.38,22.75 100.38,20.54 100.33,20.48 100.23,20.48 100.17,20.55 100.17,22.56 99.83,22.89 99.42,22.89 99.26,23.05 99.26,23.44 99.42,23.61 100.14,23.61
+FBX_PLLAVDD on BOTTOM (solid shape): 202.69,87.53 202.69,87.22 202.36,86.89 202.36,86.7 202.21,86.55 202.02,86.55 201.65,86.92 201.65,87.15 202.06,87.55 202.31,87.55 202.48,87.72 202.5,87.72
+FBX_PLLAVDD on BOTTOM (solid shape): 207.14,90.93 207.14,90.78 206.92,90.56 206.87,90.56 206.58,90.27 206.58,89.91 206.52,89.85 206.08,89.85 206.07,89.86 206.07,90.5 206.59,91.02 207.05,91.02
+HDMI_5V_OUT on TOP (solid shape): 187.21,166.33 187.21,162.52 186.96,162.27 184.93,162.27 184.86,162.33 184.86,163.92 185.18,164.24 185.62,164.24 186.2,164.81 186.2,166.39 186.39,166.58 186.96,166.58
+INV_PWR_SRC on TOP (solid shape): 120.73,160.44 120.73,159.35 120.92,159.16 122.75,159.16 124.5,157.4 124.5,156.26 124.31,156.07 122.71,156.07 122.53,156.25 117.91,156.25 117.73,156.42 117.73,157.17 122.99,157.17 123,157.11 123.01,157.06 123.03,157.01 123.06,156.97 123.09,156.93 123.13,156.89 123.17,156.86 123.22,156.84 123.27,156.82 123.32,156.81 123.38,156.81 123.43,156.82 123.48,156.84 123.53,156.86 123.57,156.89 123.61,156.93 123.65,156.97 123.67,157.01 123.69,157.06 123.7,157.11 123.71,157.17 123.7,157.22 123.69,157.27 123.67,157.32 123.65,157.37 123.61,157.41 123.57,157.45 123.53,157.48 123.48,157.5 123.43,157.52 123.38,157.52 123.32,157.52 123.27,157.52 123.22,157.5 123.17,157.48 123.13,157.45 123.09,157.41 123.06,157.37 123.03,157.32 123.01,157.27 123,157.22 122.99,157.17 117.73,157.17 117.73,158.85 118,159.12 118.51,159.12 118.91,159.52 118.91,160.43 119.04,160.55 120.61,160.55
+LAN_IO on TOP (solid shape): 204.04,150.07 204.11,150.03 204.18,150 204.2,150 204.42,149.77 204.42,148.87 203.98,148.42 203.21,148.42 203.21,149.06 203.53,149.38 203.53,149.39 203.53,150.01 203.6,150.07
+LAN_IO on BOTTOM (solid shape): 196,154.14 197.5,154.14 197.63,154.01 197.63,153.49 198.73,152.39 199.13,152.39 199.2,152.31 199.2,151.41 199.13,151.34 198.97,151.34 198.91,151.4 197.36,151.4 197.07,151.68 197.07,151.7 197.05,151.7 196.89,151.87 194.87,151.87 194.66,151.66 193.98,151.66 193.86,151.78 193.86,152.3 194.01,152.44 194.07,152.49 194.12,152.55 194.22,152.66 194.65,152.66 194.92,152.93 194.92,154.08 195,154.15 196,154.15
+LCDVDD on TOP (solid shape): 126.79,162.15 126.79,159.5 126.71,159.42 125.49,159.42 125.44,159.47 125.44,160.6 125.33,160.72 125.33,161.8 125.8,162.28 126.66,162.28
+LCDVDD on BOTTOM (solid shape): 141.6,171.31 141.6,170.24 141.25,169.88 139.11,169.88 138.91,170.09 138.91,171.51 139.31,171.91 141,171.91
+LCDVDD on BOTTOM (solid shape): 143.65,168.41 143.65,167.45 143.77,167.34 143.77,165.43 142.82,164.48 140.02,164.48 139.83,164.67 139.83,164.99 140.18,165.33 141,165.33 141.36,165.69 141.36,167.46 141.8,167.91 141.8,168.67 141.93,168.8 143.27,168.8
+LCDVDD on IN1 (solid shape): outline of 745 points within 124.5,160.57 140.34,172.63
+LCDVDD on IN2 (solid shape): outline of 639 points within 124.64,160.06 140.71,171.72
+NVVDD1 on TOP (solid shape): outline of 777 points within 188.42,55.14 213.06,70.45
+NVVDD1 on TOP (solid shape): outline of 846 points within 176.39,97.31 194.29,113.87
+NVVDD1 on BOTTOM (solid shape): 198.82,102.79 198.67,102.64 198.67,102.6 198.67,102.58 198.62,102.4 198.67,102.21 198.67,102.2 198.67,102.14 198.8,102.01 198.8,101.41 198.6,101.21 198.6,100.84 198.82,100.61 198.82,99.96 198.6,99.74 198.6,99.65 198.38,99.43 198.2,99.43 198.11,99.52 198.11,99.73 198.25,99.88 198.25,103.06 198.82,103.06
+NVVDD1 on BOTTOM (solid shape): 201.05,95.39 201.12,95.48 201.23,95.46 201.33,95.36 201.4,95.36 201.4,95.19 201.7,94.89 201.7,92.05 201.67,92.01 201.61,92.02 201.6,92.02 201.05,92.02 201.05,93.14 200.93,93.26 200.93,93.34 201.08,93.49 201.08,93.79 200.93,93.94 200.93,94.06 201.05,94.19
+NVVDD1 on BOTTOM (solid shape): 191.13,103.14 191.23,103.16 191.3,103.07 191.3,99.82 191.36,99.75 191.36,99.58 191.26,99.47 191.11,99.47 190.89,99.69 190.89,99.81 190.6,100.09 190.6,100.51 190.88,100.79 190.88,101.21 190.58,101.51 190.58,101.89 190.85,102.16 190.85,102.61 190.63,102.84 190.63,103.08 191.06,103.08
+NVVDD1 on BOTTOM (solid shape): 201.13,103.06 201.62,103.06 201.62,102.79 201.47,102.64 201.47,102.6 201.47,102.58 201.42,102.4 201.47,102.21 201.47,102.2 201.47,102.14 201.6,102.01 201.6,101.41 201.4,101.21 201.4,100.84 201.62,100.61 201.62,99.96 201.38,99.72 201.27,99.72 200.98,99.44 200.88,99.54 200.88,99.7 200.95,99.77 200.99,99.86 201,99.88 201.05,99.94 201.05,103.04 201.12,103.07
+NVVDD1 on BOTTOM (solid shape): 188.61,95.43 188.61,95.29 188.5,95.17 188.5,91.92 188.43,91.83 188.32,91.85 188.26,91.91 187.93,91.91 187.93,92.26 188.08,92.41 188.08,92.55 188.08,92.6 188.08,92.65 188.08,92.81 187.95,92.94 187.95,93.66 188.08,93.79 188.08,93.95 188.08,94 188.08,94.05 188.08,94.16 187.9,94.34 187.9,95.06 188.08,95.24 188.08,95.34 188.28,95.54 188.5,95.54
+NVVDD1 on BOTTOM (solid shape): 193.93,103.12 194.03,103.14 194.1,103.05 194.1,99.98 193.83,99.98 193.68,99.84 193.4,100.11 193.4,100.51 193.68,100.79 193.68,100.95 193.68,101 193.68,101.05 193.68,101.21 193.38,101.51 193.38,101.89 193.65,102.16 193.65,102.25 193.66,102.26 193.68,102.4 193.66,102.54 193.65,102.55 193.65,102.61 193.43,102.84 193.43,103.06 193.86,103.06
+NVVDD1 on BOTTOM (solid shape): 203.85,103.07 203.89,103.11 203.94,103.1 203.97,103.08 204.42,103.08 204.42,102.79 204.27,102.64 204.27,102.6 204.27,102.58 204.22,102.4 204.27,102.21 204.27,102.2 204.27,102.14 204.4,102.01 204.4,101.41 204.2,101.21 204.2,100.84 204.42,100.61 204.42,99.96 204.2,99.74 204.2,99.66 204,99.47 203.8,99.47 203.7,99.57 203.7,99.73 203.85,99.88
+NVVDD1 on BOTTOM (solid shape): 191.4,95.44 191.4,95.25 191.3,95.14 191.3,91.93 191.23,91.84 191.13,91.86 191.05,91.93 190.73,91.93 190.73,92.26 190.88,92.41 190.88,92.55 190.88,92.6 190.88,92.65 190.88,92.81 190.75,92.94 190.75,93.66 190.88,93.79 190.88,93.95 190.88,94 190.88,94.05 190.88,94.16 190.7,94.34 190.7,95.09 190.88,95.26 190.88,95.33 191.1,95.55 191.29,95.55
+NVVDD1 on BOTTOM (solid shape): 203.85,95.36 203.92,95.45 204.02,95.43 204.16,95.3 204.2,95.3 204.2,95.19 204.42,94.96 204.42,94.41 204.22,94.21 204.22,94.05 204.22,94 204.22,93.95 204.22,93.79 204.5,93.51 204.5,93.06 204.22,92.79 204.22,92.65 204.22,92.6 204.22,92.55 204.22,92.41 204.42,92.21 204.42,92.04 203.85,92.04 203.85,92.91 203.88,92.93 203.88,93.79 203.78,93.89 203.78,94.11 203.85,94.19
+NVVDD1 on BOTTOM (solid shape): 193.82,95.08 193.92,95.08 193.96,95.07 194,95.07 194.07,95.04 194.1,94.97 194.1,91.92 194.03,91.83 193.93,91.85 193.85,91.92 193.53,91.92 193.53,92.26 193.68,92.41 193.68,92.55 193.68,92.6 193.68,92.65 193.68,92.81 193.55,92.94 193.55,93.66 193.68,93.79 193.68,93.95 193.68,94 193.68,94.05 193.68,94.16 193.5,94.34 193.5,95.06 193.67,95.22
+NVVDD1 on BOTTOM (solid shape): 198.25,95.37 198.32,95.46 198.43,95.44 198.55,95.32 198.6,95.32 198.6,95.19 198.82,94.96 198.82,94.41 198.62,94.21 198.62,94.05 198.62,94 198.62,93.95 198.62,93.79 198.9,93.51 198.9,93.06 198.62,92.79 198.62,92.6 198.62,92.55 198.62,92.41 198.82,92.21 198.82,91.94 198.23,91.94 198.19,91.97 198.2,92.03 198.25,92.09 198.25,93.14 198.13,93.26 198.13,93.34 198.28,93.49 198.28,93.79 198.13,93.94 198.13,94.06 198.25,94.19
+NVVDD1 on BOTTOM (solid shape): outline of 93 points within 188.67,55.27 211.6,70.76
+NVVDD1 on BOTTOM (solid shape): 188.53,95.72 188.55,95.66 188.55,95.59 188.58,95.56 188.67,95.44 188.67,95.29 188.55,95.15 188.55,94.97 188.55,94.96 188.55,94.44 188.53,94.35 188.55,94.24 188.6,94.17 188.64,94.13 188.68,94 188.64,93.87 188.6,93.83 188.55,93.76 188.53,93.65 188.55,93.56 188.55,93.04 188.53,92.95 188.55,92.84 188.6,92.77 188.64,92.73 188.68,92.6 188.64,92.47 188.6,92.43 188.55,92.36 188.53,92.25 188.55,92.16 188.55,91.8 188.49,91.71 188.37,91.73 188.24,91.86 187.88,91.86 187.88,92.28 187.92,92.33 187.92,92.37 188.03,92.48 188.03,92.72 187.92,92.83 187.92,92.85 187.9,92.98 187.9,93.62 187.9,93.63 187.9,93.66 187.9,93.7 187.92,93.75 187.92,93.77 188.03,93.88 188.03,94.12 187.92,94.23 187.92,94.25 187.85,94.32 187.85,95.08 187.93,95.16 187.96,95.19 188.03,95.26 188.03,95.39 188.06,95.45 188.12,95.48 188.16,95.49 188.22,95.5 188.29,95.56 188.33,95.61 188.49,95.77
+NVVDD1 on BOTTOM (solid shape): 188.37,103.17 188.49,103.19 188.55,103.1 188.55,102.84 188.53,102.75 188.55,102.64 188.6,102.57 188.65,102.53 188.68,102.4 188.65,102.27 188.6,102.23 188.55,102.16 188.53,102.05 188.55,101.96 188.55,101.44 188.53,101.35 188.55,101.24 188.6,101.17 188.65,101.13 188.68,101 188.65,100.87 188.6,100.83 188.55,100.76 188.53,100.65 188.55,100.56 188.55,100.04 188.55,100.03 188.55,99.85 188.67,99.71 188.67,99.56 188.58,99.44 188.55,99.41 188.55,99.35 188.49,99.35 188.44,99.36 188.35,99.37 188.29,99.44 188.22,99.5 188.15,99.51 188.11,99.52 188.05,99.55 188.02,99.61 188.01,99.65 188,99.7 188,99.77 187.97,99.8 187.93,99.85 187.9,99.91 187.89,99.95 187.75,100.09 187.75,100.53 187.89,100.68 187.92,100.75 187.92,100.77 188.03,100.88 188.03,101.12 187.92,101.23 187.92,101.25 187.89,101.32 187.73,101.49 187.73,101.91 187.89,102.08 187.92,102.15 187.92,102.17 188,102.25 188,102.3 188,102.31 188.02,102.4 188,102.49 188,102.5 188,102.55 187.92,102.63 187.92,102.67 187.78,102.82 187.78,103.11 187.81,103.15 187.86,103.14 187.9,103.11 188.31,103.11
+NVVDD1 on BOTTOM (solid shape): outline of 3696 points within 174.19,87.4 206.29,119.21
+NVVDD1 on IN4 (solid shape): outline of 17699 points within 177.05,61.75 210.9,116.48
+NVVDD1 on IN5 (solid shape): outline of 16529 points within 179.08,54.97 210.75,118.67
+NVVDD1 on VCC: 171.63,54.89 170.89,55.63 170.89,62.74 161.36,72.25 161.36,103.22 174.81,116.67 179.44,116.67 182.52,113.59 184.61,113.59 189.43,108.76 189.43,107.87 190.09,107.21 204.44,107.21 205.75,105.9 205.75,87.87 208.42,85.2 208.42,67.42 210.77,65.07 210.77,56.9 208.76,54.89
+NVVDD1 on GND3: 183.89,61.56 180.93,64.52 180.93,81.44 184.48,85.01 184.48,93.16 181.98,95.66 179.38,95.66 179.15,95.89 179.15,98.05 177.18,100.02 177.18,112.89 177.73,113.44 179.87,113.44 181.58,111.72 185.39,111.72 190.35,106.77 205.01,106.77 205.75,106.03 205.75,88.25 208.55,85.45 208.55,83.29 211.98,79.87 211.98,63.69 209.84,61.56
+NVVDD2 on TOP (solid shape): 227.34,64.54 230.07,64.54 230.46,64.16 230.46,61.75 230.2,61.49 223.47,61.49 222.52,60.54 219.34,60.54 218.39,61.49 213.44,61.49 213.28,61.65 213.28,63.84 215.79,66.35 215.79,66.76 216.74,67.72 224.17,67.72
+NVVDD2 on BOTTOM (solid shape): 221.82,67.27 221.82,59.65 220.8,58.63 213.12,58.63 212.42,59.33 212.42,63.08 215.91,66.57 215.91,67.14 216.55,67.78 221.31,67.78
+NVVDD2 on BOTTOM (solid shape): 191.3,106.28 191.3,103.53 191,103.23 190.63,103.23 190.63,103.36 190.8,103.54 190.8,103.57 190.81,103.58 190.87,103.89 190.68,104.14 190.68,104.79 190.9,105.01 190.9,105.39 190.78,105.51 190.78,105.64 190.88,105.74 190.88,105.85 190.88,105.9 190.88,105.95 190.88,106.11 190.65,106.34 190.65,106.39 190.72,106.46 191.12,106.46
+NVVDD2 on BOTTOM (solid shape): 201.67,91.74 201.67,91.66 201.42,91.41 201.42,91.25 201.42,91.2 201.42,91.15 201.42,91.01 201.6,90.84 201.6,90.19 201.42,90.01 201.42,89.85 201.42,89.8 201.42,89.75 201.42,89.64 201.57,89.49 201.57,89.44 201.42,89.29 201.42,89.15 201.42,89.1 201.42,89.05 201.42,88.89 201.68,88.63 201.68,88.58 201.59,88.49 201.39,88.49 201.05,88.83 201.05,88.96 200.95,89.06 200.95,89.21 201.08,89.34 201.08,90.34 200.98,90.44 200.98,90.64 201.08,90.74 201.08,91.69 201.01,91.76 201.12,91.87 201.54,91.87
+NVVDD2 on BOTTOM (solid shape): 204.42,91.81 204.42,91.61 204.22,91.41 204.22,91.25 204.22,91.2 204.22,91.15 204.22,91.01 204.4,90.84 204.4,90.19 204.22,90.01 204.22,89.85 204.22,89.8 204.22,89.75 204.22,89.64 204.37,89.49 204.37,89.44 204.22,89.29 204.22,89.15 204.22,89.1 204.22,89.05 204.22,88.89 204.48,88.63 204.48,88.6 204.39,88.51 204.19,88.51 203.85,88.85 203.85,88.96 203.75,89.06 203.75,89.21 203.88,89.34 203.88,90.34 203.78,90.44 203.78,90.64 203.88,90.74 203.88,91.69 203.8,91.77 203.92,91.89 204.34,91.89
+NVVDD2 on BOTTOM (solid shape): 191.3,91.47 191.3,88.84 191,88.54 190.75,88.54 190.68,88.61 190.68,88.74 190.85,88.91 190.85,88.95 190.86,88.96 190.88,89.1 190.86,89.24 190.85,89.25 190.85,89.29 190.73,89.41 190.73,89.44 190.85,89.56 190.85,89.65 190.86,89.66 190.88,89.8 190.86,89.94 190.85,89.95 190.85,90.01 190.7,90.16 190.7,90.26 190.69,90.28 190.69,90.82 190.88,91.01 190.88,91.15 190.88,91.2 190.88,91.25 190.88,91.41 190.74,91.55 190.74,91.78 190.99,91.78
+NVVDD2 on BOTTOM (solid shape): 194.1,91.46 194.1,88.83 193.8,88.53 193.55,88.53 193.48,88.6 193.48,88.74 193.65,88.91 193.65,88.95 193.66,88.96 193.68,89.1 193.66,89.24 193.65,89.25 193.65,89.29 193.53,89.41 193.53,89.44 193.65,89.56 193.65,89.65 193.66,89.66 193.68,89.8 193.66,89.94 193.65,89.95 193.65,90.01 193.5,90.16 193.5,90.26 193.49,90.28 193.49,90.82 193.68,91.01 193.68,91.15 193.68,91.2 193.68,91.25 193.68,91.41 193.54,91.55 193.54,91.77 193.79,91.77
+NVVDD2 on BOTTOM (solid shape): 188.46,106.63 188.46,105.55 188.5,105.51 188.5,103.44 188.27,103.21 187.94,103.21 187.84,103.31 187.84,103.37 188,103.54 188,103.57 188.01,103.58 188.07,103.89 187.88,104.14 187.88,104.79 188.1,105.01 188.1,105.39 187.98,105.51 187.98,105.64 188.08,105.74 188.08,105.85 188.08,105.9 188.08,105.95 188.08,106.11 187.59,106.6 187.54,106.6 187.54,106.68 187.57,106.7 187.63,106.75 187.67,106.81 187.69,106.84 188.25,106.84
+NVVDD2 on BOTTOM (solid shape): 194.1,106.26 194.1,103.51 193.8,103.21 193.43,103.21 193.43,103.36 193.6,103.54 193.6,103.57 193.61,103.58 193.68,103.84 193.56,104.08 193.56,104.26 193.66,104.5 193.56,104.74 193.56,104.87 193.7,105.01 193.7,105.39 193.58,105.51 193.58,105.64 193.68,105.74 193.68,105.85 193.68,105.9 193.68,105.95 193.68,106.11 193.45,106.34 193.45,106.37 193.52,106.44 193.92,106.44
+NVVDD2 on BOTTOM (solid shape): 198.89,106.33 198.67,106.11 198.67,106.1 198.67,106.08 198.62,105.89 198.67,105.7 198.67,105.4 198.62,105.21 198.67,105.01 198.67,105 198.67,104.99 198.85,104.81 198.85,104.21 198.65,104.01 198.65,103.95 198.64,103.94 198.62,103.8 198.64,103.66 198.65,103.65 198.65,103.54 198.82,103.36 198.82,103.26 198.77,103.21 198.38,103.21 198.36,103.23 198.36,103.33 198.25,103.44 198.25,106.26 198.45,106.46 198.89,106.46
+NVVDD2 on BOTTOM (solid shape): 201.7,106.34 201.47,106.11 201.47,106.08 201.42,105.89 201.47,105.7 201.47,105.4 201.42,105.21 201.47,105.01 201.47,104.99 201.65,104.81 201.65,104.21 201.45,104.01 201.45,103.95 201.44,103.94 201.42,103.8 201.44,103.66 201.45,103.65 201.45,103.54 201.62,103.36 201.62,103.25 201.58,103.21 201.19,103.21 201.17,103.23 201.17,103.33 201.05,103.45 201.05,106.25 201.26,106.46 201.7,106.46
+NVVDD2 on BOTTOM (solid shape): 204.54,106.38 204.27,106.11 204.27,106.1 204.27,106.08 204.22,105.89 204.27,105.7 204.27,105.4 204.22,105.21 204.27,105.01 204.27,105 204.27,104.99 204.45,104.81 204.45,104.21 204.25,104.01 204.25,103.95 204.24,103.94 204.22,103.8 204.24,103.66 204.25,103.65 204.25,103.54 204.42,103.36 204.42,103.23 204.03,103.23 204.01,103.25 204.01,103.35 203.85,103.51 203.85,106.23 204.1,106.48 204.54,106.48
+NVVDD2 on BOTTOM (solid shape): 188.3,99.28 188.35,99.27 188.4,99.27 188.47,99.24 188.5,99.17 188.5,96.3 188.6,96.2 188.6,96.02 188.18,95.6 188.04,95.6 187.94,95.71 187.94,95.86 188.08,96 188.08,96.05 188.08,96.1 188.08,96.15 188.08,96.29 187.9,96.47 187.9,97.13 188.1,97.34 188.1,97.66 187.9,97.86 187.9,98.51 188.05,98.66 188.05,98.75 188.06,98.76 188.08,98.9 188.06,99.04 188.05,99.05 187.98,99.12 187.94,99.16 187.94,99.31 188.03,99.4 188.18,99.4
+NVVDD2 on BOTTOM (solid shape): 188.5,91.46 188.5,88.81 188.21,88.52 187.96,88.52 187.88,88.6 187.88,88.74 188.05,88.91 188.05,88.95 188.06,88.96 188.08,89.1 188.06,89.24 188.05,89.25 188.05,89.29 187.93,89.41 187.93,89.44 188.05,89.56 188.05,89.65 188.07,89.71 188.08,89.82 188.06,89.94 188.05,89.95 188.05,90.01 187.9,90.16 187.9,90.26 187.9,90.27 187.9,90.83 188.08,91.01 188.08,91.15 188.08,91.2 188.08,91.25 188.08,91.41 187.95,91.54 187.95,91.76 188.2,91.76
+NVVDD2 on BOTTOM (solid shape): 191.07,99.29 191.13,99.27 191.2,99.27 191.27,99.24 191.3,99.17 191.3,95.83 191.27,95.76 191.2,95.73 191.14,95.73 191.08,95.71 190.94,95.58 190.84,95.58 190.73,95.69 190.73,95.83 190.88,95.98 190.88,96.05 190.88,96.1 190.88,96.15 190.88,96.29 190.7,96.47 190.7,97.13 190.9,97.34 190.9,97.66 190.7,97.86 190.7,98.56 190.85,98.71 190.85,98.75 190.86,98.76 190.88,98.9 190.86,99.04 190.85,99.05 190.76,99.14 190.76,99.33 190.82,99.39 190.97,99.39
+NVVDD2 on BOTTOM (solid shape): 194.1,95.23 193.95,95.23 193.87,95.3 193.78,95.34 193.76,95.35 193.68,95.43 193.68,96.05 193.68,96.1 193.68,96.15 193.68,96.29 193.51,96.46 193.51,97.14 193.7,97.34 193.7,97.66 193.51,97.86 193.51,98.52 193.65,98.66 193.65,98.75 193.66,98.76 193.68,98.9 193.66,99.04 193.65,99.05 193.65,99.45 193.68,99.53 193.68,99.6 193.7,99.63 193.73,99.65 193.87,99.7 193.97,99.8 193.98,99.83 194.1,99.83
+NVVDD2 on BOTTOM (solid shape): 198.82,91.69 198.82,91.61 198.62,91.41 198.62,91.25 198.62,91.2 198.62,91.15 198.62,91.01 198.76,90.87 198.76,90.76 198.64,90.5 198.76,90.24 198.76,90.15 198.62,90.01 198.62,89.85 198.62,89.8 198.62,89.75 198.62,89.64 198.77,89.49 198.77,89.44 198.62,89.29 198.62,89.15 198.62,89.1 198.62,89.05 198.62,88.89 198.86,88.65 198.86,88.5 198.77,88.41 198.57,88.41 198.25,88.73 198.25,88.96 198.15,89.06 198.15,89.21 198.28,89.34 198.28,90.34 198.18,90.44 198.18,90.64 198.28,90.74 198.28,91.69 198.24,91.73 198.3,91.79 198.72,91.79
+NVVDD2 on BOTTOM (solid shape): 201.43,99.39 201.5,99.36 201.55,99.31 201.55,99.19 201.42,99.06 201.42,98.95 201.42,98.9 201.42,98.85 201.42,98.74 201.57,98.59 201.57,97.84 201.45,97.71 201.45,97.65 201.44,97.64 201.42,97.5 201.44,97.36 201.45,97.34 201.53,97.23 201.62,97.16 201.62,96.46 201.42,96.26 201.42,96.15 201.42,96.1 201.42,96.05 201.42,95.91 201.57,95.76 201.57,95.71 201.5,95.64 201.43,95.61 201.36,95.63 201.28,95.69 201.19,95.72 201.17,95.73 201.05,95.85 201.05,99.27 201.1,99.27 201.24,99.29 201.36,99.37
+NVVDD2 on BOTTOM (solid shape): 204.23,99.39 204.29,99.36 204.35,99.31 204.35,99.19 204.22,99.06 204.22,98.95 204.22,98.9 204.22,98.85 204.22,98.74 204.37,98.59 204.37,97.84 204.25,97.71 204.25,97.65 204.24,97.64 204.22,97.5 204.24,97.36 204.25,97.34 204.33,97.23 204.42,97.16 204.42,96.46 204.22,96.26 204.22,96.15 204.22,96.1 204.22,96.05 204.22,95.91 204.37,95.76 204.37,95.71 204.29,95.64 204.23,95.61 204.16,95.63 204.06,95.7 203.96,95.73 203.94,95.73 203.85,95.82 203.85,99.2 203.92,99.27 203.94,99.27 204.05,99.3 204.16,99.37
+NVVDD2 on BOTTOM (solid shape): 198.63,99.39 198.7,99.36 198.75,99.31 198.75,99.19 198.62,99.06 198.62,98.95 198.62,98.9 198.62,98.85 198.62,98.74 198.77,98.59 198.77,97.84 198.65,97.71 198.65,97.65 198.64,97.64 198.62,97.5 198.64,97.36 198.65,97.34 198.73,97.23 198.82,97.16 198.82,96.46 198.62,96.26 198.62,96.15 198.62,96.1 198.62,96.05 198.62,95.91 198.77,95.76 198.77,95.71 198.7,95.64 198.63,95.61 198.56,95.63 198.47,95.69 198.37,95.73 198.35,95.73 198.25,95.83 198.25,99.23 198.29,99.27 198.31,99.27 198.44,99.29 198.56,99.37
