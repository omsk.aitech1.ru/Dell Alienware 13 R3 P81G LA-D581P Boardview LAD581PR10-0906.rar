# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS4: length 68.4
  IN1 w0.089: 132.06,75.35 132.05,75.35 132.05,75.43 132.05,75.43 132.05,79.52 129.07,82.5 129.07,89.04 129.01,89.1 129.01,90.2 128.91,90.3 128.91,90.77 129.04,90.9 129.25,90.9 129.37,90.78 v2(129.37,90.62)
  IN1 w0.097: 132.06,75.35 132.06,63.25 128.43,59.62 128.43,49.23 129.62,48.04 129.62,43.5 129.72,43.4 129.93,43.4 130.18,43.15 130.18,42.74 129.95,42.51 129.72,42.51 129.62,42.41 129.62,41.55 129.17,41.1 129.17,39.71 127.77,38.31 127.77,38.06 127.85,37.98 127.93,37.98 128.17,37.74 128.17,37.33 127.95,37.11 127.87,37.11 127.77,37.01 127.77,36.68 127.85,36.6 127.97,36.6 128.17,36.4 128.17,36.01 127.93,35.77 127.85,35.77 127.76,35.69 127.76,33.93 127.89,33.8 127.97,33.8 v2(128.17,34)
  BOTTOM w0.076: v2(129.37,90.62) CPU1.AA9
  BOTTOM w0.114: v2(128.17,34) 128.02,33.86 127.83,33.86 127.7,33.98 127.7,34.94 128.41,35.65 128.41,36.16 128.53,36.27 JDIMM2.179
DDR_B_DQS5: length 67.7
  IN1 w0.089: 135.65,75.35 135.65,75.37 135.66,75.38 135.66,79.7 131.65,83.7 131.65,88.92 131.58,88.99 131.58,89.94 131.42,90.1 131.3,90.1 v2(131.19,89.99)
  IN1 w0.097: 135.65,75.35 135.65,61.69 133.25,59.29 133.25,50.65 134.28,49.62 134.28,44.2 133.81,43.73 133.81,41.75 133.81,41.75 133.81,39.86 133.74,39.79 133.74,38 133.66,37.92 133.66,34.09 133.54,33.97 133.27,33.97 133.01,33.71 133.01,32.94 133.34,32.62 133.46,32.62 133.84,32.24 v2(133.84,32.17)
  BOTTOM w0.076: v2(131.19,89.99) 131.24,89.94 131.64,89.94 131.71,90.01 131.71,90.24 CPU1.V9
  BOTTOM w0.114: JDIMM2.200 133.78,29.71 133.68,29.81 133.68,30.43 133.24,30.87 133.24,32.26 133.36,32.38 133.63,32.38 v2(133.84,32.17)
DDR_B_DQS6: length 67.5
  IN1 w0.089: 139.57,77.69 139.55,77.71 139.55,79.56 134.5,84.61 134.5,90.18 134.41,90.27 134.41,90.78 134.51,90.88 134.7,90.88 134.86,90.71 v2(134.86,90.62)
  IN1 w0.097: 139.57,77.69 139.57,60.01 138.81,59.25 138.81,50.87 139.95,49.73 139.95,44.14 139.35,43.54 139.35,36.28 139.48,36.15 140.02,36.15 140.25,35.92 140.25,35.46 140.02,35.22 138.94,35.22 138.83,35.12 138.83,34 138.96,33.87 139.25,33.87 139.35,33.98 v2(139.35,34.08)
  BOTTOM w0.076: v2(134.86,90.62) CPU1.P9
  BOTTOM w0.114: JDIMM2.221 139.03,36.1 138.88,35.96 138.88,34.09 139.05,33.92 139.19,33.92 v2(139.35,34.08)
DDR_B_DQS7: length 68.4
  IN1 w0.089: 142.63,80.76 142.63,80.76 142.45,80.76 138.15,85.06 138.15,88.07 137.66,88.56 137.56,88.56 137.01,89.12 137.01,89.84 136.88,89.97 136.7,89.97 v2(136.64,89.91)
  IN1 w0.097: v2(145.07,32.11) 145.07,32.17 144.7,32.55 144.59,32.55 144.44,32.71 144.44,33.82 144.68,34.07 145.04,34.07 145.16,34.18 145.16,37.44 144.63,37.96 144.63,42.97 145.54,43.88 145.54,49.2 143.97,50.77 143.97,52.36 143.5,52.84 143.5,73.15 143.25,73.39 143.25,80.14 142.64,80.76 142.63,80.76
  BOTTOM w0.076: v2(136.64,89.91) 137.02,89.91 137.15,90.04 CPU1.L9
  BOTTOM w0.114: v2(145.07,32.11) 145.07,32.22 144.93,32.35 144.65,32.35 144.35,32.06 144.35,30.44 144.17,30.26 144.17,29.8 144.28,29.69 JDIMM2.242
DDR_B_DQS#0: length 74.3
  IN1 w0.089: 100.3,89.25 101.39,90.34 101.39,90.79 101.61,91.02 102.76,91.02 103.27,90.51 104.01,90.51 104.2,90.7 104.2,91 104.34,91.14 v2(104.46,91.14)
  IN1 w0.097: v2(84.34,33.95) 84.13,33.74 84.02,33.74 83.89,33.86 83.89,34.83 84.63,35.57 84.63,38.8 84.59,38.84 84.59,41.48 84.84,41.74 84.84,42.27 84.58,42.53 84.58,42.76 84.71,42.89 84.77,42.89 84.98,43.09 84.98,43.53 84.6,43.91 84.6,44.09 85.25,44.74 85.25,52.4 92.8,59.95 92.8,69.81 92.81,69.81 92.81,69.83 99.3,76.32 99.3,87.37 99.97,88.04 99.97,88.31 100.28,88.62 100.28,89.23
  IN1 w0.099: 100.3,89.25 100.28,89.23
  BOTTOM w0.076: CPU1.BP9 104.14,90.54 104.23,90.45 104.37,90.45 104.46,90.54 v2(104.46,91.14)
  BOTTOM w0.114: v2(84.34,33.95) 84.49,33.81 84.7,33.81 84.85,33.96 84.85,35.14 84.66,35.33 84.66,36.09 84.53,36.23 JDIMM2.11
DDR_B_DQS#1: length 72.3
  IN1 w0.089: 104.17,77.62 104.17,77.64 104.2,77.67 104.2,82.18 105.95,83.93 105.95,86.02 105.03,86.94 105.03,87.6 106.17,88.73 106.17,90.9 v2(106.54,91.27)
  IN1 w0.097: 102.63,76.01 102.63,73.47 96.39,67.23 96.39,58.53 90.83,52.97 90.83,48.5 90.33,47.99 90.33,43.57 90.43,43.46 90.43,36.76 89.22,35.55 89.22,34 88.6,33.38 88.6,32.49 88.83,32.26 89.16,32.26 v2(89.37,32.05)
  IN1 w0.099: 102.63,76.01 104.17,77.55 104.17,77.62
  BOTTOM w0.076: v2(106.54,91.27) CPU1.BL9
  BOTTOM w0.114: JDIMM2.32 89.78,29.78 89.84,29.84 89.84,31.95 89.74,32.05 v2(89.37,32.05)
DDR_B_DQS#2: length 70.1
  IN1 w0.089: v2(109.26,90.62) 109.26,90.72 109.38,90.84 109.56,90.84 109.69,90.72 109.69,90.54 109.63,90.47 109.63,88.02 110.14,87.51 110.14,83.34 109.71,82.91 109.71,79.45 107.09,76.83
  IN1 w0.097: 106.53,75.7 106.51,75.69 106.51,75.68 106.47,75.65 106.48,75.65 106.48,72.92 106.47,72.92 106.47,72.03 100.11,65.67 100.11,56.55 95.93,52.37 95.93,47.77 96.24,47.45 96.24,33.71 95.97,33.44 95.45,33.44 94.96,33.93 v2(94.96,33.95)
  IN1 w0.099: 107.09,76.83 107.09,76.26 106.53,75.7
  BOTTOM w0.076: v2(109.26,90.62) CPU1.BG9
  BOTTOM w0.114: v2(94.96,33.95) 95.17,33.74 95.32,33.74 95.45,33.87 95.45,34.95 95.14,35.27 95.14,36.16 95.03,36.27 JDIMM2.53
DDR_B_DQS#3: length 69.1
  IN1 w0.089: v2(112,90.62) 112.24,90.62 112.37,90.5 112.37,89.1 113.19,88.27 113.19,80.99 112.89,80.69 112.89,78.5 110.52,76.13 110.52,75.38 110.51,75.38 110.51,75.35
  IN1 w0.097: v2(101.13,32.68) 101.32,32.49 101.48,32.49 101.61,32.62 101.61,34.43 101.36,34.68 101.36,35.14 101.6,35.38 101.6,52.77 103.83,55.01 103.83,57.67 104.35,58.18 104.35,64.63 110.51,70.79 110.51,75.35
  BOTTOM w0.076: v2(112,90.62) CPU1.BC9
  BOTTOM w0.114: v2(101.13,32.68) 100.94,32.5 100.68,32.5 100.41,32.23 100.41,29.81 100.28,29.67 JDIMM2.74
DDR_B_DQS#4: length 68.4
  IN1 w0.089: v2(128.46,90.62) 128.73,90.35 128.73,90.23 128.83,90.12 128.83,89.02 128.89,88.97 128.89,82.43 131.88,79.45 131.88,75.37 131.87,75.37 131.87,75.35
  IN1 w0.097: v2(128.17,33.36) 127.91,33.62 127.81,33.62 127.58,33.85 127.58,35.77 127.77,35.96 127.86,35.96 127.98,36.09 127.98,36.32 127.89,36.41 127.77,36.41 127.59,36.6 127.59,37.09 127.79,37.29 127.87,37.29 127.98,37.41 127.98,37.67 127.86,37.79 127.78,37.79 127.59,37.98 127.59,38.39 128.98,39.79 128.98,41.18 129.43,41.63 129.43,42.49 129.64,42.7 129.87,42.7 130,42.82 130,43.07 129.86,43.21 129.64,43.21 129.43,43.42 129.43,47.96 128.24,49.15 128.24,59.69 131.87,63.33 131.87,75.35
  BOTTOM w0.076: v2(128.46,90.62) CPU1.AC9
  BOTTOM w0.114: JDIMM2.177 128.03,36.29 128.16,36.15 128.16,35.74 127.45,35.04 127.45,33.88 127.73,33.61 127.92,33.61 v2(128.17,33.36)
DDR_B_DQS#5: length 67.8
  IN1 w0.089: 135.84,75.35 135.84,75.37 135.83,75.38 135.83,79.77 131.83,83.77 131.83,88.99 131.75,89.07 131.75,90.22 131.5,90.48 131.34,90.48 v2(131.19,90.63)
  IN1 w0.097: 135.84,75.35 135.83,75.34 135.83,61.62 133.43,59.21 133.43,50.73 134.46,49.7 134.46,44.13 133.99,43.65 133.99,39.78 133.93,39.71 133.93,37.92 133.85,37.85 133.85,34.01 133.62,33.78 133.35,33.78 133.2,33.63 133.2,33.02 133.41,32.81 v2(133.84,32.81)
  BOTTOM w0.076: v2(131.19,90.63) 130.86,90.3 CPU1.W9
  BOTTOM w0.114: v2(133.84,32.81) 133.66,32.63 133.26,32.63 132.99,32.36 132.99,30.77 133.41,30.35 133.41,29.85 133.28,29.72 JDIMM2.198
DDR_B_DQS#6: length 67.5
  IN1 w0.089: v2(133.95,90.62) 134.24,90.33 134.24,90.2 134.32,90.11 134.32,84.54 139.38,79.49 139.38,77.65 139.38,77.64 139.38,77.64 ; 139.38,77.63 139.38,77.62
  IN1 w0.097: 139.38,77.62 139.38,60.09 138.62,59.33 138.62,50.8 139.76,49.66 139.76,44.21 139.16,43.61 139.16,36.2 139.4,35.97 139.94,35.97 140.07,35.84 140.07,35.53 139.94,35.41 138.86,35.41 138.64,35.19 138.64,33.92 138.88,33.68 139.12,33.68 v2(139.35,33.44) ; 139.38,77.64 139.38,77.63
  BOTTOM w0.076: v2(133.95,90.62) CPU1.R9
  BOTTOM w0.114: v2(139.35,33.44) 139.35,33.45 139.16,33.65 138.94,33.65 138.63,33.96 138.63,35.99 138.53,36.1 JDIMM2.219
DDR_B_DQS#7: length 68.5
  IN1 w0.089: 142.76,80.89 142.75,80.91 142.74,80.91 142.71,80.94 142.52,80.94 138.33,85.13 138.33,88.14 137.74,88.74 137.64,88.74 137.18,89.19 137.18,90.08 v2(136.68,90.59)
  IN1 w0.097: v2(145.07,32.74) 144.86,32.74 144.84,32.73 144.67,32.73 144.62,32.78 144.62,33.74 144.76,33.88 145.12,33.88 145.34,34.1 145.34,37.52 144.82,38.04 144.82,42.89 145.72,43.8 145.72,49.28 144.15,50.85 144.15,52.44 143.68,52.91 143.68,73.23 143.44,73.47 143.44,80.22 142.76,80.89
  BOTTOM w0.076: CPU1.M9 136.39,90.3 v2(136.68,90.59)
  BOTTOM w0.114: v2(145.07,32.74) 144.92,32.6 144.54,32.6 144.1,32.16 144.1,30.54 143.92,30.36 143.92,29.82 143.78,29.68 JDIMM2.240
DDR_B_MA0: length 69.5
  IN1 w0.089: 123.74,75.35 123.74,76.73 123.67,76.8 123.67,85.08 123.43,85.32 123.43,88.08 122.5,89.01 122.5,91.1 122.63,91.22 122.85,91.22 122.97,91.1 v2(122.97,90.62)
  IN1 w0.145: 123.74,75.35 123.74,66.86 117.78,60.9 117.78,52.93 117.78,51.26 117.64,51.12 117.64,49.74 117.07,49.18 117.07,41.33 117.46,40.95 117.46,36.14 117.52,36.08 117.52,35.48 117.26,35.22 117.26,34.88 117.52,34.62 117.52,34.28 117.26,34.02 117.26,33.68 117.52,33.42 117.52,32.75 117.97,32.3 118.56,32.3 v2(118.81,32.55)
  BOTTOM w0.076: CPU1.AJ9 122.65,90.3 v2(122.97,90.62)
  BOTTOM w0.178: JDIMM2.144 117.78,31.52 v2(118.81,32.55)
DDR_B_MA1: length 67.8
  IN1 w0.089: 120.86,75.35 120.86,86.59 121.93,87.66 121.93,87.87 121.77,88.03 v2(121.51,88.03)
  IN1 w0.145: v2(114.31,34.97) 114.35,35.01 114.35,40.45 113.96,40.84 113.96,41.02 114.12,41.18 114.2,41.18 114.35,41.33 114.35,41.63 114.2,41.78 114.09,41.78 113.94,41.93 113.94,42.21 114.09,42.36 114.2,42.36 114.35,42.51 114.35,42.81 114.2,42.96 114.09,42.96 113.94,43.11 113.94,47.95 114.35,48.35 114.35,49.85 115.24,50.74 115.24,51.48 114.87,51.86 114.87,52.9 115.02,53.05 115.16,53.05 115.31,53.2 115.31,53.5 115.16,53.65 115.02,53.65 114.87,53.8 114.87,54.1 115.02,54.25 115.16,54.25 115.31,54.4 115.31,54.7 115.16,54.85 115.02,54.85 114.87,55 114.87,55.3 115.02,55.45 115.16,55.45 115.31,55.6 115.31,55.9 115.16,56.05 115.02,56.05 114.87,56.2 114.87,56.5 115.02,56.65 115.16,56.65 115.31,56.79 115.31,57.09 115.16,57.24 115.02,57.24 114.87,57.39 114.87,57.67 115.02,57.82 115.22,57.82 115.37,57.97 115.37,58.27 115.22,58.42 115.02,58.42 114.87,58.57 114.87,58.87 115.02,59.02 115.22,59.02 115.37,59.17 115.37,59.47 115.22,59.62 115.02,59.62 114.87,59.77 114.87,60.07 115.02,60.22 115.22,60.22 115.37,60.37 115.37,60.67 115.22,60.82 115.02,60.82 114.87,60.97 114.87,61.38 120.86,67.37 120.86,67.65 120.71,67.8 120.41,67.8 120.26,67.95 120.26,68.25 120.41,68.4 120.71,68.4 120.86,68.55 120.86,68.85 120.71,69 120.41,69 120.26,69.15 120.26,69.45 120.41,69.6 120.71,69.6 120.86,69.75 120.86,70.05 120.71,70.2 120.41,70.2 120.26,70.35 120.26,70.64 120.41,70.79 120.71,70.79 120.86,70.94 120.86,75.35
  BOTTOM w0.076: CPU1.AK6 121.64,88.03 v2(121.51,88.03)
  BOTTOM w0.178: v2(114.31,34.97) 114.31,35.18 115.03,35.9 JDIMM2.133
DDR_B_MA2: length 68
  IN1 w0.089: 121.73,75.35 121.73,76.87 121.23,77.37 121.23,81.8 121.07,81.96 121.07,86.56 121.99,87.47 122.17,87.47 v2(122.28,87.35)
  IN1 w0.145: v2(115.95,32.43) 115.64,32.43 115.52,32.3 115.52,31.29 115.39,31.16 114.94,31.16 114.82,31.29 114.82,32.77 115.18,33.14 115.18,33.54 114.81,33.92 114.81,49.66 115.7,50.55 115.7,51.67 115.34,52.03 115.34,52.28 115.82,52.77 115.82,61.69 121.72,67.59 121.72,70.98 121.57,71.13 121.46,71.13 121.31,71.28 121.31,71.58 121.46,71.73 121.57,71.73 121.73,71.89 121.73,75.35
  BOTTOM w0.076: CPU1.AK5 122.23,87.35 v2(122.28,87.35)
  BOTTOM w0.178: v2(115.95,32.43) 115.94,32.43 114.96,31.45 114.96,30.03 114.78,29.85 JDIMM2.132
DDR_B_MA3: length 68.3
  IN1 w0.089: 120.4,75.35 120.4,76.81 120.64,77.04 120.64,87.28 v2(120.72,87.36)
  IN1 w0.145: 120.4,75.35 120.4,71.43 119.8,70.83 119.8,66.96 114.38,61.54 114.38,56.93 114.23,56.78 113.52,56.78 113.37,56.63 113.37,56.33 113.52,56.18 114.23,56.18 114.38,56.03 114.38,55.73 114.23,55.58 113.52,55.58 113.37,55.43 113.37,55.13 113.52,54.98 114.23,54.98 114.38,54.83 114.38,54.53 114.23,54.38 113.75,54.38 113.6,54.23 113.6,53.93 113.75,53.78 114.23,53.78 114.38,53.63 114.38,50.63 113.4,49.65 113.4,49.37 113.55,49.22 113.75,49.22 113.9,49.07 113.9,48.78 113.75,48.63 113.55,48.63 113.4,48.48 113.4,40.18 113.9,39.69 113.9,35.74 113.85,35.69 113.85,33.73 113.99,33.58 114.2,33.58 v2(114.31,33.7)
  BOTTOM w0.076: v2(120.72,87.36) 120.72,87.51 120.94,87.73 121.12,87.73 CPU1.AL5
  BOTTOM w0.178: v2(114.31,33.7) 114.12,33.51 113.55,33.51 113.36,33.7 113.36,34.37 113.75,34.76 113.75,35.35 114.53,36.12 JDIMM2.131
DDR_B_MA4: length 66.7
  IN1 w0.089: v2(120.72,88.01) 120.35,88.38 119.72,88.38 119.47,88.13 119.47,76.43 118.89,75.85 118.89,75.35
  IN1 w0.145: 118.89,75.35 118.89,67.63 113.47,62.21 113.47,59.64 112.46,58.62 112.46,53.79 113.47,52.78 113.47,51.01 112.5,50.03 112.5,40.98 112.08,40.57 112.08,40.22 112.98,39.32 112.98,36.12 112.93,36.08 112.93,31.91 113.63,31.2 v2(114.31,31.2)
  BOTTOM w0.076: v2(120.72,88.01) 121.05,88.34 CPU1.AL6
  BOTTOM w0.178: v2(114.31,31.2) 114.31,30.92 113.78,30.38 JDIMM2.128
DDR_B_MA5: length 67.1
  IN1 w0.089: v2(119.88,88.01) 120.36,87.53 120.36,86.58 120,86.22 120,85.55 119.86,85.4 119.86,76.37 119.35,75.86 119.35,75.35
  IN1 w0.145: 119.35,75.35 119.35,67.44 113.93,62.02 113.93,58.73 113.78,58.58 113.06,58.58 112.91,58.43 112.91,58.14 113.06,57.99 113.78,57.99 113.93,57.84 113.93,57.54 113.78,57.39 113.06,57.39 112.91,57.24 112.91,53.98 113.93,52.97 113.93,50.82 112.95,49.84 112.95,39.99 113.44,39.51 113.44,35.93 113.39,35.89 113.39,33.29 114.25,32.43 v2(114.31,32.43)
  BOTTOM w0.076: v2(119.88,88.01) 120.21,88.34 CPU1.AM6
  BOTTOM w0.178: v2(114.31,32.43) 113.94,32.43 113.28,31.76 JDIMM2.126
DDR_B_MA6: length 67.5
  IN1 w0.089: 118.44,75.35 118.44,75.83 119.25,76.64 119.25,88.33 119.74,88.82 v2(120.23,88.82)
  IN1 w0.145: v2(111.92,33.62) 112.12,33.62 112.47,33.96 112.47,37.76 111.59,38.64 111.59,38.98 111.84,39.22 111.84,39.58 111.59,39.82 111.59,41.37 111.74,41.52 111.89,41.52 112.04,41.67 112.04,41.97 111.89,42.12 111.74,42.12 111.59,42.27 111.59,42.57 111.74,42.72 111.89,42.72 112.04,42.87 112.04,43.16 111.89,43.31 111.74,43.31 111.59,43.46 111.59,48.54 111.72,48.67 111.89,48.67 112.04,48.82 112.04,49.12 111.89,49.27 111.67,49.27 111.52,49.42 111.52,49.69 112.9,51.08 112.9,52.71 112.01,53.6 112.01,58.81 113.02,59.82 113.02,62.4 118.44,67.82 118.44,75.35
  BOTTOM w0.076: v2(120.23,88.82) 120.03,88.62 119.85,88.62 119.77,88.7 CPU1.AN7
  BOTTOM w0.178: JDIMM2.127 113.53,35.97 113.27,35.72 113.27,34.96 v2(111.92,33.62)
DDR_B_MA7: length 70.2
  IN1 w0.089: v2(120.23,91.27) 120.16,91.34 119.99,91.34 119.86,91.21 119.86,89.84 119.48,89.45 119.48,89.07 118.86,88.46 118.86,76.91 117.53,75.58 117.53,75.35
  IN1 w0.145: 117.53,75.35 117.53,68.2 111.1,61.77 111.1,50.87 110.61,50.38 110.61,43.39 110.1,42.88 110.1,38 111.08,37.02 111.08,36.39 111.46,36.01 111.46,32.23 111.59,32.1 111.8,32.1 111.92,32.23 v2(111.92,32.29)
  BOTTOM w0.076: v2(120.23,91.27) 120.19,91.02 120.03,90.9 CPU1.AN10
  BOTTOM w0.178: v2(111.92,32.29) 112.26,32.62 112.67,32.62 112.79,32.49 112.79,30.45 112.28,29.93 JDIMM2.122
DDR_B_MA8: length 68.4
  IN1 w0.089: 117.98,75.35 117.98,75.63 119.04,76.69 119.04,88.38 119.69,89.03 119.69,89.41 119.93,89.65 120.07,89.65 120.21,89.52 v2(120.21,89.39)
  IN1 w0.145: v2(111.94,34.98) 112.01,35.06 112.01,36.36 111.93,36.44 111.68,36.44 111.54,36.58 111.54,36.95 111.67,37.08 111.89,37.08 112.01,37.21 112.01,37.57 111.89,37.7 111.67,37.7 111.08,38.29 111.08,40.4 111.06,40.42 111.06,40.72 110.91,40.87 110.71,40.87 110.56,41.02 110.56,41.32 110.71,41.47 110.91,41.47 111.06,41.62 111.06,41.92 110.91,42.07 110.71,42.07 110.56,42.22 110.56,42.52 110.71,42.67 110.91,42.67 111.06,42.82 111.06,50.2 111.55,50.68 111.55,50.91 111.7,51.06 111.89,51.06 112.04,51.21 112.04,51.51 111.89,51.66 111.7,51.66 111.55,51.81 111.55,52.11 111.7,52.26 111.89,52.26 112.04,52.41 112.04,52.7 111.89,52.85 111.7,52.85 111.55,53 111.55,60.4 111.7,60.55 112.41,60.55 112.56,60.7 112.56,61 112.41,61.15 111.7,61.15 111.55,61.3 111.55,61.57 117.98,68.01 117.98,75.35
  BOTTOM w0.076: v2(120.21,89.39) 120.08,89.27 119.84,89.27 119.71,89.4 119.71,89.59 CPU1.AN8
  BOTTOM w0.178: v2(111.94,34.98) 112.13,34.79 112.41,34.79 112.79,35.16 112.79,35.36 112.58,35.57 112.58,35.82 113.03,36.27 JDIMM2.125
DDR_B_MA9: length 68.3
  IN1 w0.089: v2(118.39,91.22) 118.95,90.66 118.95,89.05 118.41,88.51 118.41,77.2 116.62,75.42 116.62,75.35
  IN1 w0.145: v2(110.05,33.49) 110.26,33.28 110.42,33.28 110.54,33.41 110.54,35.63 110.17,36.01 110.17,36.65 109.19,37.63 109.19,47.91 109.7,48.41 109.7,52.61 110.19,53.09 110.19,62.16 116.62,68.59 116.62,75.35
  BOTTOM w0.076: v2(118.39,91.22) 118.01,91.6 CPU1.AR11
  BOTTOM w0.178: JDIMM2.121 112.03,36.03 110.69,34.69 110.69,34.13 v2(110.05,33.49)
DDR_B_MA10: length 68.6
  IN1 w0.089: v2(123.89,89.32) 123.96,89.24 123.96,85.56 124.36,85.16 124.36,78.01 125.31,77.07 125.31,75.35
  IN1 w0.145: v2(118.81,31.03) 118.81,29.92 118.93,29.79 119.43,29.79 119.56,29.92 119.56,31.19 119.36,31.39 119.36,37.38 119.09,37.65 119.09,41.53 118.64,41.98 118.64,48.53 119.21,49.09 119.21,50.47 119.35,50.61 119.35,54.44 119.35,60.14 125.31,66.1 125.31,75.35
  BOTTOM w0.076: v2(123.89,89.32) CPU1.AH7
  BOTTOM w0.178: JDIMM2.146 120.28,29.94 119.19,31.03 v2(118.81,31.03)
DDR_B_MA11: length 72.2
  IN1 w0.089: 117.07,75.35 117.07,75.62 118.59,77.13 118.59,88.43 119.3,89.15 119.3,89.53 119.68,89.91 119.68,91.38 v2(120.23,91.92)
  IN1 w0.145: 117.07,75.35 117.07,68.4 110.64,61.96 110.64,51.06 110.15,50.57 110.15,48.23 109.65,47.72 109.65,37.81 110.63,36.84 110.63,36.2 111,35.82 111,32.03 111.24,31.79 111.24,31.48 110.76,30.99 110.76,30.65 111.05,30.36 112.36,30.36 112.48,30.49 112.48,30.89 112.36,31.01 v2(111.94,31.01)
  BOTTOM w0.076: v2(120.23,91.92) CPU1.AN11
  BOTTOM w0.178: JDIMM2.120 111.78,30.85 v2(111.94,31.01)
DDR_B_MA12: length 66.7
  IN1 w0.089: 116.17,75.35 116.17,75.73 116.3,75.86 116.82,75.86 118.18,77.23 118.18,88.53 118.39,88.74 118.39,88.83 118.48,88.91 118.53,88.91 118.62,89 118.62,89.18 118.53,89.27 118.48,89.27 118.39,89.36 118.39,89.49 118.47,89.57 118.68,89.57 118.77,89.66 118.77,90.49 118.66,90.61 v2(118.4,90.61)
  IN1 w0.145: v2(110.05,34.84) 110.05,35.47 109.71,35.82 109.71,36.47 109.49,36.69 109,36.69 108.74,36.96 108.74,43.6 108.59,43.75 108.53,43.75 108.38,43.9 108.38,44.2 108.53,44.35 108.59,44.35 108.74,44.5 108.74,44.8 108.59,44.95 108.53,44.95 108.38,45.1 108.38,45.4 108.53,45.55 108.59,45.55 108.74,45.7 108.74,46 108.59,46.15 108.53,46.15 108.38,46.3 108.38,46.6 108.53,46.75 108.59,46.75 108.74,46.9 108.74,47.2 108.59,47.35 108.53,47.35 108.38,47.5 108.38,47.79 108.53,47.94 108.59,47.94 109.24,48.6 109.24,52.79 109.73,53.28 109.73,62.35 116.17,68.79 116.17,75.35
  BOTTOM w0.076: CPU1.AR10 118.07,90.95 v2(118.4,90.61)
  BOTTOM w0.178: JDIMM2.119 111.53,36.21 110.15,34.84 v2(110.05,34.84)
DDR_B_MA13: length 70
  IN1 w0.089: v2(125.72,90.62) 125.13,90.04 125.13,89.13 125.46,88.8 125.46,85.5 126.25,84.71 126.25,80.24 127.78,78.7 127.78,75.35
  IN1 w0.145: 127.78,75.35 127.78,65.07 122.23,59.52 122.23,43.16 122.08,43.02 122.08,37.86 121.88,37.66 121.88,29.92 122.01,29.79 123.82,29.79 123.94,29.92 v2(123.94,30.57)
  BOTTOM w0.076: v2(125.72,90.62) CPU1.AF9
  BOTTOM w0.178: JDIMM2.158 123.28,30.14 123.71,30.57 v2(123.94,30.57)
DDR_B_PAR: length 71.1
  IN1 w0.089: 124.29,75.35 124.29,76.81 123.96,77.14 123.96,85.06 123.61,85.41 123.61,88.16 122.77,88.99 122.77,89.17 122.93,89.32 v2(122.97,89.32)
  IN1 w0.145: v2(118.81,34.07) 118.81,33.88 118.63,33.7 118.25,33.7 118.07,33.88 118.07,34.61 118.24,34.78 118.24,35.21 118.07,35.38 118.07,36.28 118.01,36.34 118.01,41.18 117.63,41.56 117.63,48.95 118.2,49.51 118.2,50.89 118.34,51.03 118.34,53.16 118.34,60.67 124.29,66.63 124.29,75.35
  BOTTOM w0.076: CPU1.AJ7 122.78,88.95 122.93,89.06 v2(122.97,89.32)
  BOTTOM w0.178: v2(118.81,34.07) 118.49,34.07 118.36,33.95 118.36,32.93 117.99,32.56 116.63,32.56 116.39,32.79 116.39,33.64 116.58,33.83 117.04,33.83 117.23,34.02 117.23,34.4 117.11,34.52 116.6,34.52 116.39,34.73 116.39,35.01 116.74,35.35 117.19,35.35 117.53,35.69 117.53,36.16 117.53,36.17 JDIMM2.143
DDR_B_RAS#: length 69.6
  IN1 w0.089: 126.21,75.35 126.21,77.1 124.82,78.5 124.82,85.21 124.32,85.7 124.32,88.89 124.49,89.05 124.49,90.12 124.26,90.35 124.26,90.9 v2(123.89,91.27)
  IN1 w0.145: v2(121.32,32.55) 121.02,32.55 120.89,32.42 120.89,31.88 120.77,31.75 120.42,31.75 120.29,31.89 120.29,38.08 120.06,38.3 120.06,40.65 120.26,40.85 120.26,44.62 120.07,44.81 120.07,48.71 120.26,48.89 120.26,59.76 126.21,65.72 126.21,75.35
  BOTTOM w0.076: v2(123.89,91.27) CPU1.AH10
  BOTTOM w0.178: JDIMM2.152 121.78,29.73 121.97,29.93 121.97,31.89 v2(121.32,32.55)
DDR_B_WE#: length 66.4
  IN1 w0.089: 126.67,75.35 126.67,79.26 125.74,80.19 125.74,84.72 125.13,85.33 124.95,85.33 124.5,85.78 124.5,88.81 124.69,89 124.69,90.32 124.43,90.58 124.43,91.38 v2(123.89,91.92)
  IN1 w0.145: v2(121.32,34.07) 120.88,34.07 120.75,34.21 120.75,38.11 120.96,38.33 120.96,40.68 120.71,40.93 120.71,59.58 126.67,65.53 126.67,75.35
  BOTTOM w0.076: v2(123.89,91.92) CPU1.AH11
  BOTTOM w0.178: v2(121.32,34.07) 121.91,34.67 121.91,35.77 121.53,36.16 JDIMM2.151
DDR_CKE0_DIMMA: length 49.1
  IN5 w0.145: 114.31,80.56 114.18,80.43 114.18,75.37 114.15,75.35 114.15,71.41 114,71.26 113.58,71.26 113.43,71.11 113.43,70.81 113.58,70.66 114,70.66 114.15,70.51 114.15,70.21 114,70.06 113.58,70.06 113.43,69.91 113.43,69.61 113.58,69.46 114,69.46 114.15,69.31 114.15,69.03 107.21,62.09 107.21,52.52 107.2,52.51 107.2,50.49 107.35,50.34 107.69,50.34 107.84,50.18 107.84,49.9 107.69,49.74 107.35,49.74 107.2,49.59 107.2,49.28 107.35,49.13 107.36,49.13 107.53,48.97 107.53,48.71 107.38,48.56 107.37,48.56 107.2,48.39 107.2,47.73 107.33,47.61 107.57,47.61 v2(107.94,47.97) ; 114.59,80.56 v2(114.92,80.24)
  IN5 w0.15: 114.31,80.56 114.59,80.56
  BOTTOM w0.076: v2(114.92,80.24) 116.87,82.19 CPU1.AT1
  BOTTOM w0.178: v2(107.94,47.97) 108.32,47.97 109.02,48.68 JDIMM1.109
DDR_CKE1_DIMMA: length 49.4
  IN5 w0.145: v2(107.95,43.89) 108.38,44.32 108.38,48.81 108.3,48.89 108.3,50.67 107.66,51.3 107.66,61.9 114.61,68.84 114.61,75.35 115.3,76.04 115.3,79.24 115.31,79.26 115.31,81.05 v2(114.89,81.48)
  BOTTOM w0.076: v2(114.89,81.48) 114.89,81.48 116.58,83.16 116.58,85.44 CPU1.AT2
  BOTTOM w0.178: JDIMM1.110 109.27,42.78 108.17,43.89 v2(107.95,43.89)
DDR_CKE2_DIMMB: length 69.6
  IN1 w0.089: 114.03,75.35 114.03,75.67 115.47,77.11 115.47,79.73 116.48,80.75 116.48,88.62 117.22,89.36 v2(117.49,89.36)
  IN1 w0.145: v2(106.99,33.57) 106.61,33.19 106.13,33.19 105.86,33.47 105.86,33.88 106.01,34.04 106.3,34.04 106.43,34.16 106.43,34.53 106.3,34.66 106.01,34.66 105.81,34.85 105.81,52.37 107.61,54.17 107.61,63.25 114.03,69.67 114.03,75.35
  BOTTOM w0.076: v2(117.49,89.36) 117.2,89.65 CPU1.AT8
  BOTTOM w0.178: JDIMM2.109 109.03,36.21 108.81,35.99 106.83,35.99 106.53,35.69 106.53,34.03 v2(106.99,33.57)
DDR_CKE3_DIMMB: length 70
  IN1 w0.089: 113.11,75.35 113.11,75.89 114.96,77.74 114.96,79.76 116.02,80.82 116.02,90.13 v2(116.55,90.65)
  IN1 w0.145: 113.11,75.35 113.11,70.05 106.7,63.64 106.7,54.54 104.9,52.75 104.9,33.12 v2(106.99,31.03)
  BOTTOM w0.076: CPU1.AT10 116.84,90.95 v2(116.55,90.65)
  BOTTOM w0.178: v2(106.99,31.03) 108.77,31.03 109.28,30.53 JDIMM2.110
DDR_CS0_DIMMA#: length 52.2
  IN5 w0.089: v2(126.57,87.36) 126.57,86.7 124.33,84.46 124.33,78.17 127.15,75.35
  IN5 w0.145: v2(121.24,46.62) 121.24,46.52 121.65,46.11 122.16,46.11 122.28,46.24 122.28,56.4 125.9,60.02 125.9,60.98 125.75,61.13 125.66,61.13 125.54,61.25 125.54,61.53 125.69,61.68 125.7,61.68 125.9,61.88 125.9,62.17 125.75,62.32 125.6,62.47 125.6,62.77 125.75,62.92 125.9,63.07 125.9,63.37 125.75,63.52 125.47,63.52 125.32,63.67 125.32,63.97 125.47,64.12 125.75,64.12 125.9,64.27 125.9,68.49 127.15,69.74 127.15,75.35
  BOTTOM w0.076: CPU1.AD5 126.89,87.69 v2(126.57,87.36)
  BOTTOM w0.178: v2(121.24,46.62) 120.72,47.14 120.72,48.5 121.02,48.8 JDIMM1.149
DDR_CS1_DIMMA#: length 56
  IN5 w0.089: 128.06,75.35 128.06,75.78 125.76,78.08 125.14,78.08 124.68,78.54 124.68,82.59 124.87,82.78 125.15,82.78 v2(125.3,82.63)
  IN5 w0.145: v2(123.22,48.4) 123.19,48.42 123.19,49.92 123.34,50.07 123.89,50.07 124.04,50.22 124.04,50.52 123.89,50.67 123.34,50.67 123.19,50.82 123.19,56.03 128.06,60.9 128.06,62.74 127.91,62.89 126.96,62.89 126.81,63.04 126.81,63.34 126.96,63.49 127.91,63.49 128.06,63.64 128.06,63.94 127.91,64.09 126.96,64.09 126.81,64.24 126.81,64.54 126.96,64.69 127.91,64.69 128.06,64.84 128.06,65.14 127.91,65.29 126.96,65.29 126.81,65.44 126.81,65.74 126.96,65.89 127.91,65.89 128.06,66.03 128.06,66.33 127.91,66.48 126.96,66.48 126.81,66.63 126.81,66.93 126.96,67.08 127.91,67.08 128.06,67.23 128.06,67.53 127.91,67.68 126.96,67.68 126.81,67.83 126.81,68.11 127.07,68.37 127.94,68.37 128.06,68.5 128.06,75.35
  BOTTOM w0.076: v2(125.3,82.63) 126.03,83.36 126.03,84.84 125.91,84.95 125.91,85.46 CPU1.AE2
  BOTTOM w0.178: v2(123.22,48.4) 123.02,48.59 JDIMM1.157
DDR_CS2_DIMMB#: length 65.7
  IN1 w0.089: v2(125.7,91.24) 125.7,91.3 125.54,91.45 125.31,91.45 125.18,91.32 125.18,90.51 124.92,90.25 124.92,89.08 125.24,88.75 125.24,88.14 125.24,85.47 125.99,84.72 125.99,80.21 127.23,78.98 127.23,75.35
  IN1 w0.145: 127.23,75.35 127.23,65.3 121.67,59.75 121.67,43.39 121.52,43.24 121.52,38.1 121.32,37.89 v2(121.32,35.47)
  BOTTOM w0.076: CPU1.AF11 125.31,91.6 125.67,91.24 v2(125.7,91.24)
  BOTTOM w0.178: v2(121.32,35.47) 121.3,35.47 120.25,34.42 120.07,34.42 119.68,34.81 119.68,34.99 121.03,36.33 JDIMM2.149
DDR_CS3_DIMMB#: length 68.3
  IN1 w0.089: v2(126.57,88.65) 126.2,88.28 126.2,86.77 126.95,86.01 126.95,80.53 129.25,78.24 129.25,75.35
  IN1 w0.145: v2(123.18,34.07) 124.11,35.01 124.11,36.32 123.67,36.77 123.67,38.63 124.02,38.98 124.02,40.24 124.83,41.05 124.83,41.38 124.68,41.52 123.84,41.52 123.69,41.67 123.69,41.97 123.84,42.12 124.68,42.12 124.83,42.27 124.83,51.3 124.21,51.92 124.21,54.84 124.36,54.99 124.9,54.99 125.05,55.14 125.05,55.44 124.9,55.59 124.36,55.59 124.21,55.74 124.21,56.04 124.36,56.19 124.9,56.19 125.05,56.34 125.05,56.64 124.9,56.79 124.36,56.79 124.21,56.94 124.21,57.24 124.36,57.39 124.9,57.39 125.05,57.54 125.05,60.27 129.25,64.46 129.25,75.35
  BOTTOM w0.076: CPU1.AE7 126.52,88.65 v2(126.57,88.65)
  BOTTOM w0.178: JDIMM2.157 123.03,36.33 123.69,35.67 123.69,34.58 v2(123.18,34.07)
DDR_RCOMP0: length 6.1
  BOTTOM w0.089: 142.36,80.49 RH148.2
  BOTTOM w0.114: 142.36,80.49 142.36,80.44 v1(142.54,80.26)
  BOTTOM w0.254: 141.03,84.24 140.93,84.24 140.08,85.09 CPU1.G1
  BOTTOM w0.381: RH148.2 142.36,82.91 141.03,84.24
DDR_RCOMP1: length 3.3
  BOTTOM w0.254: CPU1.H1 139.02,84.41 139.46,83.97
  BOTTOM w0.381: RH149.2 139.96,82.58 v1(139.96,83.47) 139.46,83.97
DDR_RCOMP2: length 4
  BOTTOM w0.254: RH150.2 138.66,82.35 v1(138.66,83.27) 138.98,83.59 138.98,83.93 138.44,84.49 138.44,85.46 CPU1.J2
DDR_VTT_PG_CTRL: length 22.5
  TOP w0.089: 100.03,91.35 101.1,92.41 101.1,93.05 101.73,93.68 v2(101.79,93.68)
  TOP w0.127: UC1.2 98.11,75.65 98.77,76.3 v3(98.77,77.56) 98.77,86.27 98.07,86.97 98.07,88.54 99.86,90.34 99.86,91.17 100.03,91.35
  BOTTOM w0.089: CPU1.BT13 102.36,93.11 v2(101.79,93.68)
DEBUG_CTL1: length 11.9
  IN5 w0.097: v2(118.14,151.1) 119.33,151.1 120.46,152.23 122.72,152.23 124.59,150.36 v2(124.59,150.28)
  BOTTOM w0.076: UT4.E4 124.89,150.58 v2(124.59,150.28)
  BOTTOM w0.114: v2(118.14,151.1) v1(118.75,150.49) 119.01,150.23 119.01,149.6 119.94,148.67 RT66.2
DEBUG_CTL2: length 13.7
  IN5 w0.099: v2(125.22,149.73) 124.78,149.28 124.44,149.28 124.03,149.69 124.03,150.52 122.63,151.92 120.73,151.92 119.33,150.52 v2(118.14,150.52)
  BOTTOM w0.076: UT4.D5 125.55,150.06 v2(125.22,149.73)
  BOTTOM w0.114: v2(118.14,150.52) 118.68,149.98 118.68,149.05 v1(119.42,148.3) 119.94,147.78 RT67.2
DEMB0: length 7.9
  BOTTOM w0.114: UM8.53 107.9,148.4 108.21,148.1 108.21,147.1 v1(109.23,146.07) 109.23,142.9 108.82,142.48 RM79.2 RM75.2
DEMB1: length 4.1
  BOTTOM w0.114: UM8.54 107.79,147.9 107.96,147.73 v1(107.96,145.87) 107.96,145.1 RM62.2 RM86.2
DEPOP#_EC: length 69.1
  TOP w0.114: UE6.2 68.65,9.47 v2(68.91,9.74) ; v2(35.07,40.41) 35.69,41.03 DA2.3
  IN5 w0.097: v2(35.07,40.41) 34.69,40.79 33.42,40.79 32.76,40.14 32.76,20.44 35.59,17.61 35.59,13.79 35.72,13.67 39.63,13.67 41.9,11.39 50.29,11.39 51.06,12.15 67.71,12.15 68.85,11.01 68.85,9.8 v2(68.91,9.74)
  BOTTOM w0.114: v1(35.54,39.94) v2(35.07,40.41)
DET: length 184.4
  TOP w0.102: RH584.1 RH585.2 168.09,30.17 v1(168,30.26) 167.87,30.39 v2(167.47,30.39)
  TOP w0.114: v2(129.36,162.83) 129.01,162.47 125.73,162.47 125.1,161.84 JEDP.28
  IN1 w0.089: v2(167.47,30.39) 167.97,30.89 167.97,32.3
  IN1 w0.097: 161.89,42.88 161.95,42.88 162.58,42.25 163.84,42.25 166.74,39.34 166.74,36.22 v2(167.45,35.51) 167.45,33.83 167.97,33.32 167.97,32.3
  IN1 w0.102: v2(155.14,136.93) 156.92,136.93 158.07,135.79 158.07,135.09 159.53,133.63 159.53,119.82 160.73,118.62 160.73,115.46 159.92,114.65 157.49,114.65 152.77,109.93 152.77,107.5 151.15,105.88 151.15,78.98 153.78,76.35 153.78,70.12 155.33,68.58 155.33,50.83 156.11,50.05 156.11,46.26 159.04,43.33 161.43,43.33 161.89,42.88
  IN2 w0.097: v2(155.14,136.93) 155.14,137.18 154.68,137.65 154.2,137.65 151,140.85 132.23,140.85 131.35,141.74 131.35,148.08 132.81,149.55 132.81,154.27 131.4,155.69 131.4,156.82 131.75,157.17 131.75,160.98 129.91,162.83 v2(129.36,162.83)
  BOTTOM w0.089: UH1.R35 167.06,35.9 v2(167.45,35.51)
DEVSLP0: length 127.6
  TOP w0.114: v2(187.23,23.54) v1(187.23,22.78)
  IN2 w0.104: v2(243.34,32.37) 241.65,30.67 241.65,16.61 236.27,11.23 232.48,11.23 231.77,11.94 224.81,11.94 224.48,12.27 218.66,12.27 213.66,7.27 212.39,7.27 212.08,6.96 203.38,6.96 201.63,8.71 193.85,8.71 189.43,13.12 189.43,17.58 187,20.01 187,23.31 v2(187.23,23.54)
  IN5 w0.097: v2(173.17,32.54) 173.17,31.74 172.54,31.11 172.54,28.92 172.32,28.7 172.32,26.87 172.51,26.68 172.51,24.02 173.5,23.02 175.73,23.02 176.46,22.29 177.47,22.29 178.04,21.72 180.08,21.72 180.42,22.06 184.14,22.06 185.63,23.54 186.35,23.54 186.38,23.51 187.2,23.51 v2(187.23,23.54)
  BOTTOM w0.089: v2(173.17,32.54) 172.76,32.38 UH1.AG42
  BOTTOM w0.114: JSSD1.38 233.44,35.8 236.88,32.37 v2(243.34,32.37)
DEVSLP3: length 96.3
  IN5 w0.097: v2(215.79,24.11) 215.5,23.82 215.5,20.19 213.61,18.31 213.61,17.5 209.59,13.49 203.82,13.49 203.61,13.27 195.57,13.27 187.8,21.04 180.74,21.04 180.53,20.84 177.8,20.84 177.14,21.5 173.58,21.5 171.03,24.04 171.03,24.53 171.19,24.69 171.19,25.27 171.07,25.38 171.07,29.04 171.57,29.55 171.57,32 170.76,32.81 v2(170.76,33.25)
  BOTTOM w0.089: UH1.AB41 170.28,32.77 v2(170.76,33.25)
  BOTTOM w0.114: v2(215.79,24.11) 216.12,23.77 v1(218.45,23.77) 219.47,23.77 219.79,24.1 230.41,24.1 230.96,23.54 230.96,20.68 231.5,20.14 231.5,14.11 233.71,11.9 JSSD2.38
DGPU_ENBKL: length 74.8
  IN1 w0.097: v2(185.13,74.55) 184.66,74.55 184.42,74.79 184.42,76.41 184.04,76.8 184.04,79.73 183.85,79.92 183.85,81.89 184.61,82.65 184.61,83.15 183.08,84.67 179.27,84.67 178.58,85.37 178.58,86.32 175.12,89.78 175.12,92.74 173.05,94.8 173.05,111.6 173.96,112.5 173.96,131.07 v2(173.43,131.6)
  BOTTOM w0.114: v2(185.13,74.55) 185.69,75.11 185.69,76.39 185.56,76.52 RG501.1 185.3,76.52 UG9.BB1 ; v2(173.43,131.6) 172.89,131.05 v3(172.73,131.05) 172.16,131.62 UV22.11
DGPU_ENVDD: length 102.6
  TOP w0.089: RG151.1 181.01,79.49 181.24,79.72 181.24,80.31 v2(180.8,80.75)
  IN1 w0.097: v2(180.8,80.75) 180.8,80.7 180.22,80.12 180.22,77.87 v2(179.27,76.92) 178.39,76.03 172.86,76.03 v2(172.23,75.4)
  IN2 w0.097: v2(172.23,75.4) 169.11,78.51 165.13,78.51 165.01,78.64 165.01,86.15 v2(165.39,86.54)
  BOTTOM w0.114: v2(179.27,76.92) 180.09,76.11 QG506.2 ; v2(165.39,86.54) 163.3,86.54 159.36,90.47 156.2,90.47 148.39,98.29 148.39,105.59 146.13,107.85 146.13,110.03 147.92,111.82 147.92,113.05 149.7,114.83 157.24,114.83 157.37,114.96 157.37,115.93 159.08,117.64 159.77,117.64 160.33,118.19 v3(160.33,128.21) 163.09,130.97 UV22.5 ; UG9.BH3 v2(180.8,80.75)
DGPU_HOLD_RST#: length 68.3
  IN4 w0.089: 164.26,55.17 164.26,53.08 165.94,51.4 165.94,45.38 166.13,45.19 166.13,42.33 166.96,41.51 166.96,34.44 167.78,33.62 170.34,33.62 171.74,35.01 173.58,35.01 174.01,34.58 v2(175.46,34.58)
  IN4 w0.137: 164.26,55.17 164.26,63.75 v2(164.77,64.26)
  BOTTOM w0.089: UH1.AL36 175.05,34.99 v2(175.46,34.58)
  BOTTOM w0.114: UG10.1 186.1,58.83 RG13.1 RG3.2 185.43,58.57 185.04,58.18 179.27,58.18 178.41,59.04 178.41,59.79 177.54,60.66 177.54,61.3 175.57,63.27 172.23,63.27 171.59,62.64 171.55,62.64 171.37,62.46 166.41,62.46 164.77,64.1 v2(164.77,64.26)
DGPU_INV_PWM: length 103
  TOP w0.114: RG536.2 164.43,61.39 UG24.6 164.65,61.92 164.8,62.06 167.08,62.06 v2(167.08,62.06)
  IN3 w0.124: v2(182.96,70.69) 182.65,70.69 181.26,72.08 172.46,72.08 166.13,65.76 166.13,62.76 166.83,62.06 v2(167.08,62.06)
  IN5 w0.097: v2(176.73,127.72) 176.33,127.32 176.33,97.58 177.18,96.73 177.18,84.29 177.62,83.84 177.62,81.43 177.31,81.11 177.31,79.93 178.47,78.77 179.42,78.77 180.68,77.51 180.68,74.23 183.34,71.58 183.34,71.14 182.96,70.77 v2(182.96,70.69)
  BOTTOM w0.114: UV22.2 167.88,129.02 170.58,126.33 174.28,126.33 v3(175.5,127.54) 175.68,127.72 v2(176.73,127.72)
DGPU_PEX_RST#: length 225.2
  TOP w0.114: v2(184.8,77.49) 185.07,77.76 185.8,77.76 185.99,77.57 QG501.2 QG501.5 ; v2(173.37,93.37) 173.37,93.18 172.23,92.04 165.69,92.04 164.17,93.55 164.17,101.31 165.44,102.58 165.44,103.41 167.15,105.12 v2(168.04,105.12) ; UG22.1 182.08,60.97 181.94,61.11 181.94,62.38 182.82,63.26 183.48,63.26 v2(183.59,63.14) ; v2(194.01,156.55) 194.01,155.98 195.09,154.9 195.09,154.46 194.9,154.27 UX1.2
  IN1 w0.097: v2(166.82,162.91) 167.53,162.91 168.23,162.22 168.23,159.94 v2(168.64,159.53) 169.86,158.3 171.51,158.3 171.8,158.59 171.8,158.64 v2(171.81,158.64) 171.81,159.39 172.96,160.54 174.93,160.54 178.99,156.48 178.99,153.02 179.65,152.36 180.75,152.36 181.31,152.92 181.31,153.74 181.77,154.2 185.88,154.2 186.28,153.8 189.45,153.8 190.27,154.62 192.97,154.62 194.01,155.65 v2(194.01,156.55)
  IN4 w0.137: v2(168.04,105.12) 168.04,107.68 168.29,107.93 168.29,140.48 159.91,148.86 159.91,153.25 163.21,156.55 163.21,161.89 164.15,162.83 166.73,162.83 v2(166.82,162.91)
  IN5 w0.097: v2(185.43,65.29) 186.51,66.37 186.51,70.58 v2(187.15,71.22) 185.93,72.44 185.93,76.36 v2(184.8,77.49) ; v2(183.59,63.14) 183.59,62.71 183.32,62.44 179.64,62.44 178.6,63.48 173.85,63.48 169.28,68.06 169.28,73.36 168.56,74.08 168.56,77.22 169.81,78.47 169.81,85.66 172.58,88.42 172.58,92.39 173.37,93.18 v2(173.37,93.37)
  BOTTOM w0.114: v2(166.82,162.91) 167.3,163.4 UX2.2 ; QG6.5 v2(185.43,65.29) QG6.2 185.43,64.03 184.55,63.14 v2(183.59,63.14) RG6.2 183.16,63.78 182.03,62.65 181.55,62.65 DG1.1 181.78,61.3 182.98,61.3 RG7.2 ; QV96.2 v2(168.64,159.53) ; v2(173.37,93.37) 173.24,93.37 172.92,93.69 172.92,94.19 173.43,94.7 RG25.1 174.73,94.98 175.87,96.13 177.27,96.13 177.73,96.59 178.56,96.59 178.77,96.8 179.21,96.8 179.56,97.15 UG9.BK26 ; QV96.5 171.54,159.53 171.81,159.26 v2(171.81,158.64) ; QG7.2 v2(187.15,71.22) QG7.5
DGPU_PRSNT#: length 5.1
  TOP w0.089: 184.56,43.45 v1(183.59,43.45) 183.44,43.45 v2(182.82,42.83)
  TOP w0.114: RH135.2 184.56,43.45
  BOTTOM w0.076: UH1.BC19 180.97,43.48 181.11,43.34 181.68,43.34 181.7,43.36 182.02,43.36 182.04,43.34
  BOTTOM w0.089: 182.04,43.34 182.19,43.19 182.46,43.19 v2(182.82,42.83)
DGPU_PWR_EN: length 213.2
  TOP w0.114: v2(88.42,4.48) 88.67,4.74 UE5.1 ; v2(86.98,58.93) 88.73,58.93 91.87,62.06 92.61,62.06 93.14,62.6 RG551.1
  IN1 w0.254: v2(173.18,33.13) 173.3,33.13 173.68,32.75 173.68,31.21 173.43,30.95 173.43,30.19 173.11,29.88 v2(172.98,29.88)
  IN2 w0.097: v2(94.32,23.27) 93.88,23.71 93.5,23.71 92.17,22.38 89.17,22.38 88.62,22.93 86.72,22.93 86.59,23.05 v2(86.59,23.39)
  IN4 w0.137: v2(86.98,58.93) 86.29,58.93 85.74,58.38 85.74,57.91 85.37,57.55 85.37,55.16 84.91,54.7 84.91,42.51 84.34,41.93 84.34,39.27 84.79,38.82 84.79,30.89 85.3,30.37 85.3,28.67 84.79,28.15 84.79,26.49 86.46,24.82 86.46,23.51 v2(86.59,23.39) ; v2(122.44,17.68) 121.92,17.16 119.97,17.16 119.39,16.57 108.75,16.57 106.95,18.38 106.95,22 106.19,22.76 104.54,22.76 103.39,21.61 103.39,17.04 102.38,16.03 99.84,16.03 98.38,17.49 98.38,23.33 97.74,23.96 95.77,23.96 95.07,23.27 v2(94.32,23.27) 94.32,23.38 93.99,23.71 93.3,23.71 92.79,23.2 92.79,22.06 91.77,21.04 91.77,19.26 93.23,17.8 93.23,15.58 94.69,14.12 94.69,10.82 94.25,10.37 94.25,9.1 96.15,7.2 96.15,5.8 95.39,5.04 88.98,5.04 v2(88.42,4.48)
  IN5 w0.254: v2(156.92,27.96) 155.72,27.96 155.27,27.52 155.27,19.2 154.07,17.99 150.95,17.99 149.3,19.65 125.28,19.65 123.72,18.08 122.85,18.08 v2(122.44,17.68)
  BOTTOM w0.254: v2(156.92,27.96) 157.43,28.47 160.48,28.47 162.13,30.12 164.77,30.12 165,29.89 166.44,29.89 167.24,29.09 167.24,27.22 166.42,26.41 166.42,23.05 166.63,22.85 168.82,22.85 170.22,24.24 171.02,24.24 172.35,25.58 v3(172.35,26.3) 172.35,28.35 172.61,28.6 RH537.1 173.49,29.37 v2(172.98,29.88) ; v2(173.18,33.13) 173.56,33.51 UH1.AJ39
DGPU_PWROK: length 139.3
  TOP w0.089: RH516.2 174.26,29.25 174.26,30.22 v2(173.9,30.58)
  TOP w0.114: v2(108.66,22.57) 108.66,22.19 108.62,22.15 108.62,20.43 v3(108.57,20.38) 107.98,19.79 107.98,13.33 107.33,12.67 107.33,3.07 105.59,1.33 88.18,1.33 85.68,3.83 82.88,3.83 79.96,0.91 70.31,0.91 69.67,1.55 69.67,2.44 69.99,2.75 69.99,5.56 UE6.19
  IN1 w0.097: v2(108.66,22.57) 109.11,22.57 109.66,22.01 112.01,22.01 113.21,20.81 117.7,20.81 119.11,22.22 132.85,22.22 133.36,22.73 143.38,22.73 143.9,22.22 150.2,22.22 151.23,23.25 v2(152.75,23.25)
  IN2 w0.089: 172.46,28.24 172.7,28.24 172.96,28.5 173.33,28.5 174.23,29.4 174.23,29.88 174.07,30.04 174.07,30.42 v2(173.9,30.58)
  IN2 w0.097: 172.46,28.24 172.05,27.83 171.61,27.83 170.22,26.44 169.17,26.44 168.54,25.81 156.6,25.81 154.03,23.25 v2(152.75,23.25)
  BOTTOM w0.089: UH1.AJ44 173.83,30.87 173.9,30.8 v2(173.9,30.58)
DGPU_ROM_CS#: length 17.1
  TOP w0.114: v1(164.86,73.05) 164.88,73.03 v2(164.88,72.48)
  IN3 w0.124: v2(168.54,79.84) 166.07,77.37 166.07,75.08 164.88,73.9 v2(164.88,72.48)
  BOTTOM w0.114: 168.67,77.43 169.45,76.65 169.85,76.65 170.17,76.33 RG538.1 ; 168.67,77.43 UG13.1 168.67,79.72 v2(168.54,79.84) ; 168.67,77.43 168.67,77.24 167.84,76.41 167.84,75.91 167.71,75.77 UG16.11 ; RG74.2 164.91,72.51 v2(164.88,72.48)
DGPU_ROM_SCLK: length 8.8
  BOTTOM w0.114: RG75.1 170.12,79.44 v2(168.63,80.93) 166.13,83.43 UG13.6
DGPU_ROM_SI: length 12
  BOTTOM w0.114: UG13.5 164.86,84.08 169.56,79.38 169.56,77.49 169.94,77.11 RG77.1 170.07,77.11 170.83,76.35 170.96,76.35 v1(171.21,76.1)
DGPU_ROM_SO: length 4.7
  BOTTOM w0.114: UG16.8 166.46,74.27 166.18,73.99 RG76.1 165.72,73.9 RG539.1 164.7,73.9 164.29,73.49 164.29,72.29 v1(164.16,72.16)
DGPU_ROM_SO_R: length 3.8
  BOTTOM w0.114: UG13.2 167.4,77.8 v1(165.81,76.22) RG76.2
DH_1.2V: length 1.2
  BOTTOM w0.114: v1(64.08,48.54) 64.15,48.61 64.15,49.6 v2(64.08,49.67)
  vias: v2(63.69,50.12) v2(66.17,51.7) v2(66.17,51.07)
DH_CHG: length 12.3
  TOP w0.114: v2(60.64,17.98) v1(60.64,17.4)
  IN5 w1.016: 60.35,18.8 60.35,28.47 58.9,29.91 58.89,29.91
  vias: v2(58.72,31.64) v2(58.72,31.06) v2(60.05,17.96)
DIMM_CHA_SA0: length 6.5
  TOP w0.114: v2(145.74,39.67) 145.38,39.67 v1(145.15,39.9) 145.04,40.01 145.04,41.18 RD28.1
  BOTTOM w0.127: JDIMM1.256 147.77,40.51 146.94,39.67 v2(145.74,39.67)
DIMM_CHA_SA1: length 3.2
  TOP w0.114: RD29.1 149.29,40.48 149.47,40.3 v2(149.47,40.3) 149.47,40.03 v1(149.21,39.78)
  BOTTOM w0.127: v2(149.47,40.3) 148.77,41 JDIMM1.260
DIMM_CHA_SA2: length 7
  TOP w0.114: RD30.1 125.48,36.67 125.02,37.13 v2(125.02,39.05) 125.43,39.05 v1(125.95,39.56)
  BOTTOM w0.127: v2(125.02,39.05) 125.28,39.3 JDIMM1.166
DIMM_CHB_SA0: length 4.6
  TOP w0.114: RD38.1 145.81,26.67 146.71,27.57 v1(146.81,27.57) 147.17,27.57 v2(147.4,27.35)
  BOTTOM w0.114: JDIMM2.256 147.78,27.98 147.4,27.6 v2(147.4,27.35)
DIMM_CHB_SA1: length 5.6
  TOP w0.114: RD5.2 147.47,26.67 148,27.19 v2(148,27.38) 148,28.51 v1(147.32,29.18)
  BOTTOM w0.114: 148.78,28.16 148,27.38 v2(148,27.38)
  BOTTOM w0.127: JDIMM2.260 148.78,28.16
DIMM_CHB_SA2: length 5.8
  TOP w0.114: v2(125.87,30.83) 126.56,30.15 126.56,29.33 RD40.1 128.33,29.33 v1(128.37,29.37)
  BOTTOM w0.114: JDIMM2.166 125.28,30.23 v2(125.87,30.83)
DISP_CEC: length 3.7
  BOTTOM w0.114: RV18.2 198.71,161.19 198.82,161.3 198.82,162.41 199.52,163.11 JDP.6
DISP_CLK_AUXP_CONN: length 25.6
  TOP w0.114: RV15.2 191.34,154.2 v2(191.91,153.63)
  IN5 w0.097: v2(195.96,156.45) 196.13,156.62 196.13,157.16 195.85,157.44 191.72,157.44 191.14,156.86 191.14,153.76 191.27,153.63 v2(191.91,153.63)
  BOTTOM w0.114: v2(191.91,153.63) 192.04,153.63 192.29,153.88 UV3.4 ; v2(195.96,156.45) 196.12,156.6 196.12,156.86 196.38,157.12 197.86,157.12 198.68,157.95 201.48,157.95 202.34,158.81 202.34,162.12 202.73,162.51 202.73,163.03 202.52,163.24 JDP.16
DISP_DAT_AUXN_CONN: length 25.3
  TOP w0.114: RV16.2 190.7,153.95 v2(190.45,153.7)
  IN5 w0.097: v2(196.55,156.45) 196.36,156.64 196.36,157.25 195.94,157.66 191.63,157.66 190.92,156.96 190.92,154.17 v2(190.45,153.7)
  BOTTOM w0.114: v2(190.45,153.7) 190.34,153.8 UV3.7 ; JDP.18 203.13,163.21 202.97,163.06 202.97,162.41 202.58,162.02 202.58,158.71 201.58,157.71 v4(199.4,157.71) 198.78,157.71 197.96,156.88 196.48,156.88 196.36,156.76 196.36,156.64 v2(196.55,156.45)
DISPOFF#: length 23.3
  TOP w0.114: JEDP.35 121.6,160.85 v2(121.69,160.95)
  IN3 w0.124: v2(121.69,160.95) 122.48,160.16 133.9,160.16 136.38,157.68 136.38,157.55 v2(136.86,157.07)
  BOTTOM w0.114: v2(136.86,157.07) 136.82,157.11 135.57,157.11 135.18,156.72 RV1.1 135.18,155.9 135.58,155.51 DV1.1 135.58,153.77 v1(135.89,153.45)
DL_1.2V: length 10.1
  IN1 w1.016: 63.32,48.03 63.71,47.64 72.01,47.64
  BOTTOM w0.114: v1(63.13,47.46) 63.13,47.99 v2(62.65,48.47)
  vias: v2(62.67,49.07) v2(72.97,48.55) v2(72.97,47.97)
DL_CHG: length 5.6
  IN5 w1.016: 52.15,26.76 52.15,27.35 55.7,30.9
  vias: v1(51.92,25.28) v2(51.8,25.81) v2(52.44,25.81) v2(56.72,31.53) v2(57.12,31.97)
DMI_CRX_PTX_N0: length 66.3
  IN1 w0.104: v2(141.19,89.8) 141.36,89.62 141.36,89.23 141.6,88.99 142.25,88.99 143.71,87.53 143.71,86.51 147.61,82.61 147.61,75.82 149.45,73.98 149.45,62.17 151.05,60.57 151.05,47.62 152.03,46.63 152.03,44.18 152.82,43.39 152.82,41.15 154.06,39.91 154.06,38.77 154.52,38.31 155.3,38.31 v2(155.44,38.17)
  BOTTOM w0.076: 159.19,39.97 160.01,39.97 160.27,39.71 160.27,39.71 160.4,39.57 160.64,39.57 160.97,39.9 UH1.C27 ; v2(141.19,89.8) CPU1.E8
  BOTTOM w0.114: v2(155.44,38.17) 155.44,38.2 155.63,38.38 155.93,38.38 156.19,38.64 156.19,39.39 157.16,40.35 v4(158,40.35) 158.69,40.35 159.07,39.97 159.19,39.97
DMI_CRX_PTX_N1: length 68.6
  IN1 w0.104: v2(140.54,88.18) 140.95,88.59 141.99,88.59 143.21,87.38 143.21,86.19 147.01,82.39 147.01,75.53 148.16,74.39 148.16,62.62 148.85,61.93 148.85,61.92 150.42,60.35 150.42,47.35 151.43,46.35 151.43,43.93 152.22,43.14 152.22,40.52 153.43,39.31 153.43,37.03 154.02,36.43 155.39,36.43 v2(155.46,36.37)
  BOTTOM w0.089: 157.41,39.56 157.44,39.58 158.63,39.58 158.76,39.44 159.37,39.44 159.62,39.19 160.21,39.19 UH1.B28 ; v2(140.54,88.18) 140.54,88.27 CPU1.F6
  BOTTOM w0.114: 157.41,39.56 157.41,39.56 v4(157.05,39.2) 156.89,39.04 156.89,38.29 156.35,37.74 156.35,36.79 156.03,36.47 155.57,36.47 v2(155.46,36.37)
DMI_CRX_PTX_N2: length 69.6
  IN1 w0.104: v2(141.19,88.22) 141.37,88.05 141.37,87.84 142.64,86.57 142.64,85.57 143.42,84.79 143.7,84.79 146.41,82.08 146.41,74.99 147.56,73.84 147.56,61.32 147.68,61.2 147.68,58.81 149.68,56.81 149.68,47.21 150.83,46.06 150.83,41.04 151.97,39.9 151.97,36.03 152.85,35.14 155.65,35.14 156.81,36.3 156.9,36.3 156.9,36.3 157,36.3 v2(157.11,36.19)
  BOTTOM w0.076: 160.26,38.73 160.4,38.58 160.51,38.58 160.58,38.66 160.58,38.78 UH1.B29 ; v2(141.19,88.22) 140.86,87.9 CPU1.E5
  BOTTOM w0.089: 160.26,38.73 159.58,38.73 159.22,39.08 158.02,39.08 157.51,38.57 157.51,38.55
  BOTTOM w0.114: 157.51,38.55 157.51,36.87 157.52,36.86 157.52,36.63 157.11,36.21 v2(157.11,36.19)
DMI_CRX_PTX_N3: length 73.8
  IN1 w0.104: v2(157.11,35) 156.82,34.71 152.46,34.71 151.56,35.61 151.56,39.49 148.78,42.27 148.78,56.45 147.27,57.96 147.27,60.86 147.15,60.98 147.15,73.57 145.77,74.95 145.77,81.6 145.23,82.14 144.99,82.14 142.25,84.89 142.25,85.82 140.01,88.05 140.01,89.92 139.58,90.35 139.42,90.35 v2(139.18,90.59)
  BOTTOM w0.076: CPU1.J9 v2(139.18,90.59)
  BOTTOM w0.089: 157.88,36.12 157.88,36.13 157.91,36.16 157.91,38.13 158.4,38.62 159.43,38.62 159.5,38.55 159.75,38.55 159.79,38.51 160.2,38.51 160.52,38.19 UH1.B30
  BOTTOM w0.114: v2(157.11,35) 157.65,35 157.88,35.24 157.88,36.12
DMI_CRX_PTX_P0: length 66.3
  IN1 w0.104: v2(141.84,89.8) 141.68,89.8 141.56,89.67 141.56,89.31 141.68,89.18 142.33,89.18 143.91,87.61 143.91,86.59 147.81,82.69 147.81,75.9 149.64,74.06 149.64,62.25 151.24,60.65 151.24,47.7 152.23,46.71 152.23,44.26 153.01,43.47 153.01,41.23 154.26,39.99 154.26,38.85 154.6,38.51 155.26,38.51 155.44,38.69 v2(155.44,38.75)
  BOTTOM w0.076: v2(141.84,89.8) 141.66,89.8 141.51,89.65 CPU1.D8 ; UH1.B27 160.64,39.8 160.73,39.9 160.73,40.05 160.63,40.15 160.48,40.15 160.35,40.02 160.19,40.02 160.06,40.15 159.22,40.15 159.2,40.17 159.19,40.17
  BOTTOM w0.114: v2(155.44,38.75) 155.59,38.6 155.84,38.6 155.97,38.73 155.97,39.48 157.06,40.57 157.65,40.57 157.67,40.59 158.27,40.59 158.29,40.57 158.76,40.57 159.16,40.17 159.19,40.17
DMI_CRX_PTX_P1: length 68.5
  IN1 w0.104: v2(140.54,89.01) 140.76,88.79 142.07,88.79 143.4,87.46 143.4,86.27 147.2,82.47 147.2,75.61 148.35,74.47 148.35,62.7 149.04,62.01 149.04,62 150.62,60.43 150.62,47.43 151.62,46.43 151.62,44.01 152.41,43.22 152.41,40.6 153.62,39.39 153.62,37.11 154.1,36.63 155.18,36.63 155.46,36.91 v2(155.46,36.95)
  BOTTOM w0.076: 159.44,39.62 159.51,39.62 159.59,39.54 159.59,39.48 159.67,39.39 159.79,39.39 159.84,39.44 159.84,39.63 159.89,39.68 160.04,39.68 160.17,39.55 160.17,39.45 UH1.A28
  BOTTOM w0.089: 159.44,39.62 158.84,39.62 158.7,39.76 157.26,39.76 157.25,39.74 ; v2(140.54,89.01) 140.54,88.94 CPU1.E6
  BOTTOM w0.114: 157.25,39.74 156.67,39.16 156.67,38.38 156.13,37.84 156.13,36.88 155.94,36.7 155.71,36.7 v2(155.46,36.95)
DMI_CRX_PTX_P2: length 69.6
  IN1 w0.104: v2(141.84,88.22) 141.68,88.22 141.56,88.11 141.56,87.92 142.83,86.65 142.83,85.65 143.5,84.99 143.78,84.99 146.6,82.16 146.6,75.07 147.75,73.92 147.75,61.4 147.87,61.28 147.87,58.89 149.88,56.89 149.88,47.29 151.02,46.14 151.02,41.12 152.16,39.98 152.16,36.11 152.93,35.33 155.57,35.33 156.73,36.49 156.82,36.49 v2(157.11,36.78)
  BOTTOM w0.076: CPU1.D5 141.51,87.9 v2(141.84,88.22) ; 160.29,38.9 160.45,39.06 160.66,39.06 160.91,38.81 UH1.C29
  BOTTOM w0.089: 160.29,38.9 159.65,38.9 159.3,39.26 157.95,39.26 157.3,38.61
  BOTTOM w0.114: 157.3,38.61 157.3,36.93 157.15,36.78 v2(157.11,36.78)
DMI_CRX_PTX_P3: length 73.8
  IN1 w0.104: v2(157.11,34.42) 157,34.52 152.38,34.52 151.37,35.53 151.37,39.41 148.59,42.19 148.59,56.37 147.08,57.88 147.08,60.78 146.95,60.9 146.95,73.49 145.58,74.87 145.58,81.52 145.15,81.95 144.91,81.95 142.05,84.81 142.05,85.74 139.82,87.97 139.82,89.84 139.5,90.16 139.37,90.16 139.24,90.03 v2(139.24,89.8)
  BOTTOM w0.076: v2(139.24,89.8) 138.92,89.8 CPU1.J8
  BOTTOM w0.089: UH1.A30 160.14,38.12 160.01,37.99 159.89,37.99 159.78,38.1 159.78,38.27 159.68,38.37 159.43,38.37 159.36,38.44 158.47,38.44 158.09,38.06 158.09,36.16 158.11,36.14 158.11,36.12
  BOTTOM w0.114: 158.11,36.12 158.11,35.14 157.74,34.77 157.46,34.77 v2(157.11,34.42)
DMI_CTX_PRX_N0: length 67.5
  IN1 w0.104: v2(146.63,87.92) 146.83,87.73 146.83,87.53 147.08,87.27 149.16,87.27 150.25,86.19 150.25,78.61 152.8,76.05 152.8,70.24 152.09,69.53 152.09,68.03 154.04,66.09 154.04,48.19 155.23,46.99 155.23,45.77 158.13,42.87 158.13,42.52 159.53,41.12 163.94,41.12 164.86,40.2 164.86,39.68 164.63,39.45 v2(164.59,39.45)
  BOTTOM w0.076: CPU1.A8 143.35,89.29 143.17,89.29 143.09,89.37 143.09,89.51 143.27,89.68 143.58,89.68 143.77,89.87 144.25,89.87 144.5,89.62 145.17,89.62
  BOTTOM w0.089: UH1.L27 165.05,39.92 v2(164.59,39.45)
  BOTTOM w0.127: 145.17,89.62 145.18,89.62 146.51,89.62 146.93,89.21 146.93,88.17 146.68,87.92 v2(146.63,87.92)
DMI_CTX_PRX_N1: length 64.7
  IN1 w0.104: v2(162.37,40.5) 162.5,40.37 162.5,40.21 162.38,40.09 162.2,40.09 161.94,40.35 161.77,40.35 161.22,39.79 159.6,39.79 157.05,42.35 157.05,42.93 154.63,45.35 154.63,46.71 153.24,48.1 153.24,65.96 151.26,67.94 151.26,75.01 149.42,76.85 149.42,85.87 148.65,86.64 146.18,86.64 145.64,87.17 145.64,87.77 145.49,87.92 v2(145.4,87.92)
  BOTTOM w0.076: CPU1.B6 142.81,88.45 142.77,88.41 142.49,88.41 142.44,88.47 142.44,88.62 142.46,88.64 142.46,88.81 142.57,88.92 144.61,88.92 144.63,88.94 144.66,88.94
  BOTTOM w0.089: UH1.E24 162.01,40.86 v2(162.37,40.5)
  BOTTOM w0.127: 144.66,88.94 145.16,88.94 145.57,88.53 145.57,88.09 v2(145.4,87.92)
DMI_CTX_PRX_N2: length 63.3
  IN1 w0.104: v2(146.79,86.02) 147.2,85.6 147.2,84.99 148.82,83.38 148.82,76.6 150.66,74.76 150.66,64.88 151.33,64.21 151.33,62.07 152.63,60.76 152.63,47.81 153.24,47.21 153.24,44.68 154.02,43.89 154.02,43.66 158.54,39.14 160.86,39.14 161.25,38.76 162.76,38.76 163,39 163,39.33 163.12,39.45 v2(163.13,39.45)
  BOTTOM w0.076: CPU1.A5 143.6,87.72 143.77,87.72 143.83,87.78 143.83,87.87 143.77,87.93 143.77,88.06 143.82,88.11 143.91,88.11 143.94,88.08 143.95,88.08 143.97,88.11
  BOTTOM w0.089: UH1.G27 162.77,39.81 v2(163.13,39.45)
  BOTTOM w0.127: 143.97,88.11 144.21,88.11 145.24,87.08 146.5,87.08 147.2,86.38 147.2,86.06 147.08,85.93 146.88,85.93 v2(146.79,86.02)
DMI_CTX_PRX_N3: length 66.8
  IN1 w0.104: v2(165.35,38.19) 165.3,38.19 165.18,38.06 165.18,37.87 164.87,37.56 161.56,37.56 161.36,37.36 160.35,37.36 159.15,38.57 158.11,38.57 153.42,43.26 153.42,43.64 152.63,44.43 152.63,46.92 152.03,47.52 152.03,60.48 150.05,62.46 150.05,74.51 148.22,76.35 148.22,82.94 145.61,85.55 145.61,85.78 v2(145.44,85.95)
  BOTTOM w0.076: 144.02,87.33 144,87.33 143.96,87.37 142.98,87.37 142.8,87.19 142.8,86.91 142.67,86.78 142.3,86.78 142.18,86.91 142.18,87.07 142.29,87.18 142.43,87.18 CPU1.B4
  BOTTOM w0.089: UH1.L29 165.06,38.48 v2(165.35,38.19)
  BOTTOM w0.127: 144.02,87.33 144.19,87.33 144.95,86.57 145.37,86.57 145.56,86.38 145.56,86.07 v2(145.44,85.95)
DMI_CTX_PRX_P0: length 67.6
  IN1 w0.104: v2(147.22,87.92) 147.02,87.73 147.02,87.61 147.16,87.47 149.24,87.47 150.44,86.27 150.44,78.69 153,76.13 153,70.16 152.29,69.45 152.29,68.11 154.23,66.17 154.23,48.27 155.42,47.07 155.42,45.85 158.32,42.95 158.32,42.6 159.61,41.31 164.02,41.31 165.05,40.28 165.05,39.76 165.35,39.46 v2(165.42,39.46)
  BOTTOM w0.076: CPU1.B8 142.93,89.52 142.93,89.58 143.2,89.85 143.52,89.85 143.7,90.03 144.32,90.03 144.56,89.79 144.73,89.79 144.76,89.82 145.22,89.82 145.22,89.82 145.28,89.82 145.31,89.84 145.31,89.84 145.31,89.84
  BOTTOM w0.089: v2(165.42,39.46) 165.82,39.87 UH1.N27
  BOTTOM w0.127: v2(147.22,87.92) 147.14,87.99 147.14,89.3 146.6,89.84 145.31,89.84
