# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C0_SCL_EC_R: length 5.2
  TOP w0.114: v1(32.08,22.19) 31.74,21.85 RA56.2 31.2,21.1 v2(31,21.3) 30.88,21.42 UA4.8
  BOTTOM w0.114: v2(31,21.3) 31.07,21.23 31.07,20.79 31.82,20.04 RA50.2
I2C0_SDA_EC: length 95.3
  TOP w0.114: UE5.84 93.47,22.28 93.42,22.33 93.42,23.04 93.67,23.28 v2(93.74,23.28) ; RA55.1 32.91,19.95 v2(33.86,19.95) 33.86,19.77 34.88,18.75 36.69,18.75 37.93,19.99 v2(38.11,19.99)
  IN2 w0.097: v2(38.11,19.99) 38.42,19.99 39.53,18.88 43.52,18.88 44.55,17.86 45.66,17.86 49.33,14.18 62.92,14.18 64.62,15.88 70.43,15.88 74.55,20 84.59,20 86.5,21.91 92.37,21.91 v2(93.74,23.28)
  IN4 w0.137: v2(31.2,36.5) 30.9,36.2 30.9,35.65 31.12,35.44 31.12,30.68 30.51,30.08 30.51,28.28 31.32,27.46 31.32,26.34 31.06,26.07 30.35,26.07 30.05,26.38 29.35,26.38 29.03,26.06 29.03,25.11 28.75,24.82 28.75,23.33 30.28,21.8 31.4,21.8 33.26,19.95 v2(33.86,19.95)
  BOTTOM w0.114: UA1.11 30.65,36.78 30.93,36.5 v2(31.2,36.5) ; v1(34.3,20.37) 33.89,19.95 v2(33.86,19.95)
I2C0_SDA_EC_R: length 4.9
  TOP w0.114: UA4.7 30.17,21.02 v2(30.31,20.89) 30.63,20.89 31.32,20.21 RA55.2 31.74,19.35 v1(31.95,19.14)
  BOTTOM w0.114: v2(30.31,20.89) 30.93,20.27 RA53.2
I2C_CLK: length 363
  TOP w0.114: v2(194,146.43) 193.83,146.59 193.44,146.59 191.54,148.5 188.64,148.5 188.06,149.07 186.79,149.07 186.3,149.57 186.3,149.97 186.17,150.09 UE3.25 ; RM97.1 143.12,167.35 140.13,167.35 139.38,168.1 139.38,168.95 v2(139.21,169.12) ; UE1.29 260.69,41.78 260.41,41.5 259.87,41.5 258.71,40.35 v2(257.57,40.35) 256.93,40.99 256.93,41.56 256.74,41.74 256.11,41.74 255.8,41.43 CE58.1 RE2.2
  IN2 w0.097: v2(194,146.43) 194.18,146.61 196.9,146.61 199.4,144.11 233.35,144.11 233.79,144.54 233.79,144.88 v2(233.97,145.06)
  IN4 w0.137: v2(257.57,40.35) 257.39,40.17 257.39,39.88 257.12,39.61 255.83,39.61 255.41,40.03 250.44,40.03 235.59,25.17 232.55,25.17 229.82,22.44 227.22,22.44 226.26,21.49 225.06,21.49 224.19,20.62 218.48,20.62 217.23,19.37 217.23,18.97 215.84,17.58 212.45,17.58 208,13.12 195.14,13.12 191.4,16.86 181.61,16.86 180.29,18.19 173.75,18.19 170.81,21.12 170.81,21.72 v2(170.64,21.89) ; v2(194,146.43) 193.79,146.64 193.7,146.64 192.62,147.72 190.56,147.72 188.66,145.81 179.8,145.81 178.76,146.85 178.76,151.16 178.51,151.41 178.51,154.2 177.22,155.49 177.22,160.17 173.25,164.14 169.13,164.14 167.39,165.89 160.48,165.89 159.64,166.73 155.2,166.73 154.4,167.53 153.35,167.53 151.33,165.51 144.08,165.51 141.22,168.36 139.68,168.36 139.4,168.64 139.4,168.93 v2(139.21,169.12)
  IN5 w0.097: v2(257.57,40.35) 257.36,40.55 257.36,43.6 256.49,44.47 256.49,59.15 258.14,60.79 258.14,67.78 256.01,69.91 251.95,69.91 249.86,72 249.86,86.35 246.08,90.13 246.08,131.15 233.79,143.44 233.79,144.88 v2(233.97,145.06)
  BOTTOM w0.114: v2(170.64,21.89) 171.1,21.43 UE4.25
I2C_CTL_EN: length 5.8
  BOTTOM w0.114: RV22.1 157.21,99.17 157.21,100.53 RV21.1 158.18,101.5 159.02,101.5 159.21,101.69 159.21,102.39 159.07,102.53 UV21.53
I2C_DAT: length 361
  TOP w0.114: UE1.30 260.69,40.98 260.41,41.26 259.97,41.26 258.66,39.96 258.66,39.27 258.54,39.14 258.36,39.14 258.23,39.27 258.23,39.78 258.1,39.9 257.38,39.9 v2(256.94,40.35) 256.69,40.35 RE1.2 ; UE3.26 186.41,150.59 186.54,150.46 186.54,149.67 186.89,149.31 188.16,149.31 188.74,148.74 191.64,148.74 193.54,146.83 193.82,146.83 v2(194,147.01) ; RM98.1 143.12,167.59 140.23,167.59 139.62,168.2 139.62,168.95 v2(139.79,169.12)
  IN2 w0.097: v2(194,147.01) 194.18,146.83 197,146.83 199.5,144.33 233.26,144.33 233.57,144.64 233.57,144.88 v2(233.39,145.06)
  IN4 w0.137: v2(256.94,40.35) 257.12,40.16 257.12,39.99 257.01,39.87 255.94,39.87 255.52,40.29 250.33,40.29 235.48,25.43 232.44,25.43 229.71,22.7 227.11,22.7 226.16,21.75 224.95,21.75 224.08,20.88 218.37,20.88 216.97,19.48 216.97,19.08 215.73,17.84 212.35,17.84 207.89,13.39 195.25,13.39 191.51,17.13 181.72,17.13 180.4,18.45 173.85,18.45 171.08,21.23 171.08,21.72 v2(171.25,21.89) ; v2(194,147.01) 193.89,146.9 193.81,146.9 192.73,147.98 190.45,147.98 188.55,146.07 179.91,146.07 179.02,146.96 179.02,151.27 178.78,151.52 178.78,154.31 177.48,155.6 177.48,160.28 173.35,164.41 169.24,164.41 167.5,166.15 160.59,166.15 159.75,166.99 155.31,166.99 154.51,167.79 153.24,167.79 151.22,165.77 144.19,165.77 141.33,168.63 139.79,168.63 139.66,168.75 139.66,168.99 v2(139.79,169.12)
  IN5 w0.097: v2(233.39,145.06) 233.57,144.88 233.57,143.35 245.85,131.06 245.85,90.04 249.63,86.26 249.63,71.91 251.86,69.68 255.92,69.68 257.92,67.68 257.92,60.89 256.27,59.24 256.27,44.38 257.14,43.51 257.14,40.55 v2(256.94,40.35)
  BOTTOM w0.114: UE4.26 171.6,21.54 v2(171.25,21.89)
I2CC_SCL: length 37.7
  IN1 w0.097: v2(185.92,69.75) 185.5,70.17 185.5,71.84 185.93,72.28 185.93,75.09 185.45,75.58 185.45,84.39 184.69,85.15 181.53,85.15 181.4,85.27 181.4,85.34 181.4,85.34 v2(181.4,85.65)
  IN2 w0.097: v2(198.58,74.06) 198.38,74.26 195.06,74.26 191.2,70.4 187.48,70.4 186.83,69.75 v2(185.92,69.75)
  BOTTOM w0.114: v2(185.92,69.75) 186.16,69.75 QG7.3 ; UG11.6 199.16,73.99 198.96,74.19 198.71,74.19 v2(198.58,74.06) 198.1,74.06 RG60.2 ; UG9.BG9 v2(181.4,85.65)
I2CC_SCL_R: length 1.4
  BOTTOM w0.114: RG12.2 v2(186.43,72.73) 186.5,72.66 QG7.4
I2CC_SDA: length 44.5
  IN1 w0.097: v2(180.8,85.62) 181.18,85.24 181.18,85.18 181.44,84.92 184.6,84.92 185.22,84.3 185.22,75.48 185.71,75 185.71,72.37 185.27,71.94 185.27,69.27 185.88,68.67 187.09,68.67 187.64,69.23 187.64,71.77 v2(188.36,72.48)
  IN2 w0.097: v2(188.36,72.48) 188.16,72.48 187.98,72.29 187.98,70.84 188.2,70.62 191.11,70.62 194.97,74.48 198.41,74.48 v2(198.58,74.64)
  BOTTOM w0.114: RG61.2 198.14,75.08 v2(198.58,74.64) 198.78,74.45 198.96,74.45 199.16,74.64 UG11.7 ; QG7.6 187.8,72.3 187.97,72.48 v2(188.36,72.48) ; v2(180.8,85.62) 181.1,85.32 UG9.BH9
I2CC_SDA_R: length 1.4
  BOTTOM w0.114: QG7.1 188.28,70.09 v2(188.38,69.99) 188.93,69.99 RG11.2
I2S_DATA_OUT: length 21.5
  TOP w0.114: v2(33.89,39.69) 33.89,40.45 RA33.2 ; v2(30.76,23.89) 30.77,23.89 30.77,23.88 30.16,23.88 30.11,23.82 UA4.14
  IN4 w0.137: v2(33.89,39.69) 35.02,38.56 35.02,36.12 33.69,34.78 33.35,34.78 32.85,34.28 32.85,34.14 32.22,33.51 32.22,28.65 32.38,28.49 32.38,25.79 31.79,25.19 31.79,24.39 31.28,23.89 v2(30.76,23.89)
  BOTTOM w0.114: v1(34.05,39.1) 33.89,39.26 v2(33.89,39.69)
I2S_DATA_OUT_R: length 4.6
  TOP w0.114: v2(30.95,39.1) 30.76,39.29 30.76,40.11 v1(30.82,40.18) 30.92,40.27 31.16,40.27 31.83,40.93 CA40.1 32.5,40.93 RA33.1
  BOTTOM w0.114: v2(30.95,39.1) 30.87,39.18 UA1.5
I2S_LRCK: length 26.3
  TOP w0.114: v2(31.11,23.43) 30.73,23.04 30.24,23.04 29.83,22.62 UA4.11
  IN4 w0.137: v2(31.11,23.43) 31.19,23.43 32.1,24.34 32.1,25.13 32.64,25.67 32.64,28.61 32.49,28.76 32.49,32.71 34.11,34.33 34.11,34.69 35.29,35.87 35.29,38.99 33,41.28 v2(33,42)
  BOTTOM w0.114: CA37.1 RA30.2 32.53,41.26 33,41.73 v2(33,42) ; v1(31.53,22.57) 31.53,23.01 v2(31.11,23.43)
I2S_LRCK_R: length 1.6
  BOTTOM w0.114: RA30.1 31.46,41.07 30.81,41.07 30.52,40.78 UA1.1
I2S_OUT: length 22.3
  TOP w0.114: UA4.12 29.82,23.02 30.25,23.46 v2(30.37,23.46)
  IN4 w0.137: v2(33.29,39.67) 34.76,38.2 34.76,36.23 33.67,35.14 33.34,35.14 32.59,34.39 32.59,34.32 31.96,33.69 31.96,28.47 32.12,28.31 32.12,25.94 30.34,24.17 30.34,23.49 v2(30.37,23.46)
  BOTTOM w0.114: v2(33.29,39.67) 33.46,39.84 CA36.1 RA31.2 ; v1(29.96,23.15) 30.27,23.46 v2(30.37,23.46)
I2S_OUT_R: length 1.6
  BOTTOM w0.114: UA1.3 30.86,39.98 31.15,40.27 31.55,40.27 RA31.1
I_SYS: length 113.9
  TOP w0.203: v2(59.21,37.86) PU700.9
  IN2 w0.254: v2(59.21,37.86) 57.96,39.1 57.96,47.62 v2(59.64,49.3)
  IN4 w0.254: v2(88.28,126.6) 87.26,126.6 86.12,125.46 86.12,91.72 83.64,89.24 83.64,83.33 78.06,77.75 75.01,77.75 67.64,70.38 67.64,65.37 67.51,65.24 67.51,63.14 66.99,62.62 66.99,58.46 67.23,58.22 67.23,57.78 66.5,57.05 64.17,57.05 62.87,55.75 58.4,55.75 57.93,55.27 57.93,50.39 59.02,49.3 v2(59.64,49.3)
  BOTTOM w0.254: v2(59.21,37.86) 59.06,37.71 59.06,37.24 PR728.2 ; v2(88.28,126.6) 88.35,126.53 v1(88.91,126.53) 89,126.53 89.33,126.86 PR526.1
IFPAB_RSET: length 1.1
  TOP w0.089: v2(184.2,94.75) 184.15,94.7 RG36.1
  BOTTOM w0.114: UG9.BD23 v2(184.2,94.75)
IFPCD_RSET: length 4.4
  TOP w0.114: v2(184.2,92.65) 183.71,93.14 v1(181.56,93.14) RG37.1
  BOTTOM w0.114: UG9.BD20 v2(184.2,92.65)
IFPEF_RSET: length 5.4
  TOP w0.1: RG38.1 180.43,89.94 180.43,90.6 180.75,90.92 v1(183.14,90.92) 183.83,90.92 v2(184.2,90.55)
  BOTTOM w0.114: UG9.BD17 v2(184.2,90.55)
IGPU_ENBKL: length 120.4
  TOP w0.114: v2(156.54,67.52) v1(157.1,67.52)
  IN1 w0.097: v2(169.73,35.44) 169.73,36.75 167.59,38.89 167.59,40.68 165.8,42.47 165.8,44.13 165.32,44.6 160.35,44.6 159.91,45.05 158.22,45.05 156.72,46.55 156.72,50.3 155.93,51.09 155.93,66.92 v2(156.54,67.52)
  IN2 w0.097: v2(156.54,67.52) 157.6,68.58 157.6,70.54 155.8,72.34 155.8,77.69 153.58,79.92 153.58,110.44 158.63,115.5 158.63,118.34 161.07,120.78 161.07,125.84 164.29,129.06 166.07,129.06 166.5,129.49 166.5,130.55 v2(166.03,131.03)
  BOTTOM w0.089: UH1.W35 169.37,35.8 v2(169.73,35.44)
  BOTTOM w0.114: v2(166.03,131.03) 167.09,131.03 168.33,132.27 UV22.10
IGPU_ENVDD: length 128.9
  IN1 w0.097: v2(169.74,31.85) 169.17,32.43 169.17,36.97 167.4,38.73 167.4,40.6 165.61,42.39 165.61,42.71 164.93,43.39 162.29,43.39 161.65,44.03 160.42,44.03 159.84,44.6
  IN1 w0.102: 159.84,44.6 158.38,44.6 156.52,46.47 156.52,50.22 155.73,51 155.73,69.14 154.39,70.48 154.39,76.71 151.58,79.52 151.58,105.7 153.2,107.32 153.2,109.79 157.64,114.22 160.1,114.22 161.41,115.54 161.41,118.91 159.97,120.35 159.97,134.14 158.83,135.28 v2(158.83,135.34)
  BOTTOM w0.089: UH1.W42 169.31,32.29 v2(169.74,31.85)
  BOTTOM w0.114: v2(158.83,135.34) v3(162.55,131.62) UV22.6
IGPU_INV_PWM: length 102.5
  TOP w0.114: v2(166,129.69) 167.46,128.23 167.46,118.39 164.67,115.59 164.67,106.83 162.63,104.79 162.63,101.87 v1(162.03,101.28) 161.3,100.54 161.3,89.81 165.08,86.03 165.08,76.97 165.92,76.13 165.92,68.4 v2(166.48,67.84)
  IN4 w0.089: v2(168.73,35.46) 167.97,36.22 167.97,38 167.78,38.19 167.78,44.73 167.94,44.89 167.94,54.86 167.63,55.17
  IN4 w0.137: 167.63,55.17 166.48,56.32 v2(166.48,67.84)
  BOTTOM w0.089: v2(168.73,35.46) 169.15,35.04 UH1.W36
  BOTTOM w0.114: v2(166,129.69) 165.98,129.67 UV22.3
IGPU_ROM_CS#: length 17.3
  TOP w0.114: v2(164.89,71.11) 164.38,71.11 v1(164.35,71.08)
  IN2 w0.097: v2(170.37,75.17) 170.89,74.65 170.89,73.18 170.38,72.67 170.07,72.67 168.51,71.11 v2(164.89,71.11)
  BOTTOM w0.114: UG15.1 167.08,70.06 166.49,69.47 164.82,69.47 164.53,69.76 RG147.2 164.53,70.75 v2(164.89,71.11) ; v2(170.37,75.17) 169.56,75.17 168.96,75.77 UG16.2
IGPU_ROM_SCLK: length 6.4
  BOTTOM w0.114: UG15.6 169.62,65.49 171.46,67.33 RG148.1 172.4,67.46 v1(173.22,68.27)
IGPU_ROM_SI: length 4.3
  BOTTOM w0.114: v1(172.4,65.05) RG149.1 171.34,66 170.89,65.56 UG15.5
IGPU_ROM_SO: length 10.3
  IN5 w0.097: v2(167.96,73) 167.78,72.82 v2(167.78,70.13)
  BOTTOM w0.114: RG146.1 164.59,67.83 165.5,68.73 v1(165.56,68.73) 166.38,68.73 v2(167.78,70.13) ; v2(167.96,73) 168.04,73.08 168.63,73.08 169.11,73.08 169.24,73.21 169.24,74 168.98,74.27 UG16.5
IGPU_ROM_SO_R: length 6.4
  BOTTOM w0.114: v1(165.62,66.7) 165.62,67.4 165.51,67.51 RG146.2 165.51,67.79 166.19,68.48 167.4,68.48 168.35,69.43 UG15.2
IMVP_VR_ON: length 201.4
  TOP w0.114: CE38.1 85.64,9.92 v2(85.76,10.04) 85.77,10.04 85.86,10.14 UE5.121 ; Q7.6 111.54,6.49 v3(109.34,8.68) 109.34,11.24 v2(110.38,12.28)
  IN1 w0.097: v2(85.76,10.04) 91.5,10.04 91.9,10.44 91.9,11.39 92.79,12.28 94.88,12.28 95.9,11.26 95.9,10.16 96.8,9.27 100.39,9.27 102.49,11.37 104.98,11.37 105.89,12.28 v2(110.38,12.28)
  IN5 w0.097: v2(88.28,125.77) 87.27,124.76 87.27,91.36 85.68,89.76 85.68,60.17 79.93,54.43 79.93,48.89 77.41,46.37 77.41,26.51 78.56,25.36 82.44,25.36 83.9,26.82 88.57,26.82 89.09,26.3 91.25,26.3 91.84,26.88 93.06,26.88 93.95,25.99 97.57,25.99 97.94,25.62 97.94,22.72 96.41,21.19 96.41,15.58 97.49,14.5 97.49,13.55 97.93,13.11 98.88,13.11 99.14,12.85 99.14,12.28 98.91,12.05 91.32,12.05 90.6,11.33 87.33,11.33 86.04,10.04 v2(85.76,10.04)
  BOTTOM w0.114: PR523.2 90.22,126.98 89.01,125.77 v2(88.28,125.77)
IN1_PEQ#: length 5.3
  BOTTOM w0.114: RV628.1 158.56,99.25 159.03,99.72 159.03,100.53 RV629.1 159.06,100.99 159.47,101.4 UV21.52
IN2_PEQ#: length 5.9
  BOTTOM w0.114: RV631.1 160.54,98.63 RV630.1 160.53,98.66 160.53,101.53 v1(160.18,101.88) 159.87,102.19 UV21.51
INV_PWM: length 75.6
  TOP w0.114: v2(121.1,160.92) JEDP.36 ; RV8.1 136.25,155.88 v2(136.82,155.88)
  IN2 w0.097: v2(136.82,155.88) 136.84,155.88 137.32,155.4 137.32,153.1 136.97,152.75 136.53,152.75 135.33,151.55 135.33,146.37 140.01,141.69 151.19,141.69 154.42,138.45 155.78,138.45 157.39,136.84 157.39,134.24 158.51,133.12 164.39,133.12 165.56,131.95 165.56,130.76 v2(166,130.32)
  IN3 w0.124: v2(121.1,160.92) 122.7,162.52 128.12,162.52 128.65,161.99 134.8,161.99 136.78,160.01 136.78,158.33 137.26,157.85 137.26,156.32 v2(136.82,155.88)
  BOTTOM w0.114: UV22.4 v2(166,130.32) ; v2(136.82,155.88) v1(137.34,155.88)
ISEN1_GT: length 42.7
  TOP w0.114: v2(114.76,125.27) v1(114.23,125.27)
  TOP w0.254: PR589.2 115.68,125.63 PR587.2 115.43,125.69 115.01,125.27 v2(114.76,125.27) ; PC528.2 88.89,134.47 89.29,134.47 89.29,134.48 v2(89.37,134.48)
  IN1 w0.254: v2(89.37,134.48) 88.79,134.48 87.9,133.58 87.9,132.32 89.1,131.12 89.1,130.43 89.37,130.16 89.37,128.2 89.57,128 97.15,128 99.3,130.16 103.58,130.16 105.1,128.63 105.1,126.28 106.63,124.76 114.25,124.76 v2(114.76,125.27)
  BOTTOM w0.203: PU500.9 89.63,134.22 v2(89.37,134.48)
ISEN1_VCORE: length 60.1
  TOP w0.114: v1(129.67,124.55) 129.93,124.81 v2(129.93,125.2)
  TOP w0.254: PC527.1 94.75,137.69 v2(94.75,137.39) ; v2(129.93,125.2) 130,125.2 130.52,125.73 PR558.2 131.55,124.85 PR560.2 130.68,124.83 PR561.2
  IN5 w0.254: v2(94.75,137.39) 94.5,137.65 94.5,138.09 95.39,138.98 98.69,138.98 99.64,138.03 100.57,138.03 104.61,133.99 104.61,124.52 109.83,119.3 125.42,119.3 129.93,123.81 v2(129.93,125.2)
  BOTTOM w0.203: v2(94.75,137.39) 94.75,137.2 94.53,136.97 PU500.21
ISEN2_GT: length 52.1
  TOP w0.114: v1(121.74,125.23) 122.16,125.65 v2(122.31,125.65)
  TOP w0.254: PR598.2 123.17,125.76 PR596.2 122.44,125.77 v2(122.31,125.65) ; v2(89.32,135.07) 88.7,135.07 PC525.2
  IN1 w0.254: v2(122.31,125.65) 122.19,125.65 120.86,124.32 106.43,124.32 104.72,126.03 104.72,128.31 103.33,129.71 100.28,129.71 98.18,127.62 89.45,127.62 89.02,128.05 89.02,130.01 88.75,130.28 88.75,130.97 87.26,132.45 87.26,133.84 88.49,135.07 v2(89.32,135.07)
  BOTTOM w0.203: PU500.10 89.91,134.62 89.46,135.07 v2(89.32,135.07)
ISEN2_VCORE: length 66.5
  TOP w0.114: v1(137.5,125.86) 137.59,125.77 v2(138.12,125.77)
  TOP w0.254: PC526.1 95.39,137.94 v2(95.39,137.46) ; v2(138.12,125.77) 138.88,125.77 PR568.2 139.01,125.8 139.01,125.02 PR571.2 PR570.2
  IN5 w0.254: v2(95.39,137.46) 96.41,138.47 97.8,138.47 99.26,137.01 101.05,137.01 104.25,133.81 104.25,124.35 109.68,118.92 125.62,118.92 128.22,121.52 135.46,121.52 136.22,122.28 136.22,124.63 137.36,125.77 v2(138.12,125.77)
  BOTTOM w0.203: PU500.22 94.93,136.8 95.39,137.27 v2(95.39,137.46)
ISEN3_VCORE: length 72.4
  TOP w0.254: PR581.2 PR580.2 146.63,125.72 PR578.2 v2(145.74,125.77)
  IN5 w0.254: v2(145.74,125.77) 142.7,122.73 142.7,121.5 142.32,121.12 138.7,121.12 138.34,120.76 128.66,120.76 126.06,118.15 109.11,118.15 103.48,123.78 103.48,133.43 100.98,135.93 98.28,135.93 97.06,137.15 v2(97.04,137.15)
  BOTTOM w0.203: v2(97.04,137.15) 96.92,137.27 v1(96.53,137.27) 95.9,137.27 95.33,136.7 PU500.23
  BOTTOM w0.254: v2(97.04,137.15) 97.08,137.2 PC524.1
ISENSEP_L: length 2.7
  TOP w0.203: UA4.25 24.51,25.94 RA58.2
  TOP w0.356: RA58.2 RA77.2
ISENSEP_L_R: length 15.4
  IN1 w1.016: 25.12,27.01 24.16,26.04 24.16,24.78 24.59,24.34 ; 24.59,17.55 24.4,17.36 24.4,14.95 25.84,13.51 26.96,13.51 28.72,15.26 29.81,15.26 31.06,14.01
  BOTTOM w0.127: 31.02,15.43 v1(30.1,15.43)
  vias: v2(24.79,28.02) v2(25.38,28.02) v2(32.08,14.33) v2(32.08,13.73)
ISENSEP_R: length 5.3
  TOP w0.203: UA4.28 23.31,25.18 23.08,25.41 v2(21.73,25.41) 21.73,25.67 21.49,25.91 21.2,25.91 20.69,26.41 RA63.2
  TOP w0.508: RA63.2 20.64,26.49 RA80.2
  BOTTOM w0.127: v2(21.73,25.41) v1(21.73,26.15)
ISENSEP_R_R: length 15.9
  TOP w0.127: v2(23.44,12.05) v1(23.44,11.32)
  IN1 w1.016: 23.7,13.51 22.11,15.09 22.11,16.47 22.87,17.23 22.87,25.46 21.29,27.05 21.26,27.05
  vias: v2(20.53,28.02) v2(21.16,28.02) v2(23.45,12.64)
ISUMN_GT: length 66.3
  TOP w0.254: v2(115.01,123.49) 115.01,123.42 115.14,123.3 116.41,123.3 116.65,123.54 PR588.1 ; v2(122.31,125.01) 122.18,124.87 122.18,123.68 v1(122.22,123.64) 122.44,123.42 123.65,123.42 124.13,123.9 PR597.1
  TOP w0.508: PC525.1 PC528.1 86.96,134.23 86.8,134.07 v2(86.8,133.98)
  IN1 w0.254: v2(122.25,120.55) 122.31,120.61 v2(122.31,125.01) 120.79,123.49 v2(115.01,123.49) 111.33,123.49 111.07,123.23 106.88,123.23 104.34,125.77 104.34,128 103.01,129.33 100.53,129.33 98.37,127.17 88.98,127.17 86.7,129.44 86.7,133.88 v2(86.8,133.98)
  BOTTOM w0.254: PH502.2 122.19,120.48 v2(122.25,120.55)
  BOTTOM w0.508: PR535.2 PC516.2 PC517.2 v2(86.8,133.98) 86.7,134.07 86.7,135.31 87.16,135.77 PR540.1 87.55,136.63 PR538.1 PC523.1
ISUMN_SA: length 83
  TOP w0.114: v2(98.26,128.43) v1(98.78,128.43)
  TOP w0.254: PC511.1 v2(98.26,128.43)
  IN2 w0.254: v2(98.26,128.43) 98.95,127.74 98.95,124.5 102.31,121.14 107.96,121.14 111.01,118.09 124.18,118.09 128.22,122.13 155.08,122.13 156.29,120.93 158.51,120.93 158.83,121.25 v2(158.83,121.69)
  BOTTOM w0.254: v2(158.83,121.69) 159.86,120.66 159.86,119.54 159.53,119.22 PH501.1 PR5027.1 ; v2(98.26,128.43) 98.27,128.44 100.15,128.44 100.72,129.01 100.72,130.07 100.18,130.61 PR528.1 100.14,130.62 PR524.2 PC512.1 PC510.1 PR529.1
ISUMN_VCORE: length 90.7
  TOP w0.254: PR559.1 v2(133.87,123.92) 134.26,123.54 139.39,123.54 PR569.1 v3(141.95,124.05) 142.76,123.23 146.89,123.23 147.57,123.92 PR579.1 ; v2(95.24,140.29) PC526.2 PC527.2 94.29,139.07 PC531.1 PC530.1 PR542.1
  IN5 w0.254: v2(133.87,123.92) 131.34,123.92 130.95,124.31 130.95,126.15 130.31,126.79 129.11,126.79 128.79,126.47 128.79,123.84 125.01,120.06 110.15,120.06 105.36,124.85 105.36,134.32 100.89,138.79 99.96,138.79 99.01,139.74 95.78,139.74 v2(95.24,140.29)
  BOTTOM w0.254: v2(133.87,123.92) 135.28,123.92 135.9,123.3 135.9,120.45 PH503.1 ; PR541.2 95.26,138.16 PR543.2 97.04,139.07 PC524.2 97.08,139.95 PC529.1 96.63,140.4 95.35,140.4 v2(95.24,140.29)
ISUMP_GT: length 63.9
  TOP w0.114: v2(121.74,126.41) v1(121.21,126.41)
  TOP w0.254: PR595.1 122.72,126.81 122.31,126.41 v2(121.74,126.41) ; v2(113.61,125.9) PR572.2 114.51,126.59 PR586.1 ; PR534.1 90.63,140.14 91.1,140.61 v2(91.45,140.61)
  IN1 w0.254: v2(121.74,126.41) 121.74,125.84 120.66,124.76 119.33,124.76 117.68,126.41 114.12,126.41 v2(113.61,125.9) 112.98,125.27 106.76,125.27 105.49,126.54 105.49,128.89 103.77,130.6 99.21,130.6 97.05,128.44 90.63,128.44 90.02,129.05 90.02,130.87 88.34,132.55 88.34,133.33 88.54,133.53 v2(89.04,133.53)
  IN2 w0.254: v2(89.04,133.53) 87.64,134.93 87.64,139.27 88.5,140.12 90.61,140.12 91.1,140.61 v2(91.45,140.61)
  BOTTOM w0.203: PU500.7 89.15,133.42 v2(89.04,133.53)
  BOTTOM w0.254: PR535.1 PC516.1 PC517.1 88.46,133.98 88.9,133.53 v2(89.04,133.53)
ISUMP_SA: length 80.7
  TOP w0.254: PR5003.2 158.19,122.58 v2(158.19,121.44)
  IN2 w0.254: v2(98.25,132.44) 97.42,131.62 97.42,130.61 99.42,128.61 99.42,124.66 102.56,121.52 108.15,121.52 111.09,118.58 123.92,118.58 127.85,122.52 155.4,122.52 156.48,121.44 v2(158.19,121.44)
  BOTTOM w0.203: v2(98.25,132.44) 98.07,132.62 PU500.32
  BOTTOM w0.254: PR529.2 PC510.2 PC512.2 98.32,132.37 v2(98.25,132.44) ; v2(158.19,121.44) v1(158.55,121.08) 159.31,120.32 PR530.2
ISUMP_VCORE: length 84.9
  TOP w0.114: v2(129.36,125.58) v1(128.8,125.58)
  TOP w0.254: PR567.1 138.44,126.41 v2(138.12,126.41) ; v2(129.36,125.58) 129.49,125.71 129.57,125.71 PR562.2 130.33,126.47 130.58,126.47 PR557.1 ; PR577.1 146.25,126.91 v2(145.74,126.41) ; v2(93.74,137.52) 93.74,137.62 PC531.2 PC530.2 PR542.2 PR544.2
  IN5 w0.254: v2(93.74,137.52) 94.12,137.9 94.12,138.25 95.23,139.36 98.85,139.36 99.8,138.41 100.73,138.41 104.99,134.14 104.99,124.68 109.99,119.68 125.17,119.68 129.36,123.87 v2(129.36,125.58) 129.49,125.71 130.25,125.71 130.57,125.39 130.57,123.93 131.27,123.23 134.19,123.23 137.36,126.41 v2(138.12,126.41) 138.38,126.41 140.41,124.38 143.46,124.38 145.49,126.41 v2(145.74,126.41)
  BOTTOM w0.203: v2(93.74,137.52) 93.73,137.51 PU500.19
IVSENSE_L: length 2.5
  TOP w0.203: RA59.2 24.11,26.41 UA4.26
  TOP w0.356: RA59.2 RA78.2
IVSENSE_R: length 3.4
  TOP w0.203: v2(21.69,24.5) 21.69,24.08 21.95,23.82 UA4.29
  TOP w0.457: v2(21.69,24.5) RA64.2 RA81.2
  BOTTOM w0.127: v1(20.99,24.5) v2(21.69,24.5)
JKSI0: length 42.1
  TOP w0.114: v2(137.09,5.09) 137.11,5.11 137.11,6.56 136.86,6.82 RE471.1 ; v3(165.78,5.74) 165.95,5.91 v2(165.95,6.27)
  IN2 w0.097: v2(165.95,6.27) 165.94,6.29 165.94,7.45 165.18,8.22 163.15,8.22 160.61,10.76 155.53,10.76 151.33,6.56 140.67,6.56 139.65,5.55 137.55,5.55 v2(137.09,5.09)
  BOTTOM w0.114: JKB.30 167,7.32 v2(165.95,6.27)
JKSI1: length 48.4
  TOP w0.114: v2(166.64,6.25) 166.08,6.8 v3(166.08,7.44) ; RE474.1 134.82,1.8 134.6,2.02 134.6,4.35 134.48,4.47 v2(134.47,4.47)
  IN5 w0.097: v2(134.47,4.47) 134.12,4.82 134.12,5.73 135.37,6.97 152.93,6.97 156.8,10.84 159.65,10.84 164.69,5.8 166.19,5.8 v2(166.64,6.25)
  BOTTOM w0.114: JKB.29 167.5,7.11 v2(166.64,6.25)
JKSI2: length 47.1
  TOP w0.114: v2(167.25,6.25) 167.25,4.93 v3(167.3,4.88) ; RE466.1 134.38,6.82 134.54,6.66 134.54,5.21 134.5,5.18 v2(134.5,5.06)
  IN2 w0.097: v2(167.25,6.25) 167.27,6.27 167.27,7.52 166.32,8.47 163.25,8.47 160.71,11.01 155.42,11.01 151.23,6.82 140.56,6.82 139.55,5.8 135.25,5.8 v2(134.5,5.06)
  BOTTOM w0.114: v2(167.25,6.25) 167.72,6.72 167.72,10.65 168,10.94 JKB.28
JKSI3: length 47.9
  TOP w0.114: v2(168.19,9.51) 168.21,9.51 168.42,9.71 168.42,9.77 v3(169.03,10.39) ; RE467.1 132.16,1.87 132,2.02 132,4.35 v2(131.87,4.47)
  IN2 w0.097: v2(168.19,9.51) 168.19,9.26 167.91,8.98 163.46,8.98 160.92,11.52 155.21,11.52 151.02,7.33 140.35,7.33 139.33,6.31 134.7,6.31 133.87,5.49 131.84,5.49 131.59,5.23 131.59,4.91 131.87,4.63 v2(131.87,4.47)
  BOTTOM w0.114: v2(168.19,9.51) 168.19,10.27 168.5,10.59 JKB.27
JKSI4: length 32.2
  TOP w0.114: RE461.1 147.44,6.82 148.29,5.97 v3(148.29,5.59) v2(148.29,5.02)
  IN1 w0.097: v2(168.04,6.25) 167.91,6.12 167.91,6.06 167.46,5.61 164.23,5.61 159.59,10.25 153.94,10.25 148.71,5.02 v2(148.29,5.02)
  BOTTOM w0.114: v2(168.04,6.25) 168.65,6.86 168.65,10.13 169,10.49 JKB.26
JKSI5: length 33.5
  TOP w0.114: v2(169.05,9.55) 169.05,9.49 169.69,8.85 v3(169.88,8.85) ; v2(145.3,4.53) 145.02,4.25 145.02,2.02 145.18,1.87 RE460.1
  IN3 w0.124: v2(169.05,9.55) 168.48,8.98 161.69,8.98 160.61,10.06 155.84,10.06 151.59,5.8 146.06,5.8 145.3,5.04 v2(145.3,4.53)
  BOTTOM w0.114: v2(169.05,9.55) 169.05,10.04 169.5,10.49 JKB.25
JKSI6: length 41.9
  TOP w0.114: RE455.1 145.02,6.44 145.02,5.16 144.72,4.86 v2(144.72,4.51) ; v3(167.86,7.38) 167.86,7.1 168.67,6.29 v2(168.67,6.25)
  IN3 w0.124: v2(168.67,6.25) 168.67,7.77 169.5,8.6 169.5,9.74 169.24,9.99 161.81,9.99 161.05,10.76 156.03,10.76 151.53,6.25 145.87,6.25 144.72,5.09 v2(144.72,4.51)
  BOTTOM w0.114: v2(168.67,6.25) 169.52,7.1 169.52,10.11 170,10.59 JKB.24
JKSI7: length 48.8
  TOP w0.114: v2(170.79,9.52) 170.96,9.36 170.96,9.26 v3(171.74,8.47) ; v2(142.22,4.51) 142.48,4.25 142.48,2.09 142.7,1.87 RE454.1
  IN2 w0.097: v2(142.22,4.51) 142.22,4.57 141.81,4.98 141.81,5.8 142.06,6.06 151.53,6.06 155.65,10.18 160.35,10.18 163.78,6.76 163.78,6.5 164.86,5.42 173.05,5.42 173.62,5.99 173.62,6.69 v2(170.79,9.52)
  BOTTOM w0.114: v2(170.79,9.52) 170.5,9.82 JKB.23
JKSI8: length 52
  TOP w0.114: v2(169.27,6.25) 169.27,5.78 v3(168.94,5.45) ; v2(132.03,5.04) 131.9,5.17 131.9,6.69 131.78,6.82 131.59,6.82 RE396.1
  IN2 w0.097: v2(132.03,5.04) 132.23,5.23 134,5.23 134.82,6.06 139.44,6.06 140.46,7.07 151.12,7.07 155.32,11.26 160.82,11.26 163.36,8.72 168.04,8.72 169.27,7.49 v2(169.27,6.25)
  BOTTOM w0.114: v2(169.27,6.25) 171.19,8.17 171.19,9.75 171,9.94 JKB.22
JKSI9: length 53.4
  TOP w0.114: v2(129.15,4.47) 129.15,3.67 129.33,3.49 129.33,2.02 129.49,1.87 RE399.1 ; v3(171.2,10.13) 171.2,10.01 v2(171.59,9.61)
  IN2 w0.097: v2(129.15,4.47) 129.15,4.56 128.86,4.86 128.86,4.87 128.73,5 128.73,5.29 128.98,5.55 130.82,5.55 131.27,5.99 133.62,5.99 134.44,6.82 139.08,6.82 140.22,7.96 149.87,7.96 153.94,12.03 161.24,12.03 163.14,10.13 171.08,10.13 v2(171.59,9.61)
  BOTTOM w0.114: JKB.21 171.5,9.7 v2(171.59,9.61)
JKSI10: length 66.6
  TOP w0.114: v2(126.51,15.39) 126.41,15.49 126.41,18.12 126.28,18.25 RE476.1 ; v3(169.57,7.1) 169.57,7.02 170.26,6.34 v2(170.26,6.25)
  IN5 w0.097: v2(170.26,6.25) 170.26,6.5 169.94,6.82 163.97,6.82 159.72,11.07 156.73,11.07 152.92,7.26 126.51,7.26 125.81,7.96 125.81,14.68 v2(126.51,15.39)
  BOTTOM w0.114: v2(170.26,6.25) 172,7.99 JKB.20
JKSI11: length 55.2
  TOP w0.114: RE480.1 123.98,13.09 123.98,11.81 v2(123.76,11.59) 123.76,11.43 124.25,10.95 124.25,10.21 v3(123.59,9.55)
  BOTTOM w0.114: JKB.19 172.5,12.18 172.25,12.43 166.82,12.43 165.61,11.23 161.79,11.23 160.57,12.44 133.78,12.44 133.11,11.77 123.94,11.77 v2(123.76,11.59)
JKSI12: length 43.3
  TOP w0.114: v3(170.68,5.16) 171.34,5.82 v2(171.34,6.12) ; RE482.1 142.4,6.42 142.4,5.23 v2(142.34,5.17)
  IN5 w0.097: v2(171.34,6.12) 170.32,5.1 164.54,5.1 159.46,10.18 157.3,10.18 153.24,6.12 142.57,6.12 142.34,5.89 v2(142.34,5.17)
  BOTTOM w0.114: v2(171.34,6.12) 171.34,6.69 172.26,7.62 172.26,10.16 173,10.89 JKB.18
JKSI13: length 48.7
  TOP w0.114: v2(171.93,6.18) 171.88,6.18 v3(171.29,6.77) ; RE486.1 140.03,1.8 139.87,1.96 139.87,4.24 139.63,4.48 v2(139.63,4.51)
  IN5 w0.097: v2(171.93,6.18) 171.55,6.56 171.15,6.56 170.89,6.31 170.89,5.99 170.24,5.34 164.59,5.34 159.48,10.45 156.97,10.45 153.09,6.57 140.48,6.57 139.33,5.42 139.33,4.85 139.63,4.55 v2(139.63,4.51)
  BOTTOM w0.114: JKB.17 173.5,10.95 172.49,9.94 172.49,6.74 v2(171.93,6.18)
JKSI14: length 58.4
  TOP w0.114: v2(129.21,5.05) 129.27,5.11 129.27,6.44 128.96,6.76 RE488.1 ; v3(172.42,5.27) 172.54,5.39 v2(172.54,6.12)
  IN2 w0.097: v2(172.54,6.12) 172.54,6.88 170.37,9.04 170.37,9.69 170.13,9.93 162.96,9.93 161.11,11.77 155.02,11.77 150.89,7.64 140.29,7.64 139.21,6.56 134.57,6.56 133.75,5.74 131.4,5.74 130.71,5.05 v2(129.21,5.05)
  BOTTOM w0.114: v2(172.54,6.12) 172.71,6.29 172.71,9.85 173.37,10.51 173.74,10.51 174,10.78 JKB.16
JKSI15: length 58.4
  TOP w0.114: v2(126.63,4.53) 126.63,3.39 126.73,3.29 126.73,2.09 126.95,1.87 RE492.1 ; v2(173.2,9.12) 173.66,8.66 v3(173.66,8.52)
  IN2 w0.097: v2(173.2,9.12) 172.21,9.12 172.04,9.3 172.04,10.16 171.87,10.33 163.32,10.33 161.37,12.28 153.75,12.28 150.64,9.17 140.86,9.17 138.76,7.07 134.32,7.07 133.49,6.25 131.14,6.25 130.76,5.87 127.9,5.87 126.63,4.6 v2(126.63,4.53)
  BOTTOM w0.114: v2(173.2,9.12) 173.61,9.52 173.61,10.06 174.5,10.95 JKB.15
JKSI16: length 47
  TOP w0.114: v2(139.72,5.13) 139.77,5.19 139.77,6.63 139.59,6.82 RE495.1 ; v2(173.12,6.12) 173.12,6.81 v3(173.05,6.88)
  IN2 w0.097: v2(173.12,6.12) 172.68,5.68 165.05,5.68 164.1,6.63 164.1,6.82 160.42,10.5 155.65,10.5 151.46,6.31 140.79,6.31 139.72,5.23 v2(139.72,5.13)
  BOTTOM w0.114: v2(173.12,6.12) 174.41,7.41 174.41,10.07 175,10.66 JKB.14
JKSI17: length 54.4
  TOP w0.114: v2(174.13,6.12) 174.13,5.31 v3(174.16,5.28) ; RE498.1 137.43,1.87 137.27,2.02 137.27,4.33 v2(137.13,4.47)
  IN5 w0.097: v2(137.13,4.47) 136.54,5.06 136.54,5.99 137.32,6.77 153.01,6.77 156.89,10.64 159.56,10.64 164.66,5.55 170.13,5.55 170.64,6.06 170.64,6.69 170.77,6.82 171.82,6.82 172.13,6.51 173.75,6.51 v2(174.13,6.12)
  BOTTOM w0.114: JKB.13 175.5,10.59 174.7,9.79 174.7,6.69 v2(174.13,6.12)
JKSI18: length 65
  TOP w0.114: RE502.1 126.5,6.76 126.63,6.63 v2(126.63,5.17) ; v3(174.8,6.91) 174.72,6.82 v2(174.72,6.12)
  IN2 w0.097: v2(126.63,5.17) 126.63,5.73 127.08,6.18 130.63,6.18 130.95,6.5 133.36,6.5 134.19,7.33 138.63,7.33 140.79,9.49 150.58,9.49 153.65,12.56 161.47,12.56 163.5,10.52 173.92,10.52 174.45,9.99 174.45,6.39 v2(174.72,6.12)
  BOTTOM w0.114: v2(174.72,6.12) 174.92,6.32 174.92,9.58 176,10.66 JKB.12
JKSI19: length 63.5
  TOP w0.114: v3(174.89,9.36) 174.93,9.36 175.3,8.99 v2(175.35,8.99) ; RE503.1 124.35,1.87 124.13,2.09 124.13,4.37 124,4.49 v2(123.96,4.49)
  IN2 w0.097: v2(175.35,8.99) 174.84,9.5 174.84,10.18 174.3,10.72 163.64,10.72 161.57,12.79 153.56,12.79 151.21,10.44 141.37,10.44 138.51,7.58 134.06,7.58 133.24,6.76 130.82,6.76 130.57,6.5 126,6.5 123.99,4.49 v2(123.96,4.49)
  BOTTOM w0.114: JKB.11 176.5,10.79 175.35,9.64 v2(175.35,8.99)
JKSI20: length 69.3
  TOP w0.114: RE507.1 124.02,6.43 124.02,5.1 124.01,5.08 v2(124.01,5.08) ; v2(175.33,6.12) 175.33,5.98 v3(175.9,5.41)
  IN2 w0.097: v2(124.01,5.08) 125.68,6.76 130.38,6.76 130.63,7.01 133.11,7.01 133.94,7.83 138.13,7.83 140.98,10.69 151.02,10.69 153.37,13.04 161.69,13.04 163.81,10.92 174.79,10.92 175.73,9.99 175.73,6.52 v2(175.33,6.12)
  BOTTOM w0.114: JKB.10 177,10.86 175.83,9.69 175.83,6.63 v2(175.33,6.12)
JKSI21: length 68.5
  TOP w0.114: v2(176.23,8.92) v3(176.82,8.92) ; RE510.1 121.3,1.87 121.17,1.99 v2(121.17,4.53)
  IN2 w0.097: v2(121.17,4.53) 122.19,5.55 123.84,5.55 125.3,7.01 130.13,7.01 130.38,7.26 132.98,7.26 133.81,8.09 137.94,8.09 140.79,10.95 150.89,10.95 153.24,13.3 161.88,13.3 164.03,11.14 175.66,11.14 176.23,10.57 v2(176.23,8.92)
  BOTTOM w0.114: v2(176.23,8.92) 176.23,9.59 177.5,10.86 JKB.9
JKSO0: length 66.3
  TOP w0.114: v3(176.61,7.02) 176.54,6.96 v2(176.54,6.06) ; QE49.6 124.71,10.58 125.55,9.74 127.08,9.74 v2(127.2,9.87) 127.32,9.98 QE54.6
  IN5 w0.097: v2(127.2,9.87) 127.2,8.22 127.9,7.52 152.69,7.52 156.5,11.33 159.78,11.33 164.07,7.03 171.88,7.03 172.22,6.7 173.99,6.7 174.2,6.5 176.17,6.5 176.54,6.12 v2(176.54,6.06)
  BOTTOM w0.114: JKB.8 178,10.87 176.61,9.48 176.61,8.47 176.54,8.4 v2(176.54,6.06)
JKSO1: length 65.3
  TOP w0.114: QE50.6 129.98,10.39 130.25,10.12 131.29,10.12 131.98,9.44 132.05,9.44 132.66,8.83 132.66,8.38 v2(132.21,7.93) 132.01,7.73 128.9,7.73 128.62,8.01 QE54.3 ; v2(177.34,6.12) 177.34,5.72 v3(177.65,5.41)
  IN5 w0.097: v2(132.21,7.93) 132.37,7.77 152.67,7.77 156.52,11.63 159.8,11.63 164.16,7.26 171.94,7.26 172.3,6.9 174.07,6.9 174.28,6.7 176.77,6.7 v2(177.34,6.12)
  BOTTOM w0.114: v2(177.34,6.12) 177.34,9.71 178.5,10.87 JKB.7
JKSO2: length 65.4
  TOP w0.114: QE51.6 132.78,16.28 133.29,15.77 v2(134.44,15.77) 134.7,16.03 135.4,16.03 135.64,16.27 QE55.6 ; v3(178.35,7.04) 177.93,6.62 v2(177.93,6.14)
  IN5 w0.097: v2(177.93,6.14) 177.93,5.94 178.2,5.68 179.21,5.68 179.53,5.99 179.53,6.37 178.81,7.09 174.44,7.09 174.24,7.3 172.46,7.3 171.99,7.77 165.19,7.77 160.68,12.28 151.33,12.28 149.88,10.82 137.23,10.82 134.44,13.61 v2(134.44,15.77)
  BOTTOM w0.114: v2(177.93,6.14) 177.65,6.42 177.65,9.49 179,10.84 JKB.6
JKSO3: length 75
  TOP w0.114: QE52.6 139.06,16.17 139.21,16.03 139.96,16.03 140.86,15.13 v3(140.86,10.95) 140.16,10.25 v2(139.02,10.25) 137.81,10.25 136.94,11.12 QE55.3
  IN3 w0.124: v2(139.02,10.25) 141.68,12.91 145.57,12.91 146.66,14.01 150.14,14.01 150.89,14.76 158.45,14.76 161.75,11.45 174.78,11.45 176.43,13.11 180.1,13.11 180.8,12.41 180.8,9.78 178.53,7.51 v2(178.53,6.06)
  BOTTOM w0.114: JKB.5 179.5,10.71 178.08,9.3 178.08,7.02 178.53,6.57 v2(178.53,6.06)
JKSO4: length 66.2
  TOP w0.114: QE53.6 129.62,16.13 129.31,15.82 v2(129.22,15.82) 127.42,15.82 127.06,16.17 QE56.6 ; v2(179.11,6.12) 179.11,5.88 v3(179.39,5.6)
  IN5 w0.097: v2(179.11,6.12) 178.34,6.9 174.36,6.9 174.16,7.1 172.38,7.1 171.96,7.52 164.23,7.52 159.91,11.84 151.27,11.84 150.06,10.63 137.11,10.63 133.05,14.69 130.35,14.69 v2(129.22,15.82)
  BOTTOM w0.114: v2(179.11,6.12) 179.11,6.56 178.37,7.3 178.37,9.04 180,10.67 JKB.4
JRTC1: length 4.5
  TOP w0.114: PD5.2 259.18,56.58 v1(259.92,55.84)
  TOP w0.254: PR2.1 256.82,55.84 258.21,55.84 258.66,56.3 PD5.2
JTAG_TCLK: length 4.3
  BOTTOM w0.114: T10.1 177.22,94.83 177.34,94.94 177.34,95.62 178.02,96.3 178.63,96.3 178.84,96.09 179.13,96.09 179.47,95.75 UG9.BK24
JTAG_TDI: length 2.3
  BOTTOM w0.114: UG9.BM23 178.3,94.87 176.93,93.5 T12.1
JTAG_TDO: length 5.8
  BOTTOM w0.114: UG9.BM24 177.88,95.33 177.88,94.81 176.93,93.85 176.14,93.85 175.72,93.43 174.45,93.43 174.19,93.18 T13.1
JTAG_TMS: length 4.6
  BOTTOM w0.114: UG9.BL23 178.83,95.05 176.47,92.68 175.9,92.68 T11.1
JTAG_TRST#: length 7.3
  BOTTOM w0.114: v3(173.62,94.26) 173.85,94.03 174.69,94.03 RG518.1 174.73,93.81 174.86,93.69 175.66,93.69 176.04,94.07 176.8,94.07 177.62,94.89 177.62,95.46 177.98,95.82 177.98,95.88 178.17,96.07 178.23,96.07 178.24,96.08 178.53,96.08 178.86,95.75 UG9.BL24
KB_LED_B1_DRV#: length 34.6
  TOP w0.114: v2(189.05,8.06) 189.04,8.06 v3(188.56,7.58)
  IN2 w0.097: v2(176.91,16.79) 177.89,15.8 182.35,15.8 185.12,13.04 185.12,7.68 185.48,7.31 188.3,7.31 v2(189.05,8.06)
  BOTTOM w0.114: v2(189.05,8.06) 189.05,7.16 189.87,6.34 194.14,6.34 196.35,8.55 JKBBL.5 ; v2(176.91,16.79) 175.96,17.74 UE4.5
KB_LED_B2_DRV#: length 47.9
  TOP w0.114: v2(165.44,12.51) 165.48,12.47 166.13,12.47 v3(166.58,12.92)
  IN1 w0.097: v2(190.99,7.81) 190.98,7.82 190.98,8.28 189.6,9.66 180.16,9.66 179.94,9.88 174.98,9.88 173.68,11.18 166.77,11.18 v2(165.44,12.51)
  BOTTOM w0.114: UE4.9 174.6,14.84 173.18,13.42 166.1,13.42 165.44,12.76 v2(165.44,12.51) ; v2(190.99,7.81) 190.99,7.57 191.53,7.03 193.22,7.03 194.85,8.65 JKBBL.8
KB_LED_B3_DRV#: length 44.6
  TOP w0.114: v2(163.79,13.73) v3(163.79,12.72)
  IN1 w0.097: v2(163.79,13.73) 165.21,13.73 167.36,11.58 174.13,11.58 175.2,10.5 180.23,10.5 180.64,10.09 189.77,10.09 191.46,8.4 v2(191.56,8.4)
  BOTTOM w0.114: v2(163.79,13.73) 164.14,14.07 171.45,14.07 172.1,14.72 UE4.14 ; v2(191.56,8.4) 191.56,8.41 192.05,8.41 193.35,9.71 JKBBL.11
KB_LED_B4_DRV#: length 38.1
  TOP w0.114: v2(169.42,16.88) 168.78,16.24 v3(168.78,14.3)
  IN2 w0.097: v2(189.96,8.77) 189.96,7.96 189.85,7.85 189.85,7.31 189.07,6.53 185.53,6.53 184.72,7.34 184.72,12.88 183.67,13.93 172.37,13.93 v2(169.42,16.88)
  BOTTOM w0.114: v2(189.96,8.77) 190.47,9.28 191.27,9.28 191.85,9.86 JKBBL.14 ; UE4.17 169.64,16.24 169.42,16.46 v2(169.42,16.88)
KB_LED_G1_DRV#: length 36.1
  TOP w0.114: v2(178.95,17.7) v3(178.95,16.43)
  IN2 w0.097: v2(189.09,8.74) 189.1,8.74 189.1,10.87 186.04,13.93 186.04,15.22 183.96,17.3 179.35,17.3 v2(178.95,17.7)
  BOTTOM w0.114: v2(178.95,17.7) 178.5,17.25 178.09,17.25 177.66,17.68 176.58,17.68 176.02,18.24 UE4.4 ; JKBBL.4 196.85,8.38 194.6,6.13 189.65,6.13 188.37,7.4 188.37,8.02 v2(189.09,8.74)
KB_LED_G2_DRV#: length 32.2
  TOP w0.114: v2(179.53,17.7) v3(179.53,18.39)
  IN2 w0.097: v2(179.53,17.7) 179.7,17.52 184.01,17.52 186.24,15.3 186.24,14.01 189.47,10.77 189.47,8.42 v2(189.58,8.31)
  BOTTOM w0.114: JKBBL.7 195.35,8.45 193.71,6.81 190.27,6.81 189.84,7.24 189.84,8.05 v2(189.58,8.31) ; v2(179.53,17.7) 178.69,16.85 177.7,16.85 177.08,16.24 UE4.8
KB_LED_G3_DRV#: length 46.6
  TOP w0.114: v3(192.9,8) 192.5,8 v2(192.13,7.63)
  IN1 w0.097: v2(164.22,13.33) 165.21,13.33 167.16,11.38 173.76,11.38 175.03,10.11 180.03,10.11 180.28,9.86 189.69,9.86 191.18,8.37 191.18,8.15 191.31,8.03 191.73,8.03 v2(192.13,7.63)
  BOTTOM w0.114: v2(192.13,7.63) 193.85,9.35 JKBBL.10 ; UE4.11 173.6,14.77 172.68,13.86 164.75,13.86 v2(164.22,13.33)
KB_LED_G4_DRV#: length 50.4
  TOP w0.114: v2(162.94,14.52) v3(163.54,15.12)
  IN2 w0.097: v2(190.23,7.69) 190.23,7.36 189.1,6.23 184.77,6.23 184.52,6.47 184.52,12.79 183.64,13.68 164.91,13.68 164.07,14.52 v2(162.94,14.52)
  BOTTOM w0.114: JKBBL.13 192.35,9.81 191.59,9.05 190.82,9.05 190.15,8.39 190.15,7.77 v2(190.23,7.69) ; UE4.16 171.1,14.65 170.97,14.52 v2(162.94,14.52)
KB_LED_R1_DRV#: length 36.4
  TOP w0.114: v3(177.61,18.09) 178,17.7 v2(178.36,17.7)
  IN2 w0.097: v2(188.49,8.68) 188.9,9.09 188.9,10.79 185.84,13.84 185.84,15.14 183.94,17.04 179.02,17.04 v2(178.36,17.7)
  BOTTOM w0.114: v2(178.36,17.7) 178.07,17.99 176.71,17.99 175.97,18.74 UE4.3 ; v2(188.49,8.68) 188.16,8.35 188.16,7.24 189.49,5.91 194.96,5.91 197.35,8.29 JKBBL.3
KB_LED_R2_DRV#: length 33.8
  TOP w0.114: v2(176.31,16.79) 175.8,16.28 v3(175.66,16.28)
  IN2 w0.097: v2(176.31,16.79) 176.31,16.67 178.22,14.76 183.12,14.76 184.92,12.96 184.92,7.46 185.36,7.02 188.85,7.02 v2(189.46,7.63)
  BOTTOM w0.114: v2(176.31,16.79) 176.31,16.88 175.96,17.24 UE4.6 ; v2(189.46,7.63) 189.46,7.17 190.06,6.56 193.89,6.56 195.85,8.52 JKBBL.6
KB_LED_R3_DRV#: length 51.9
  TOP w0.114: v2(191.54,7.62) v3(191.54,6.82)
  IN2 w0.097: v2(191.54,7.62) 189.75,5.83 184.6,5.83 184.13,6.31 184.13,11.65 182.6,13.17 164.89,13.17 v2(164.66,12.94)
  BOTTOM w0.114: v2(164.66,12.94) 165.36,13.64 172.91,13.64 174.1,14.83 UE4.10 ; v2(191.54,7.62) 191.92,7.24 192.79,7.24 194.35,8.8 JKBBL.9
KB_LED_R4_DRV#: length 49.9
  TOP w0.114: v2(190.54,8.19) 190.54,8.69 v3(190.69,8.84)
  IN2 w0.097: v2(190.54,8.19) 190.61,8.12 190.61,7.45 189.19,6.03 184.68,6.03 184.33,6.39 184.33,11.73 182.63,13.42 164.8,13.42 164.11,14.11 v2(163.35,14.11)
  BOTTOM w0.114: v2(163.35,14.11) 163.54,14.3 171.28,14.3 171.6,14.62 UE4.15 ; JKBBL.12 192.85,9.73 191.92,8.79 191.14,8.79 v2(190.54,8.19)
KB_RST#: length 120.6
  TOP w0.089: RH518.1 174.38,44.91 v1(175.34,44.91) 176.96,44.91 177.09,45.04 v2(177.09,45.15)
  TOP w0.114: v2(91.36,14.88) 91.23,14.75 91.23,12.06 90.78,11.61 90.78,9.97 90.65,9.85 90.65,8.5 89.42,7.26 88.72,7.26 87.68,6.22 87.68,3.42 88.13,2.97 RE646.2
  IN2 w0.097: v2(177.09,45.15) 177.09,45.04 176.4,44.35 174.81,44.35 174.48,44.03 173.55,44.03 172.53,43.01 172.53,42.75 172.22,42.44 167.84,42.44 167.53,42.12 161.6,42.12 160.71,41.24 160.71,41.09 159.8,40.18 158.53,40.18 156.02,37.67 156.02,35.57 155.48,35.04 155.48,33.66 151.7,29.87 147.91,29.87 144.47,26.44 143.39,26.44 141.43,24.48 137.79,24.48 136.8,23.49 116.91,23.49 113.83,20.41 112.76,20.41 111.2,18.84 107.89,18.84 107.6,18.55 102.33,18.55 101.65,17.87 92.8,17.87 91.65,16.71 91.65,15.17 v2(91.36,14.88)
  BOTTOM w0.089: UH1.AT17 177.6,44.64 v2(177.09,45.15)
KSI0: length 43.6
  TOP w0.114: RE469.2 136.18,2.78 136.53,3.12 QE42.3 136.53,3.47 136.03,3.96 136.03,4.28 v2(135.84,4.47) ; v2(105.47,13.73) 105.47,13.88 106.17,14.58 106.17,15.73 105.76,16.14 v1(105.07,16.14) UE5.55
  IN4 w0.137: v2(135.84,4.47) 135.84,5.57 134.51,6.9 131.99,6.9 130.67,8.22 124.73,8.22 123.27,9.68 113.54,9.68 108.97,14.25 105.99,14.25 v2(105.47,13.73)
KSI1: length 44.3
  TOP w0.114: v2(135.09,4.59) 135.09,4.74 135.23,4.87 QE42.6 135.23,5.7 135.51,5.98 RE470.2 ; UE5.56 105.72,16.54 106.47,15.79 106.47,14.05 v1(106.47,14.05) 106.47,14.02 v2(106.12,13.68)
  IN4 w0.137: v2(135.09,4.59) 135.09,5.98 134.41,6.66 131.89,6.66 130.59,7.96 124.54,7.96 123.06,9.44 115.46,9.44 114.2,8.18 109.15,8.18 107.59,9.73 107.59,12.53 106.44,13.68 v2(106.12,13.68)
KSI2: length 45.5
  TOP w0.114: UE5.57 104.12,16.94 v2(104.15,16.98) ; RE464.2 133.64,3.14 QE41.3 133.91,3.86 133.68,4.09 133.18,4.09 132.62,4.65 v2(132.48,4.65)
  IN4 w0.137: v2(132.48,4.65) 132.48,5.4 130.97,6.91 123.77,6.91 122.98,7.7 108.95,7.7 107.11,9.54 107.11,11.23 106.45,11.89 105.61,11.89 104.96,11.25 103.52,11.25 103.04,11.72 103.04,14.32 104.36,15.64 104.36,16.77 v2(104.15,16.98)
  BOTTOM w0.114: v2(132.48,4.65) 132.48,5.02 v1(132.62,5.16)
KSI3: length 46.3
  TOP w0.114: v2(133.17,4.65) 132.61,5.21 QE41.6 132.61,5.74 132.89,6.03 RE463.2 ; UE5.58 103.75,17.34 103.84,17.42 104.41,17.42 v2(104.85,16.98)
  IN4 w0.137: v2(104.85,16.98) 104.6,16.72 104.6,15.54 103.28,14.23 103.28,11.82 103.62,11.48 104.76,11.48 105.43,12.15 106.52,12.15 107.35,11.33 107.35,9.63 109.05,7.94 114.3,7.94 115.56,9.2 122.14,9.2 124.19,7.15 131.07,7.15 133.17,5.04 v2(133.17,4.65)
  BOTTOM w0.114: v1(133.45,4.19) 133.17,4.47 v2(133.17,4.65)
KSI4: length 61.2
  TOP w0.114: v2(106.17,21.53) 106.77,20.93 106.77,19.03 v3(105.48,17.74) UE5.59 ; RE459.2 146.66,2.78 146.93,3.05 QE40.3 146.93,3.48 146.32,4.09 v2(146.32,4.51)
  IN4 w0.137: v2(106.17,21.53) 106.17,18.01 108.12,16.06 117.94,16.06 118.99,15.01 122.72,15.01 125.88,11.85 138.98,11.85 v2(146.32,4.51)
  BOTTOM w0.114: v2(106.17,21.53) 105.86,21.53 105.71,21.68 105.71,22.28 105.24,22.76 JEC.4
KSI5: length 59.8
  TOP w0.114: v2(143.31,9.93) v3(144.32,9.93) 146.01,8.24 RE457.2 146.01,5.94 145.63,5.56 QE40.6 ; v2(106.14,22.11) 105.76,21.73 105.76,21.39 106.53,20.63 106.53,19.1 105.89,18.46 104.34,18.46 104.03,18.14 UE5.60
  IN4 w0.137: v2(106.14,22.11) 106.26,22.11 106.63,21.74 106.63,17.99 108.33,16.3 118.04,16.3 119.09,15.25 122.82,15.25 125.98,12.09 139.91,12.09 142.06,9.93 v2(143.31,9.93)
  BOTTOM w0.114: v2(106.14,22.11) 106.14,22.2 105.74,22.6 JEC.5
KSI6: length 60.2
  TOP w0.114: UE5.61 103.99,18.54 104.15,18.7 105.82,18.7 106.29,19.16 106.29,20.32 v3(106,20.6) 105.29,21.31 105.29,21.49 v2(105.33,21.53) ; RE452.2 144.06,2.91 144.37,3.22 QE39.3 144.37,3.63 v2(143.46,4.53)
  IN4 w0.137: v2(105.33,21.53) 105.33,17.71 107.22,15.82 117.84,15.82 118.89,14.77 122.62,14.77 125.78,11.61 138.37,11.61 143.46,6.52 v2(143.46,4.53)
  BOTTOM w0.114: v2(105.33,21.53) 104.64,21.53 104.24,21.93 JEC.2
KSI7: length 59
  TOP w0.114: UE5.62 105.76,18.94 106.04,19.23 106.04,19.81 104.78,21.07 104.78,21.82 v3(104.81,21.85) 105.07,22.11 v2(105.3,22.11) ; RE451.2 143.36,5.89 143.07,5.6 QE39.6 143.07,4.89 v2(142.79,4.61)
  IN4 w0.137: v2(105.3,22.11) 104.79,21.6 104.79,17.68 106.88,15.58 117.74,15.58 118.79,14.53 122.52,14.53 125.68,11.37 136.88,11.37 142.79,5.45 v2(142.79,4.61)
  BOTTOM w0.114: JEC.3 104.74,22.43 105.06,22.11 v2(105.3,22.11)
KSI8: length 34.6
  TOP w0.114: v2(105.9,10.5) 105.9,10.58 v1(105.53,10.94) 104.99,11.49 104.99,12.04 104.09,12.94 UE5.47 ; RE398.2 131.04,2.84 131.28,3.09 QE29.3 131.28,3.89 v2(130.7,4.47)
  IN4 w0.137: v2(130.7,4.47) 130.7,5.1 129.13,6.67 123.67,6.67 122.88,7.46 108.85,7.46 105.9,10.41 v2(105.9,10.5)
KSI9: length 34.2
  TOP w0.114: RE400.2 130.25,5.93 129.98,5.66 QE29.6 129.98,4.87 v2(129.72,4.6) ; v2(105.78,11.5) 105.78,11.5 105.79,11.51 105.79,11.69 v1(105.29,12.2) 104.14,13.34 UE5.48
  IN4 w0.137: v2(105.78,11.5) 105.78,11.44 105.5,11.16 105.5,10.25 108.53,7.22 122.79,7.22 123.58,6.43 128.74,6.43 129.72,5.45 v2(129.72,4.6)
KSI10: length 27
  TOP w0.114: v2(123.71,15.71) 124.09,16.09 125.11,16.09 125.75,15.45 QE43.3 125.75,14.57 125.45,14.27 RE475.2 ; UE5.49 104.25,13.74 v2(104.3,13.7)
  IN1 w0.097: v2(123.71,15.71) 122.62,14.61 108.22,14.61 106.71,13.1 104.89,13.1 v2(104.3,13.7)
  BOTTOM w0.114: v2(123.71,15.71) v1(123.71,15.2)
KSI11: length 24.8
  TOP w0.114: v2(123.13,15.7) 123.13,16.08 v1(123.35,16.3) 123.78,16.73 QE43.6 124.45,17.14 124.77,17.46 RE477.2 ; UE5.50 104.45,14.14 104.88,13.71 v2(104.88,13.69)
  IN1 w0.097: v2(104.88,13.69) 105.28,13.3 106.63,13.3 108.14,14.81 122.24,14.81 v2(123.13,15.7)
KSI12: length 46.2
  TOP w0.114: RE481.2 141.52,3.15 QE44.3 141.76,3.65 v2(140.9,4.51) ; UE5.51 105.14,14.54 v1(105.49,14.88) 105.55,14.95 v2(105.55,15.39)
  IN4 w0.137: v2(105.55,15.39) 105.68,15.26 117.72,15.26 118.69,14.3 122.42,14.3 125.59,11.13 134.98,11.13 140.9,5.21 v2(140.9,4.51)
KSI13: length 44.3
  TOP w0.114: v2(104.97,15.39) 104.62,15.39 v1(104.22,14.98) 104.17,14.94 UE5.52 ; RE483.2 140.73,5.99 140.46,5.72 QE44.6 140.46,4.96 v2(140.2,4.7)
  IN4 w0.137: v2(104.97,15.39) 105.37,14.99 117.66,14.99 118.59,14.06 122.32,14.06 125.5,10.88 134.89,10.88 140.2,5.58 v2(140.2,4.7)
KSI14: length 37.3
  TOP w0.114: v2(127.96,4.47) 127.96,4.35 128.03,4.28 128.03,4.09 128.66,3.46 QE45.3 128.66,3.19 128.37,2.91 RE487.2 ; v2(101.44,14.8) 101.44,15.15 101.63,15.34 UE5.53
  IN4 w0.137: v2(101.44,14.8) 101.44,13.98 102.8,12.62 102.8,11.11 103.77,10.14 105.27,10.14 108.43,6.98 122.56,6.98 123.35,6.19 127.07,6.19 127.96,5.3 v2(127.96,4.47)
  BOTTOM w0.114: v2(101.44,14.8) v1(102.07,14.8)
KSI15: length 36.9
  TOP w0.114: RE489.2 127.62,5.56 QE45.6 127.37,5.29 127.37,4.76 127.28,4.67 v2(127.28,4.6) ; UE5.54 101.58,15.74 100.86,15.01 v2(100.86,14.8)
  IN4 w0.137: v2(100.86,14.8) 100.86,14.23 102.56,12.52 102.56,11.01 103.67,9.9 105.17,9.9 108.33,6.74 122.46,6.74 123.25,5.95 126.61,5.95 127.28,5.29 v2(127.28,4.6)
  BOTTOM w0.114: v2(100.86,14.8) v1(100.31,14.8)
KSI16: length 47.4
  TOP w0.114: RE493.2 138.91,3.16 QE46.3 139.15,3.89 138.57,4.47 v2(138.44,4.47) ; v2(103.97,11.9) 103.92,11.9 103.68,12.14 UE5.45
  IN4 w0.137: v2(138.44,4.47) 138.44,6.56 134.38,10.63 125.41,10.63 122.22,13.82 118.49,13.82 117.58,14.73 105.79,14.73 105.55,14.49 103.99,14.49 103.52,14.01 103.52,12.3 103.92,11.9 v2(103.97,11.9)
  BOTTOM w0.114: v2(103.97,11.9) 103.96,11.88 v1(103.38,11.88)
KSI17: length 45.6
  TOP w0.114: RE494.2 138.1,5.97 137.85,5.72 QE46.6 137.85,4.78 137.72,4.65 v2(137.69,4.65) ; UE5.46 103.94,12.54 v2(104.58,11.9)
  IN4 w0.137: v2(137.69,4.65) 137.69,5.48 136.03,7.14 132.09,7.14 130.76,8.47 124.86,8.47 123.41,9.92 113.64,9.92 109.07,14.49 105.89,14.49 105.65,14.25 104.09,14.25 103.76,13.92 103.76,12.72 v2(104.58,11.9)
  BOTTOM w0.114: v2(104.58,11.9) 104.6,11.88 v1(105.17,11.88)
KSI18: length 50
  TOP w0.114: v2(94.44,22.63) 94.67,22.4 UE5.81 ; v2(125.46,4.47) 126.04,3.89 QE47.3 126.04,3.11 125.77,2.84 RE500.2
  IN4 w0.137: v2(125.46,4.47) 125.46,4.53 124.28,5.71 123.15,5.71 122.36,6.5 106.03,6.5 104.26,8.28 96.85,8.28 95.84,9.3 95.84,17.2 94.25,18.79 94.25,22.44 v2(94.44,22.63)
  BOTTOM w0.114: v2(94.44,22.63) v1(95,22.63)
KSI19: length 47
  TOP w0.114: v2(93.68,20.09) 93.99,20.09 94.27,20.37 UE5.82 ; v2(124.6,4.53) 124.74,4.67 QE47.6 124.74,5.56 124.98,5.8 RE499.2
  IN4 w0.137: v2(93.68,20.09) 93.68,19.02 95.6,17.1 95.6,9.2 96.75,8.04 104.16,8.04 105.94,6.27 122.26,6.27 123.05,5.48 124.18,5.48 124.6,5.05 v2(124.6,4.53)
  BOTTOM w0.114: v2(93.68,20.09) v1(93.68,19.58)
KSI20: length 46.5
  TOP w0.114: UE5.85 93.07,20.36 v2(92.8,20.09) ; v1(123.26,1.68) 123.1,1.83 RE505.2 123.1,2.78 123.45,3.13 QE48.3 123.45,3.82 v2(122.79,4.47)
  IN4 w0.137: v2(92.8,20.09) 92.8,19.56 95.36,17 95.36,9.1 96.65,7.8 104.06,7.8 105.84,6.02 121.97,6.02 122.79,5.2 v2(122.79,4.47)
KSI21: length 44.7
  TOP w0.114: RE506.2 122.37,5.85 122.15,5.64 QE48.6 122.15,4.87 v2(121.81,4.53) ; v2(92.22,20.09) 92.67,20.55 UE5.86
  IN4 w0.137: v2(121.81,4.53) 121.32,5.02 117.19,5.02 116.47,5.74 105.74,5.74 103.95,7.53 96.54,7.53 95.12,8.96 95.12,16.9 92.22,19.81 v2(92.22,20.09)
  BOTTOM w0.114: v2(92.22,20.09) v1(92.22,19.57)
KSO0: length 28.8
  TOP w0.114: UE5.39 103.88,9.74 v2(104.12,9.5) ; RE513.1 127.07,12.25 v1(127.16,12.34) v2(127.7,12.88)
  IN1 w0.097: v2(127.7,12.88) 127.7,12.21 126.19,10.71 124.44,10.71 123.31,9.58 105.2,9.58 104.9,9.88 104.5,9.88 v2(104.12,9.5)
KSO1: length 31.3
  TOP w0.114: v2(131.65,12.88) 131.5,12.72 RE531.1 ; UE5.40 104.16,10.14 v1(104.35,9.96) 104.74,9.57 v2(104.74,9.5)
  IN1 w0.097: v2(104.74,9.5) 104.86,9.38 123.39,9.38 124.52,10.51 129.28,10.51 v2(131.65,12.88)
KSO2: length 38
  TOP w0.114: RE534.1 134.23,18.72 133.47,19.48 120.81,19.48 v1(120.46,19.14) 120.46,18.82 117.87,16.23 v2(117.87,13.68) ; UE5.41 v2(103.93,10.54)
  IN1 w0.097: v2(103.93,10.54) 104.75,10.54 105.23,10.06 111.52,10.06 115.18,13.71 117.83,13.71 v2(117.87,13.68)
KSO3: length 65.5
  TOP w0.114: v2(101.3,18.72) 100.95,18.38 100.95,17.04 100.72,16.81 100.72,16.47 100.24,15.99 100.24,13.74 100.22,13.72 100.22,13.68 100.98,12.91 100.98,11.26 101.3,10.94 UE5.42 ; v3(140.58,19.44) v2(140.58,18.88) RE536.1
  IN4 w0.137: v2(101.3,18.72) 102.38,19.8 102.38,21.49 104.27,23.38 108.98,23.38 109.81,22.55 109.81,17.74 110.47,17.08 119.18,17.08 120.41,18.31 140.01,18.31 v2(140.58,18.88)
  BOTTOM w0.114: v2(101.3,18.72) 101.7,19.12 102.47,19.12 103.14,19.79 103.14,20.97 103.74,21.57 JEC.1
KSO4: length 55.2
  TOP w0.114: v2(101.23,16.6) 101.23,15.84 100.47,15.07 100.47,14.96 100.47,14.96 100.47,14.64 100.47,14.64 100.47,13.74 101.17,13.04 101.23,13.04 101.23,11.98 101.88,11.34 UE5.43 ; RE540.1 131.56,18.38 131.83,18.11 v1(131.83,17.54) 131.83,15.76 v2(131.45,15.39)
  IN4 w0.137: v2(101.23,16.6) 101.23,17.93 102.69,19.39 102.69,21.36 104.47,23.14 107.39,23.14 107.52,23.01 109,23.01 109.4,22.61 109.4,21.47 107.77,19.84 107.77,18.26 109.2,16.83 119.31,16.83 120.56,18.08 125.6,18.08 128.79,14.88 130.95,14.88 131.45,15.38 v2(131.45,15.39)
LAN_ACTIVITY#: length 25.4
  TOP w0.114: v2(197.17,150.51) 197.17,150.52 197.17,152.82 197.63,153.28 197.63,153.83 197.75,153.95 200.72,153.95 201.13,154.36 203.94,154.36 v3(206.77,157.19) v2(206.77,158.84)
  BOTTOM w0.114: UL1.38 197.74,150.37 197.6,150.51 v2(197.17,150.51) ; v2(206.77,158.84) 207.98,158.84 208.62,159.49 CL27.1 209.48,159.54 212.33,162.38 JLAN.10
LAN_LED2#: length 8.4
  BOTTOM w0.114: JLAN.13 227.54,160.16 v3(228.41,160.16) 231.77,160.16 CL29.1 RL15.1
LAN_LED2#_R: length 49.6
  TOP w0.114: v2(201.61,145.93) v1(201.02,145.93)
  IN4 w0.137: v2(233.35,159.15) 232.55,158.34 232.55,145.65 231.2,144.3 201.75,144.3 201.05,145 201.05,145.44 201.55,145.93 v2(201.61,145.93)
  BOTTOM w0.114: v2(201.61,145.93) 201.89,146.21 UL1.23
  BOTTOM w0.508: RL15.2 v2(233.35,159.15)
LAN_LINK#: length 11.5
  BOTTOM w0.114: JLAN.11 v3(225.16,160.25) 225.94,159.47 230.55,159.47 CL28.1 RL13.1
LAN_LINK#_R: length 55.5
  TOP w0.114: RL4.2 198,152.41 197.5,151.92 v1(197.5,151.88) 197.5,151.01 v2(197.55,150.95)
  IN2 w0.097: v2(197.55,150.95) 198.46,150.95 198.89,150.52 198.89,147.79 199.7,146.98 202.2,146.98 203.04,146.14 206.26,146.14 207.72,144.68 231.39,144.68 232.94,146.23 232.94,155.03 v2(234.53,156.62)
  BOTTOM w0.114: v2(197.55,150.95) 197.74,150.95 197.93,150.77 UL1.39 ; v2(234.53,156.62) QL3.2
LAN_MDIN0: length 12.2
  IN1 w0.089: v2(204.8,150.7) 204.87,150.77 205.73,150.77 206.06,150.43 206.06,150.41 206.06,146.95 207.43,145.58 207.89,145.58 v2(208.05,145.42)
  BOTTOM w0.089: v2(208.05,145.42) 208.07,145.44 208.77,145.44 209.16,145.83 209.16,146.06 209.43,146.33 209.63,146.33 209.82,146.52 TL1.11 ; UL1.12 204.74,150.77 v2(204.8,150.7)
LAN_MDIN1: length 18.4
  IN5 w0.089: v2(214.59,145.68) 214.53,145.68 214.33,145.88 214.33,146.36 214.05,146.64 205.83,146.64 204.99,147.48 204.1,147.48 203.79,147.79 203.79,149.43 204.05,149.69 204.7,149.69 204.83,149.57 v2(204.83,149.49)
  BOTTOM w0.089: TL1.7 214.9,146.38 214.45,145.93 214.45,145.83 v2(214.59,145.68) ; UL1.15 203.98,149.57 204.14,149.73 204.64,149.73 204.83,149.54 v2(204.83,149.49)
LAN_MDIN2: length 22
  IN1 w0.089: v2(216.7,145.43) 216.53,145.6 216.53,145.94 215.82,146.65 213.97,146.65 211.54,144.22 206.86,144.22 203.88,147.2 203.88,148.27 204.09,148.48 204.61,148.48 v2(204.8,148.29)
  BOTTOM w0.089: UL1.18 203.86,148.37 203.91,148.42 204.67,148.42 v2(204.8,148.29) ; TL1.5 217.44,146.46 217.18,146.2 216.8,146.2 216.67,146.07 216.67,145.9 216.53,145.76 216.53,145.6 v2(216.7,145.43)
