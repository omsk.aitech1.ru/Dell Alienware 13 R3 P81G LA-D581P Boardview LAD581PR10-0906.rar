# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 158
  TOP w0.127: v3(16.78,38.9) v2(17.47,38.21)
  TOP w0.381: v2(14.19,30.3) 14.49,30.6 v3(14.68,30.6) 15.1,30.6 15.32,30.38 15.68,30.38 CA48.2 16.32,29.73 RA45.2 ; v2(15.59,14.91) 15.63,14.95 CA42.2 ; CA43.2 15.23,23.42 v2(14.48,22.66)
  TOP w0.508: v2(17.73,15.67) 17.11,15.05 RA7.1 ; CA17.2 23.23,31.69 CA16.2 23.82,31.36 v2(24.21,30.96) ; v2(22.21,35.27) 22.25,35.24 CA25.2 ; v2(23.06,41.39) 23.28,41.17 RA6.1 ; v2(20.67,40.69) CA33.2 19.97,41.6 CA27.2 CA26.2 20.12,43.44 20.46,43.78 v3(20.59,43.78) 20.86,43.78 v2(21.28,43.35) 21.69,43.35 CA32.2 ; CA50.2 14.79,36.02 14.49,36.32 v2(14.49,36.65) ; v2(14.62,23.65) 14.62,23.93 CA44.2 ; v2(26.9,30.44) 26.67,30.67 CA31.2 26.15,31.13 CA30.2 ; RA44.2 18,37.68 v2(17.47,38.21) ; RA1.1 v2(12.84,36.35)
  GND1 w0.203: 7.68,35.62 JACK2.6 ; JACK2.6 9.84,35.62 ; JACK2.6 8.76,35.62 ; JACK2.6 9.84,34.95 ; JACK2.6 7.68,34.27 ; JACK2.6 8.76,34.27 ; JACK2.6 9.84,34.27 ; JACK2.6 7.68,34.95 ; JACK2.3 7.39,25.45 ; JACK2.3 6.31,24.77 ; JACK2.3 5.23,25.45 ; JACK2.3 7.39,24.77 ; JACK2.3 5.23,24.77 ; JACK1.5 12.57,22.31 ; JACK1.5 11.49,22.98 ; JACK1.5 12.57,21.63 ; JACK1.5 10.41,21.63 ; JACK1.5 10.41,22.98 ; JACK1.5 11.49,21.63 ; JACK1.5 10.41,22.31 ; JACK1.5 12.57,22.98 ; 2.63,24.77 JACK2.4 ; JACK2.4 4.79,25.45 ; JACK2.4 4.79,24.77 ; JACK2.4 2.63,25.45 ; JACK2.4 3.71,24.77
  GND2 w0.203: 10.41,22.98 JACK1.5 ; JACK1.5 11.49,21.63 ; JACK1.5 12.57,21.63 ; JACK1.5 11.49,22.98 ; JACK1.5 10.41,22.31 ; JACK1.5 10.41,21.63 ; JACK1.5 12.57,22.31 ; JACK1.5 12.57,22.98 ; JACK2.6 9.84,34.27 ; JACK2.6 8.76,35.62 ; JACK2.6 9.84,34.95 ; JACK2.6 8.76,34.27 ; JACK2.6 7.68,34.27 ; JACK2.6 7.68,35.62 ; JACK2.6 9.84,35.62 ; JACK2.6 7.68,34.95 ; JACK2.4 4.79,24.77 ; JACK2.4 2.63,25.45 ; JACK2.4 4.79,25.45 ; JACK2.4 3.71,24.77 ; JACK2.4 2.63,24.77 ; JACK2.3 7.39,24.77 ; JACK2.3 5.23,25.45 ; JACK2.3 5.23,24.77 ; JACK2.3 6.31,24.77 ; JACK2.3 7.39,25.45
  IN4 w0.508: v2(11.05,23.23) 11.49,22.79 JACK1.5 ; JACK2.6 v2(8.76,36.45)
  GND3 w0.203: 7.68,35.62 JACK2.6 ; JACK2.6 8.76,35.62 ; JACK2.6 8.76,34.27 ; JACK2.6 9.84,34.27 ; JACK2.6 9.84,35.62 ; JACK2.6 7.68,34.95 ; JACK2.6 7.68,34.27 ; JACK2.6 9.84,34.95 ; 10.41,22.98 JACK1.5 ; JACK1.5 10.41,22.31 ; JACK1.5 12.57,22.98 ; JACK1.5 10.41,21.63 ; JACK1.5 11.49,21.63 ; JACK1.5 12.57,21.63 ; JACK1.5 11.49,22.98 ; JACK1.5 12.57,22.31 ; 2.63,24.77 JACK2.4 ; JACK2.4 3.71,24.77 ; JACK2.4 2.63,25.45 ; JACK2.4 4.79,25.45 ; JACK2.4 4.79,24.77 ; 6.31,24.77 JACK2.3 ; JACK2.3 7.39,24.77 ; JACK2.3 7.39,25.45 ; JACK2.3 5.23,25.45 ; JACK2.3 5.23,24.77
  GND4 w0.203: JACK2.6 9.84,35.62 ; JACK2.6 8.76,35.62 ; JACK2.6 7.68,34.27 ; JACK2.6 8.76,34.27 ; JACK2.6 9.84,34.95 ; JACK2.6 7.68,35.62 ; JACK2.6 7.68,34.95 ; JACK2.6 9.84,34.27 ; 2.63,24.77 JACK2.4 ; JACK2.4 2.63,25.45 ; JACK2.4 4.79,24.77 ; JACK2.4 4.79,25.45 ; JACK2.4 3.71,24.77 ; 10.41,22.31 JACK1.5 ; JACK1.5 10.41,22.98 ; JACK1.5 11.49,22.98 ; JACK1.5 12.57,22.98 ; JACK1.5 12.57,21.63 ; JACK1.5 12.57,22.31 ; JACK1.5 10.41,21.63 ; JACK1.5 11.49,21.63 ; JACK2.3 7.39,25.45 ; JACK2.3 7.39,24.77 ; JACK2.3 5.23,24.77 ; JACK2.3 6.31,24.77 ; JACK2.3 5.23,25.45
  BOTTOM w0.203: UA1.20 27.21,33.3 v2(27.12,33.21) ; UA1.42 22.81,40.78 22.68,40.91 22.68,41.14 22.93,41.39 v2(23.06,41.39) ; v2(22.21,35.27) 22.17,35.31 22.17,35.52 22.63,35.98 UA1.30
  BOTTOM w0.254: CA24.2 21.77,34.84 v2(22.21,35.27) ; UA2.A2 16.84,25.94 v2(17.18,26.28)
  BOTTOM w0.356: CA46.2 15.25,15.25 v2(15.59,14.91) ; CA45.2 14.81,22.33 v2(14.48,22.66)
  BOTTOM w0.381: CA51.2 15.21,27.23 v2(15.15,27.29)
  BOTTOM w0.508: v2(17.18,26.28) 17.77,25.68 18.01,25.68 18.39,25.3 18.39,23.21 18.06,22.88 CA91.2 ; v2(21.28,43.35) 22,43.35 CA15.2 ; v2(24.21,30.96) 24.76,31.51 CA29.2 25.21,31.89 25.58,32.26 CA28.2 ; CA92.2 17.62,15.56 v2(17.73,15.67) ; CA14.2 21.44,44.21 v2(21.4,44.17)
  vias: v2(17.48,26.82)
VCC_CORE_PT1: length 1.1
  BOTTOM w0.254: PT1.1 127.92,132.87 PU502.22
VCC_CORE_PT2: length 1.3
  BOTTOM w0.254: PU503.22 PT2.1
VCC_CORE_PT3: length 1.1
  BOTTOM w0.254: PT3.1 144.5,132.85 PU504.22
VCC_GT_PT1: length 1.3
  BOTTOM w0.254: PT4.1 111.28,132.81 PU507.22
VCC_GT_PT2: length 1.2
  BOTTOM w0.254: PU510.22 119.72,132.9 PT5.1
VCC_SA_PT1: length 1.1
  BOTTOM w0.254: PT6.1 152.22,126.91 PU511.9
VCCGT_SENSE: length 50.4
  IN2 w0.381: v2(122.38,115.46) 122.03,115.8 110.41,115.8 107.08,119.14 99.8,119.14 96.91,122.03 91.33,122.03 89.67,123.68 89.67,125.17 89.1,125.74 89.1,129.14 88.44,129.8 v2(88.38,129.8)
  BOTTOM w0.254: CPU1.AH38 123.28,111.97 123.12,111.97 122.62,112.47
  BOTTOM w0.381: 122.62,112.47 121.67,112.47 121.04,113.11 121.04,114.65 121.31,114.92 RH203.2 121.88,114.96 v2(122.38,115.46) ; PC508.1 88.39,129.79 v2(88.38,129.8) PR531.2
VCCIO_PGOOD: length 2.3
  TOP w0.114: v2(92.72,109.11) v1(92.72,108.51)
  BOTTOM w0.114: PR5016.2 93.22,109.61 v2(92.72,109.11) 92.49,108.88 PU509.9
VCCIO_SENSE: length 68.1
  IN5 w0.254: 135.02,114.45 135.94,113.54 135.94,107.77 135.21,107.03 135.21,105.94 135.61,105.54 135.61,102.23 137.21,100.64 137.21,96.38 138.48,95.11 v2(138.48,93.68)
  IN5 w0.381: v2(101.04,115.3) 102.12,115.3 103.42,116.6 132.88,116.6 135.02,114.45
  BOTTOM w0.254: v2(138.48,93.68) 138.48,93.75 CPU1.H14
  BOTTOM w0.381: PR5017.2 94.82,111.61 95.33,112.12 95.33,113.9 96.13,114.7 100.91,114.7 101.04,114.83 v2(101.04,115.3)
VCCSA_SENSE: length 77.4
  IN5 w0.381: v2(143.84,117.83) 142.12,117.83 141.39,117.1 133.81,117.1 133.23,117.68 104.48,117.68 100.09,122.07 100.09,130.47 100.75,131.13 v2(100.75,133.31)
  BOTTOM w0.254: 136.29,112.74 136.14,112.59 CPU1.M38
  BOTTOM w0.381: PR533.2 101.03,135.06 PC514.2 101.13,135.06 101.13,133.69 v2(100.75,133.31) ; 136.29,112.74 136.29,114.39 136.75,114.85 140.16,114.85 141.12,113.89 144.74,113.89 145.12,114.27 145.12,115.23 144.54,115.81 RH201.1 143.85,117.83 v2(143.84,117.83)
VCCSENSE: length 58.3
  IN2 w0.381: v2(93.22,140.64) 93.22,139.37 93.61,138.98 95.47,138.98 96.44,138.01 96.44,136.77 96.98,136.23 96.98,130.45 96.81,130.29 96.81,128.59 97.35,128.06 97.35,124.69 101.37,120.66 107.71,120.66 110.79,117.58 122.91,117.58 124.95,115.54 v2(125.8,115.54)
  BOTTOM w0.254: CPU1.AG37 124.48,111.06 124.74,111.33 124.74,112.05 125,112.31
  BOTTOM w0.381: PR550.1 93.22,139.08 PC533.1 v2(93.22,140.64) ; v2(125.8,115.54) 126.07,115.28 RH197.2 125.83,114.92 125.42,114.51 125.42,113.36 125,112.95 125,112.31
VDD_1.2V: length 5.5
  TOP w0.114: PR201.1 61.61,45.81 61.61,45.81 v1(61.61,45.8)
  TOP w0.203: v2(60.14,48.31) 60.51,48.68 PU201.11
  TOP w0.254: PR201.1 61.23,46.7 v2(60.97,46.96)
  BOTTOM w0.254: v2(60.14,48.31) 60.33,48.13 PC212.1 PR203.2 61.54,47.52 v2(60.97,46.96)
VIN: length 146.1
  TOP w0.254: PD700.3 64.78,31.6 64.78,33.95 64.99,34.16 64.99,35.52 64.53,35.98 64.53,36.94 64.18,37.29 v2(63.82,37.29) 63.69,37.29 63.25,36.84 PR716.1 ; v2(42.52,54.51) v3(42.52,57.64) 49.63,64.75 56.51,64.75 57.51,63.75 57.51,62.73 59.38,60.86 62.69,60.86 64.34,62.51 64.34,63.4 64.78,63.84 66.33,63.84 66.86,63.32 v2(66.86,63.16) ; v2(40.64,43.77) 39.26,42.38 39.26,28.87 39.05,28.66 39.05,20.1 38.36,19.4 v2(38.11,19.4) ; PR729.2 93.24,71.26 93.68,70.83 93.68,70.06 93.55,69.94 93.36,69.94 93.34,69.91 93,69.91 92.98,69.94 89.68,69.94 89.29,70.32 PR732.1 88.71,69.91 88.71,69.91 88.41,69.61 v3(88.41,67.33) 88.41,64.02 89.74,62.68 89.74,60.79 89.28,60.34 86.3,60.34 82.88,56.92 v2(82.88,53.68)
  TOP w0.508: 47.38,44.15 47.38,43.08 PC723.1
  IN1 w0.254: v2(42.55,43.77) 45.31,41 54.11,41 54.43,40.68 54.43,38.47 54.7,38.21 57.29,38.21 57.59,38.51 61.48,38.51 61.84,38.14 62.92,38.14 63.77,37.29 v2(63.82,37.29)
  IN2 w0.254: v2(82.88,53.68) 79.44,53.68 72.78,60.34 68.79,60.34 67.07,62.06 67.07,62.95 v2(66.86,63.16)
  BOTTOM w0.254: PD101.2 37.29,19.03 37.58,19.32 38.03,19.32 v2(38.11,19.4)
  vias: v2(40.64,44.4) v2(40.71,47.26) v2(41.34,47.26) v2(41.28,44.4) v2(41.28,43.77) v2(41.91,44.4) v2(41.91,43.77) v2(41.98,47.26) v2(42.55,47.58) v2(42.55,46.94) v2(42.55,46.31) v2(42.55,45.67) v2(42.55,45.04) v2(42.55,44.4) v2(42.68,49.1) v2(42.68,48.47) v2(43.06,47.89) v2(43.06,47.26) v2(43.06,46.62) v2(43.06,45.99) v2(43.06,45.35) v2(43.06,44.72) v2(43.06,44.08) v3(41.02,45.66)
VIN1N: length 7
  BOTTOM w0.254: RG59.2 CG62.2 205.56,77.05 v1(205.06,77.56) 204.83,77.79 202.49,77.79 201.89,77.18 UG11.11
VIN1P: length 6.9
  BOTTOM w0.254: UG11.12 202.54,76.88 203.04,77.38 v1(203.44,77.38) 203.9,77.38 204.67,76.61 204.67,75.14 204.93,74.89 CG62.1 206.63,74.89 RG62.2
VIN2N: length 4.4
  TOP w0.114: v2(204.57,74.34) v1(205.16,74.34)
  BOTTOM w0.254: RG64.2 206.5,73.43 CG63.2 205.49,73.43 v2(204.57,74.34) 204.27,74.64 UG11.14
VIN2P: length 5.3
  BOTTOM w0.114: v1(206.76,71.28) RG66.2
  BOTTOM w0.254: RG66.2 206.57,72.03 CG63.1 204.67,72.92 204.67,73.37 204.05,73.99 UG11.15
VIN3N: length 3.2
  BOTTOM w0.254: UG11.1 202.54,70.99 CG183.2 202.64,70.38 RG138.2
VIN3P: length 3.2
  BOTTOM w0.254: RG137.2 201.75,70.38 CG183.1 201.89,71.03 UG11.2
VSSGT_SENSE: length 54.9
  TOP w0.254: PC513.1 89.24,132.95 v2(89,132.95)
  IN2 w0.381: v2(123.32,115.51) 123.32,115.56 122.44,116.44 110.5,116.44 107.29,119.65 100.05,119.65 97.17,122.54 91.54,122.54 90.18,123.89 90.18,125.38 89.62,125.94 89.62,129.34 88.91,130.05 88.91,132.86 v2(89,132.95)
  BOTTOM w0.203: PU500.6 89.05,133.02 88.98,132.95 v2(89,132.95)
  BOTTOM w0.254: CPU1.AH37 123.65,111.06 123.96,111.37 123.96,111.94 123.44,112.46
  BOTTOM w0.381: v2(123.32,115.51) RH472.1 122.89,114.9 122.56,114.57 122.56,113.34 v1(122.81,113.09) 123.44,112.46
VSSIO_SENSE: length 66.5
  IN5 w0.254: v2(137.67,94.1) 137.67,95.44 136.87,96.24 136.87,100.5 135.24,102.12 135.24,105.36 134.84,105.76 134.84,107.19 135.6,107.95 135.6,113.16 134.19,114.56
  IN5 w0.381: 134.19,114.56 132.67,116.09 103.68,116.09 102.18,114.6 100.79,114.6 100.41,114.98 v2(100.41,115.3)
  BOTTOM w0.254: v2(137.67,94.1) 138.19,94.1 CPU1.J14
  BOTTOM w0.381: PR5018.2 94.64,114.17 95.77,115.3 v2(100.41,115.3)
VSSSA_SENSE: length 74.9
  TOP w0.254: v2(98.56,133.14) 98.27,133.14 97.74,132.61 97.74,132.35 PC515.1
  IN5 w0.381: v2(98.56,133.14) 99.56,132.14 99.56,121.88 104.34,117.11 133.09,117.11 133.58,116.62 141.86,116.62 142.38,117.14 v2(143.2,117.14)
  BOTTOM w0.203: v2(98.56,133.14) 98.44,133.02 PU500.31
  BOTTOM w0.254: CPU1.M37 135.74,111.46 135.74,112.71
  BOTTOM w0.381: v2(143.2,117.14) 142.96,116.89 RH469.1 142.79,115.81 142.4,115.42 v1(141.98,115.42) 136.62,115.42 135.74,114.54 135.74,112.71
VSSSENSE: length 56.2
  TOP w0.254: v2(93.13,137.52) 93.13,137.41 93.48,137.06 94.32,137.06 PC534.1
  IN2 w0.381: v2(124.21,115.51) 124.09,115.51 122.59,117.01 110.64,117.01 107.5,120.16 101.13,120.16 96.86,124.43 96.86,127.85 96.33,128.39 96.33,130.5 96.47,130.64 96.47,135.98 95.94,136.51 95.94,137.8 95.28,138.45 93.61,138.45 93.13,137.97 v2(93.13,137.52)
  BOTTOM w0.203: v2(93.13,137.52) 93.33,137.32 PU500.18
  BOTTOM w0.254: CPU1.AG38 124.32,112.66
  BOTTOM w0.381: v2(124.21,115.51) RH466.1 124.24,114.9 124.86,114.27 124.86,113.64 124.32,113.1 124.32,112.66
+CODEC_AVDD2: length 16.6
  TOP w0.508: CA16.1 23.8,32.59 CA17.1 21.72,32.59 21.15,32.02 21.15,30.49 21.7,29.95 v3(22.43,29.95) 22.91,29.95 23.5,30.54 v2(23.5,30.61)
  IN5 w0.508: v2(25.12,33.22) 25.09,33.22 23.5,31.64 v2(23.5,30.61)
  BOTTOM w0.203: v2(25.12,33.22) 25.12,33.47 25.61,33.96 UA1.24
  BOTTOM w0.508: LA4.1 26.72,29.16 25.88,29.16 25.17,29.87 RA12.1 24.67,30.44 24.48,30.25 23.86,30.25 v2(23.5,30.61)
+EC_VCCA: length 30.6
  TOP w0.508: v2(107.37,21.55) 107.37,13.58 106.48,12.7 v3(106.48,3.88) 105.04,2.44 103.72,2.44 LE1.2
  IN5 w0.508: v2(107.37,21.55) 107.01,21.55 106.76,21.8 106.76,22.82 106.29,23.28 v2(99.52,23.28)
+FBA_VREFC: length 10.5
  BOTTOM w0.381: UG2.J14 191.53,135.98 192.23,135.28 193.55,135.28 RG112.1 193.5,135.36 RG110.2 ; UG1.J14 198.64,135.98 198.13,135.47
  BOTTOM w0.406: 198.13,135.47 197.86,135.19 v1(197.86,135.18) 196.13,135.18 CG79.1 CG78.1 194.74,135.66 RG111.2 193.55,136.1 RG110.2
+FBB_VREFC: length 26.9
  BOTTOM w0.381: UG4.J14 226.13,135.66 226.94,135.66 ; UG3.J14 236.63,120.02 236.63,120.65
  BOTTOM w0.406: 236.63,120.65 CG113.1 ; CG113.1 RG121.2 RG122.2 ; CG113.1 CG114.1 RG123.1 236.63,124.98 236.15,125.46 232.02,125.46 v1(231.6,125.88) 231.54,125.94 231.54,133.88 229.76,135.66 226.94,135.66
+FBC_VREFC: length 11.6
  BOTTOM w0.102: RG132.2 233.64,90.14 v1(233.38,89.88)
  BOTTOM w0.254: 235.18,86.32 235.18,85.64 UG5.J14
  BOTTOM w0.381: RG133.2 CG148.1 RG134.1 CG149.1 ; RG133.2 234.63,91.86 234.27,92.23 234.27,92.67 234.65,93.05 UG6.J14 ; RG133.2 RG132.2
  BOTTOM w0.406: 235.18,86.32 235.18,86.49 234.63,87.03 CG149.1
+FBX_PLLAVDD: length 139.8
  TOP w0.089: v2(193.05,79.78) 193.24,79.78 v1(193.82,80.35)
  TOP w0.254: v2(206.65,105.3) 206.02,104.67 CG56.1 ; v2(201.85,87) 201.31,87.54 CG58.1 ; CG54.1 191.01,107.66 v2(191.35,108) ; CG59.1 197.25,107.5 v2(196.75,108) ; v2(206.65,99) 206.02,98.37 CG60.1
  TOP w0.508: CG57.1 206.35,90.45 v2(206.59,90.69) ; v2(193.05,79.78) 192.82,80.02 LG6.1
  GND2 w0.381: v2(206.59,90.69) 206.01,91.28 206.01,98.39 206.62,99 v2(206.65,99) 206.07,99.58 206.07,106.32 205.12,107.28 197.47,107.28 v2(196.75,108) 196.09,107.34 192.04,107.34 191.38,108 v2(191.35,108) 191.35,107.98 190.83,107.47 189.88,107.47 189.31,108.04 187.21,108.04 186.56,107.39 186.56,97.39 187.15,96.8 187.15,88.23 187.72,87.65 187.72,83.4 189.75,81.37 189.75,80.92 190.45,80.22 191.53,80.22 191.97,79.78 v2(193.05,79.78)
  IN2 w0.381: v2(206.59,90.69) 206.01,91.28 206.01,98.39 206.62,99 v2(206.65,99) 206.07,99.58 206.07,106.32 205.12,107.28 197.47,107.28 v2(196.75,108) 196.09,107.34 192.04,107.34 191.38,108 v2(191.35,108)
  IN5 w0.35: v2(206.65,105.3) 206.65,105.47 204.7,107.42 191.93,107.42 v2(191.35,108)
  BOTTOM w0.254: v2(196.75,108) 196.75,108.1 UG9.AF42 ; v2(206.65,99) 206.75,99 UG9.L29 ; v2(191.35,108) 191.6,108.25 UG9.AN42 ; UG9.L38 206.9,105.55 v2(206.65,105.3)
  BOTTOM w0.508: 206.33,90.09 206.33,88.35 205.37,87.4 204.55,87.4 204.29,87.65 202.77,87.65 202.52,87.4 ; v2(193.05,79.78) 193.05,79.4 192.67,79.02 192.67,76.97 CG55.1 192.56,76.3 LG2.1
+HDMI_5V_OUT: length 20.5
  TOP w0.127: v1(186.37,161.75) 186.27,161.85 186.27,162.51
  IN5 w0.508: v2(186.2,164.11) 184.99,164.11 184.23,163.35 181.29,163.35 176.16,158.22 176.16,157.69 175.72,157.25 174.89,157.25 174.26,156.62 v2(174.26,156.17)
  BOTTOM w0.381: v2(174.26,156.17) 174.13,156.04 173.12,156.04 173.08,156.01 172.42,156.01 171.87,156.55 DV13.2 DV12.2
+IFPX_PLLVDD: length 17
  TOP w0.356: LG5.2 179.94,91.35 183.93,91.35 184.2,91.63 v2(184.2,91.85) ; CG47.1 178.89,88.1 179.26,88.46 180.11,88.46 180.6,88.95 181.53,88.95 181.73,89.15 v1(183.4,89.15) 183.6,89.15 v2(184.2,89.75)
  TOP w0.508: CG49.1 CG47.1 178.27,88.82 178.79,89.34 CG247.1 178.79,90.2 LG5.2
  BOTTOM w0.254: UG9.BD15 v2(184.2,89.75) ; UG9.BD18 v2(184.2,91.85)
+INV_PWR_SRC:
  vias: v1(122.81,158.04)
+LAN_IO: length 83.9
  TOP w0.508: RL2.1 198.19,153.26 v2(197.69,152.76)
  IN2 w0.457: v2(207.02,160.43) 206.07,161.38 202.2,161.38 199.53,158.71 199.53,157.78 198.9,157.14 198.9,155.94 v2(199.57,155.27)
  IN2 w0.508: v2(207.02,160.43) 207.41,160.04 207.41,158.2 206.58,157.38 206.58,153.46 205.24,152.13 204.74,152.13 203.66,151.05 203.66,149.9 204.27,149.29 v2(204.27,149.17) 203.6,148.49 203.6,147.53 204.21,146.92 223.45,146.92 224.61,145.76 230.33,145.76 232.23,147.66 232.23,157.21 232.71,157.69 232.71,160.65 232.92,160.86 v2(233.36,160.86) ; v2(197.69,152.76) 197.69,153.39 v2(199.57,155.27)
  BOTTOM w0.203: v2(204.27,149.17) UL1.16
  BOTTOM w0.381: RL1.1 199.57,155.13 v2(199.57,155.27)
  BOTTOM w0.508: RL8.2 v2(207.02,160.43) ; RL14.1 235.16,160.14 v3(234.83,160.47) 234.43,160.86 v2(233.36,160.86) 233.03,160.86 LL1.1
+LCDVDD: length 2.9
  BOTTOM w1.524: 140.86,170.65 140.86,170.08 142.51,168.43
  vias: v2(125.6,161.43) v2(125.6,160.84) v2(125.82,161.97) v2(139.24,170.95) v2(139.54,171.47) v2(139.83,170.95) v3(143.56,168.22)
+NVVDD1: length 164.5
  TOP w0.254: v2(202.5,105.9) 202.51,105.89 v2(202.51,105.2) 202.39,105.08 202.39,103.92 v2(202.51,103.8) 202.51,103.28 PC6346.1 202.51,102.77 v2(202.51,102.4) 202.51,101.88 PC6322.1 202.51,101.37 v2(202.51,101) 202.51,100.53 PC6334.1 202.51,100.05 v2(202.51,99.6) 202.51,98.9 v2(202.5,98.9) 202.5,98.56 PC6411.1 202.5,97.83 v2(202.5,97.5) 202.58,97.5 202.83,97.24 202.83,96.42 202.52,96.1 v2(202.5,96.1) ; PC6306.1 191.2,91.99 v2(191.2,92.6) 191.2,93.22 PC6349.1 191.2,93.39 v2(191.2,94) 191.2,94.62 PC6356.1 191.2,94.78 v2(191.2,95.35) ; 200.45,98.2 v2(199.75,98.9) 199.75,99.55 v2(199.7,99.6) ; 200.45,98.2 200.45,98.2 v2(199.75,97.5) 199.7,97.45 v2(199.7,96.1) 199.75,96.05 v2(199.75,95.4) 199.75,94.05 v2(199.7,94) v2(199.7,93.3) v2(199.7,92.6) v2(199.7,91.2) v2(199.7,90.5) v2(199.7,89.1) 199.53,88.94 PC6345.1 ; 200.45,98.2 PC6410.1 ; v2(192.6,102.4) v2(192.6,101.7) v2(192.6,101) v2(192.6,99.6) v2(192.6,98.9) ; PC6351.1 194,94.66 v2(194,94) 193.96,93.96 PC6348.1 194,93.27 v2(194,92.6) 193.96,92.56 PC6307.1 ; PC6367.1 196.86,102.98 v2(196.86,102.39) 196.86,101.73 PC6325.1 196.86,101.52 v2(196.86,100.99) 196.86,100.39 PC6326.1 196.9,100.22 v2(196.9,99.6) 196.95,99.55 v2(196.95,98.9) ; PC6391.1 196.9,92.75 v2(196.9,91.2) ; PC6391.1 195.4,94.25 v2(195.4,95.4) v2(195.4,96.1) ; PC6391.1 196.9,94.11 v2(196.9,95.4) 196.9,96.05 v2(196.95,96.1) 196.99,96.14 196.99,97.46 v2(196.95,97.5) ; v2(203.9,99.65) 203.9,100.99 v2(203.91,101) v2(203.91,102.4) ; v2(189.8,98.9) v2(189.8,99.6) ; v2(193.95,102.4) 193.96,102.39 v2(193.96,101.7) 193.95,101.69 v2(193.95,101) ; v2(195.4,103.8) v2(195.4,104.5) v2(195.4,105.9) ; v2(195.4,99.6) v2(195.4,98.9) v2(195.4,97.5) 196.1,98.2 PC6409.1 196.95,97.54 v2(196.95,97.5) ; PC6330.1 188.62,92.37 v2(188.4,92.6) 188.62,92.83 PC6308.1 188.62,93.77 v2(188.4,94) 188.62,94.23 PC6309.1 188.62,95.13 v2(188.4,95.35) ; PC6303.1 189.8,88.76 v2(189.8,89.1) 189.8,89.1 v2(189.8,89.8) v2(189.8,91.2) 189.49,91.51 PC6305.1 189.49,92.29 v2(189.8,92.6) 189.8,93 PC6310.1 189.49,93.69 v2(189.8,94) 189.49,94.31 PC6311.1 189.49,95.09 v2(189.8,95.4) v2(189.8,96.1) ; v2(192.6,95.4) v2(192.6,96.1) ; v2(198.35,92.6) 198.35,93.29 v2(198.35,93.3) 198.35,93.99 v2(198.35,94) 198.35,95.3 v2(198.3,95.35) ; PC6350.1 205.35,93.95 v2(205.3,94) ; PC6353.1 202.5,88.78 v2(202.5,89.1) v2(202.5,89.8) v2(202.5,91.2) ; PC6365.1 206.02,101.19 205.83,101 ; v2(192.6,89.1) v2(192.6,89.8) 192.36,90.04 192.36,90.96 v2(192.6,91.2) ; v2(198.3,99.65) 198.3,99.87 PC6313.1 198.31,100.7 v2(198.31,101) 198.31,101.21 PC6333.1 198.31,102.04 v2(198.31,102.4) 198.31,102.67 PC6301.1 ; PC6358.1 206.02,100.81 205.83,101 ; v2(199.7,105.2) v2(199.7,103.8) ; v2(201.1,99.65) 200.47,100.28 PC6312.1 200.47,100.37 v2(201.11,101) 200.48,101.62 PC6364.1 200.47,101.77 v2(201.11,102.4) 200.48,103.02 PC6368.1 ; v2(201.1,95.35) v2(201.1,94) v2(201.1,92.6) ; 205.83,101 v2(205.26,101) ; PC6412.1 197.65,98.2 v2(196.95,97.5) ; v2(196.93,105.9) v2(196.93,105.2) ; v2(191.2,102.4) v2(191.2,101)
  TOP w0.305: v2(196.9,90.5) v2(196.9,91.2)
  TOP w0.381: PC6300.1 199.7,106.5 v2(199.7,105.9) v2(199.7,105.2) ; v2(196.9,89.1) 196.9,88.9 196.5,88.49 PC6331.1
  TOP w0.508: v2(196.29,26.06) 197.52,24.83 213.55,24.83 214.02,25.3 RG544.1
  IN3 w0.508: v2(188.93,55.5) 188.72,55.29 188.72,52.67 192.17,49.22 192.17,48.35 190.62,46.8 190.62,43.17 189.31,41.86 189.31,38.54 190.4,37.45 190.4,33.51 193.44,30.48 193.44,28.15 195.53,26.06 v2(196.29,26.06)
  BOTTOM w0.114: UG9.BA47 v2(186.3,111.55) ; v2(187.1,110.15) UG9.AW45
  BOTTOM w0.254: UG9.AV30 v2(188.4,99.65) ; v2(191.2,99.65) UG9.AP30 190.9,100.1 191.15,100.35 ; UG9.BC49 v2(184.3,112.95)
  vias: v2(177.41,115.67) v2(177.41,115.05) v2(177.9,112.9) v2(179.3,112.9) v2(180,113.6) v2(180.7,112.9) v2(181.4,110.8) v2(182.1,111.5) v2(182.8,110.8) v2(183.5,111.5) v2(183.5,108.7) v2(183.5,107.35) v2(183.58,110.08) v2(183.97,109.37) v2(184.2,110.8) v2(184.23,108.67) v2(184.61,109.37) v2(184.93,108.66) v2(185.24,109.37) v2(185.56,108.67) v2(185.62,107.28) v2(185.6,106.55) v2(185.65,105.3) v2(186.32,108.67) v2(187,109.4) v2(187.7,108.7) v2(187.7,107.3) v2(188.93,61.75) v2(188.93,60.48) v2(188.93,59.26) v2(188.93,58) v2(188.93,56.77) v2(189.1,107.3) v2(189.8,105.9) v2(189.8,104.5) v2(189.8,103.8) v2(189.8,97.5) v2(192.48,62.83) v2(192.6,105.9) v2(192.6,104.5) v2(192.6,103.8) v2(192.6,97.5) v2(192.59,94) v2(192.59,92.6) v2(193.12,63.84) v2(193.12,62.83) v2(193.44,65.37) v2(193.44,64.35) v2(193.44,63.33) v2(193.75,65.87) v2(193.75,64.86) v2(193.75,63.84) v2(193.75,62.83) v2(194.07,66.38) v2(194.07,65.37) v2(194.07,64.35) v2(194.07,63.33) v2(194.39,66.89) v2(194.39,65.87) v2(194.39,64.86) v2(194.39,63.84) v2(194.39,62.83) v2(194.71,66.38) v2(194.71,65.37) v2(194.71,64.35) v2(194.71,63.33) v2(194.83,89.8) v2(194.85,89.1) v2(195.02,66.89) v2(195.02,65.87) v2(195.02,64.86) v2(195.02,63.84) v2(195.02,62.83) v2(195.34,66.38) v2(195.34,65.37) v2(195.34,64.35) v2(195.34,63.33) v2(195.4,67.4) v2(195.66,63.84) v2(195.66,62.83) v2(196.04,67.4) v2(195.98,63.33) v2(196.29,63.84) v2(196.29,62.83) v2(196.61,63.33) v2(196.67,67.4) v2(196.93,63.84) v2(196.93,62.83) v2(196.99,67.91) v2(197.25,63.33) v2(197.31,67.4) v2(197.56,63.84) v2(197.56,62.83) v2(197.88,63.33) v2(198.2,62.83) v2(198.83,62.83) v2(199.47,62.83) v2(199.7,102.4) v2(199.7,101) v2(200.1,62.83) v2(200.55,67.46) v2(200.74,62.83) v2(201.18,67.46) v2(201.37,62.83) v2(202,65.87) v2(202.01,63.84) v2(202.01,62.83) v2(202.33,66.38) v2(202.33,65.37) v2(202.33,64.35) v2(202.33,63.33) v2(202.5,95.4) v2(202.64,66.89) v2(202.64,65.87) v2(202.64,64.86) v2(202.64,63.84) v2(202.64,62.83) v2(202.96,66.38) v2(202.96,65.37) v2(202.96,64.35) v2(202.96,63.33) v2(203.28,66.89) v2(203.28,65.87) v2(203.28,64.86) v2(203.28,63.84) v2(203.28,62.83) v2(203.6,66.38) v2(203.6,65.37) v2(203.6,64.35) v2(203.6,63.33) v2(203.9,95.35) v2(203.91,66.89) v2(203.91,65.87) v2(203.91,64.86) v2(203.91,63.84) v2(203.91,62.83) v2(204.23,66.38) v2(204.23,65.37) v2(204.23,64.35) v2(204.23,63.33) v2(204.55,63.84) v2(204.55,62.83) v2(204.87,63.33) v2(205.12,67.4) v2(205.18,63.84) v2(205.18,62.83) v2(205.5,63.33) v2(205.82,70.26) v2(205.82,69.43) v2(205.82,68.48) v2(205.75,67.4) v2(205.82,63.84) v2(205.82,62.83) v2(206.14,63.33) v2(206.39,67.4) v2(206.45,63.84) v2(206.45,62.83) v2(206.77,63.33) v2(207.09,65.87) v2(207.09,64.86) v2(207.09,63.84) v2(207.09,62.83) v2(207.41,65.37) v2(207.41,64.35) v2(207.41,63.33) v2(207.72,64.86) v2(207.72,63.84) v2(207.72,62.83) v2(208.04,64.35) v2(208.04,63.33) v2(208.36,62.83) v2(208.99,62.83) v2(209.63,62.83) v2(210.26,62.83) v3(190.07,63.11)
+NVVDD2: length 191.3
  TOP w0.254: v2(196.1,103.8) 196.41,104.11 PC6338.1 196.41,104.85 v2(196.05,105.21) ; v2(194,99.55) v2(194,98.9) v2(194,97.5) v2(194,96.1) v2(194,95.45) ; v2(203.95,96.1) v2(203.95,97.5) 203.95,98.85 v2(203.9,98.9) ; v2(198.3,103.8) 198.3,104.44 PC6315.1 198.3,104.52 v2(198.3,105.2) ; v2(198.3,98.9) 198.5,98.7 198.5,97.7 v2(198.3,97.5) 198.39,97.41 198.39,96.19 v2(198.3,96.1) ; v2(201.1,98.9) 201.11,98.9 201.37,98.64 201.37,97.77 v2(201.1,97.5) 201.12,97.5 201.37,97.24 201.37,96.37 v2(201.1,96.1) ; v2(188.43,89.1) 188.37,89.15 v2(188.37,89.8) 188.37,90.27 PC6318.1 188.37,90.75 v2(188.37,91.2) ; v2(201.1,91.2) 201.1,90.63 ; v2(191.2,98.9) 191.47,98.63 191.47,98.2 191.2,97.93 v2(191.2,97.5) v2(191.2,96.1) ; PC6317.1 188.51,105.31 v2(188.4,105.2) ; v2(203.9,91.2) 203.93,91.17 PC6342.1 203.93,89.83 v2(203.9,89.8) ; v2(203.93,103.8) 203.86,103.87 PC6314.1 203.93,104.55 v2(203.93,105.2) 203.93,105.87 v2(203.9,105.9) ; v2(201.1,105.9) 201.13,105.87 v2(201.13,105.2) 201.13,104.68 PC6337.1 200.93,103.97 v2(201.1,103.8) ; v2(193.95,89.8) 193.82,89.93 PC6336.1 193.82,91.02 v2(194,91.2) ; PC6339.1 191.64,105.45 v2(191.2,105.9) 190.83,105.53 PC6321.1 190.83,104.87 v2(191.2,104.5) 191.21,104.49 191.21,104 191.2,103.99 v2(191.2,103.8) ; v2(194,103.8) 194,104.43 193.94,104.48 193.96,104.5 v2(194,104.5) 194,105.06 PC6316.1 193.88,105.78 v2(194,105.9) ; v2(198.3,91.2) v2(198.3,90.5) 198.3,89.93 PC6343.1 198.25,89.16 v2(198.3,89.1) ; v2(191.2,91.2) 191.2,90.82 PC6340.1 191.17,90.24 v2(191.17,89.8)
  TOP w0.3: 201.1,90.63 v2(201.1,90.5) ; v2(193.95,89.8) 194,89.75 194,89.07 v2(193.99,89.06) ; v2(191.17,89.8) 191.17,89.13 v2(191.2,89.1) ; v2(196.05,105.21) 196.1,105.26 196.1,105.88 v2(196.07,105.91) ; v2(198.3,105.9) v2(198.3,105.2) ; v2(203.9,89.8) v2(203.9,89.1)
  TOP w0.356: v2(201.1,89.1) 201.1,89.85 PC6341.1 201.1,89.91 v2(201.1,90.5)
  TOP w0.381: v2(196.2,90.5) 196.2,90.29 196.47,90.02 PC6320.1 196.2,89.61 v2(196.2,89.1) ; v2(196.2,90.5) 196.19,90.51 PC6319.1 ; v2(196.2,90.5) v2(196.2,91.2)
  TOP w0.508: v2(190.02,41.29) 188.83,42.48 RG542.1
  IN3 w0.508: 187.02,107.4 186.45,107.97 179.53,107.97 176.8,110.7 v2(173.94,110.7) ; v2(190.02,41.29) 190.21,41.29 191.4,40.09 191.4,33.87 198.27,27.01 202.55,27.01 204.01,28.47 205.25,28.47 206.26,27.46 206.26,27.24 207.53,25.97 210.48,25.97 211.34,25.11 221.44,25.11 222.2,24.34 225.25,24.34 229.76,28.85 229.76,29.98 233.94,34.16 233.94,37.71 236.73,40.5 240.59,40.5 248.5,48.41 250.95,48.41 253.41,50.87 253.41,57.65 v2(253.76,58)
  IN4 w0.508: v2(245.7,77.3) 246.25,77.3 247.75,75.8 247.75,71.61 251.81,67.55 254.2,67.55 257.55,64.21 257.55,60.86 254.69,58 v2(253.76,58)
  BOTTOM w0.254: PR6223.1 v2(173.94,110.7)
  vias: v2(187.78,106.6) v2(188.4,98.9) v2(188.4,97.5) v2(188.4,96.1) v2(196.1,98.9) v2(196.2,96.1) v2(214.83,63.02) v2(215.15,63.52) v2(215.53,64.35) v2(215.47,63.02) v2(215.79,63.52) v2(216.1,65.37) v2(216.1,64.73) v2(216.1,64.1) v2(216.1,63.02) v2(216.42,65.94) v2(216.42,63.52) v2(216.61,66.95) v2(216.74,65.37) v2(216.74,64.73) v2(216.74,64.1) v2(216.74,63.02) v2(216.93,67.46) v2(216.93,66.45) v2(217.06,63.52) v2(217.25,66.95) v2(217.37,63.02) v2(217.57,67.46) v2(217.57,66.45) v2(217.69,63.52) v2(217.88,66.95) v2(218.01,63.02) v2(218.2,67.46) v2(218.2,66.45) v2(218.33,63.52) v2(218.52,66.95) v2(218.64,63.02) v2(218.84,67.46) v2(218.84,66.45) v2(218.96,63.52) v2(219.15,66.95) v2(219.28,63.02) v2(219.47,67.46) v2(219.47,66.45) v2(219.66,63.52) v2(219.79,66.95) v2(219.98,63.02) v2(220.11,67.46) v2(220.11,66.45) v2(220.42,66.95) v2(220.42,65.87) v2(220.42,65.24) v2(220.42,64.6) v2(220.36,63.52) v2(220.74,67.46) v2(220.74,66.45) v2(220.68,63.02) v2(220.93,65.56) v2(220.93,64.92) v2(220.93,64.29) v2(220.95,63.53) v2(221.06,66.95) v3(228.72,63.87)
+PEX_PLL_HVDD: length 3.3
  TOP w0.457: v2(185.65,100.2) v1(186.21,100.2) 187.05,100.2 CG34.1 187.09,99.23 LG1.1
  BOTTOM w0.254: UG9.BB30 185.4,99.95 v2(185.65,100.2)
+PEX_VDD: length 24.9
  TOP w0.4: v2(184.9,103.15) 184.95,103.2 184.95,104.4 v2(184.9,104.45)
  TOP w0.508: CG5.1 CG43.1 179.1,95.35 CG3.1 CG48.1 184.53,95.35
  BOTTOM w0.25: UG9.BC17 v2(184.9,90.55) ; UG9.BC15 v2(184.9,89.75)
  BOTTOM w0.254: v2(185.65,102.3) 185.4,102.05 UG9.BB33 ; v2(185.75,93.67) 185.73,93.65 UG9.BB21 ; v2(185.65,103.2) 185.4,103.45 UG9.BB35 ; UG9.BC23 v2(184.9,94.75) ; UG9.BB23 185.4,95.05 v2(185.65,94.8)
  BOTTOM w0.3: UG9.BC33 v2(184.9,102.35) ; UG9.BD33 v2(184.2,102.35) ; UG9.BC36 v2(184.9,104.45) ; UG9.BD36 v2(184.2,104.45) ; UG9.BB36 185.6,103.85 v2(185.62,103.85) ; UG9.BC35 v2(184.9,103.15)
  BOTTOM w1.524: 176.22,148.38 176.22,143.66 175.08,142.52 175.08,140.74 176.61,139.22
  vias: v2(173.61,151.76) v2(174.23,151.55) v2(174.45,150.95) v2(177.49,138.28) v2(177.49,137.65) v2(177.49,137.01) v2(177.49,136.38) v2(178,138.58) v2(178,137.97) v2(178,137.33) v2(178,136.7) v2(184.9,93.95) v2(184.9,92.65) v2(184.9,91.85) v3(177.57,143.81)
+RBIAS: length 3.7
  BOTTOM w0.203: UL1.10 202.69,152.26 203.04,152.61 203.39,152.61 ; RL3.1 v1(205.79,152.78)
  BOTTOM w0.508: RL3.1 204.68,152.61 203.39,152.61
+RTC_CELL: length 354.4
  TOP w0.381: RH531.2 181.3,47.24 RH83.1
  TOP w0.508: RH84.1 181.5,48.97 180.42,48.97 v2(180.4,48.96) 180.38,48.94 180.38,48.67 181.07,47.99 RH531.2 ; CH173.1 CH80.1 178.84,42.15 179.46,42.77 v2(179.46,42.88) ; PD5.1 258.01,53.67 257.61,53.27 256.95,53.27 249.66,45.98 249.66,39.11 v3(251.11,37.67) 251.72,37.06 v2(251.72,36.35) ; v2(33.89,35.96) 33.29,35.96 RA25.2
  IN1 w0.508: v2(179.46,42.88) 179.7,42.88 181.34,44.52 181.34,48.01 180.4,48.95 v2(180.4,48.96)
  IN2 w0.508: v2(251.72,36.35) 250.62,36.35 242.67,28.4 242.67,16.11 240.39,13.83 240.39,13.83 236.41,9.86 226.29,9.86 226,9.57 224.53,9.57 223.15,10.95 219.34,10.95 214.43,6.04 212.9,6.04 212.59,5.73 202.87,5.73 201.12,7.48 193.34,7.48 186.64,14.18 186.64,15.47 184.88,17.23 184.88,27.46 183.72,28.62 179.27,28.62 178.66,28 178.66,22.96 v2(178.3,22.6) 177,21.3 168.61,21.3 167.97,20.66 160.11,20.66 157.81,18.36 151.74,18.36 150.07,16.69 145.68,16.69 143.46,14.47 139.25,14.47 138.45,13.67 119.08,13.67 117.88,12.47 116.55,12.47 115.7,11.62 115.7,10 113.52,7.82 104.1,7.82 103.41,8.51 97.03,8.51 96.81,8.72 94.06,8.72 93.23,7.9 87.7,7.9 87.3,8.29 85.65,8.29 83.22,10.72 68.99,10.72 67.76,11.95 67.05,11.95 66.76,12.24 48.84,12.24 45.09,15.99 36.99,15.99 32.63,20.35 32.63,24.87 32.63,24.87 32.63,25.38 32.63,25.38 32.63,26.9 32.41,27.12 32.41,29.93 32.66,30.18 35.26,32.77 35.26,33.87 33.89,35.24 v2(33.89,35.96)
  IN5 w0.508: v2(179.46,42.88) 179.77,42.88 181.36,41.29 181.36,30.11 180.05,28.8 179.26,28.8 178.35,27.89 178.35,22.65 v2(178.3,22.6)
  BOTTOM w0.203: UH1.BA22 179.89,42.49 179.64,42.84 v2(179.46,42.88)
+TBTA_VBUS:
  vias: v1(129.4,150.91) v2(114.57,168.87) v2(114.57,168.24) v2(114.57,167.6) v2(115.08,169.19) v2(115.08,168.55) v2(115.08,167.92) v2(115.58,168.87) v2(115.58,168.24) v2(127.81,147.83) v2(128.26,147.42) v2(129.3,153.32) v2(129.29,152.73) v2(129.29,152.12) v2(129.88,153.32) v2(129.87,152.73) v2(129.87,152.12) v2(157.6,172.04) v2(158.27,170.15) v2(158.33,169.55) v2(160.11,170.02) v2(160.11,169.2) v2(160.51,172.13) v2(160.79,167.77)
+V_DDR_REFA: length 5.7
  TOP w0.508: RH484.2 RH209.1 CD18.1 RH206.2 123.89,40.75 v2(124.51,40.13)
  BOTTOM w0.305: v2(124.51,40.13) 124.77,40.39 JDIMM1.164
+V_DDR_REFA_R: length 65.6
  TOP w0.508: CH101.1 126.1,43.47 126.51,43.06 v2(126.83,43.06) 126.83,42.69 126.56,42.43 RH484.1
  IN4 w0.508: v2(105.11,93.55) 104.88,93.55 104.53,93.2 104.53,92.47 105.17,91.83 105.17,89.2 105.74,88.63 110.88,88.63 111.52,87.99 111.52,65.85 122.92,54.45 122.92,50.43 125.55,47.8 125.55,44.05 126.54,43.06 v2(126.83,43.06)
+V_DDR_REFB: length 5.6
  TOP w0.508: RH207.2 RH485.2 RH210.1 CD29.1 124.77,30.35 v2(124.62,30.5)
  BOTTOM w0.305: JDIMM2.164 124.78,30.34 v2(124.62,30.5)
+V_DDR_REFB_R: length 78.7
  TOP w0.508: RH485.1 CH100.1 v2(122.99,26.84)
  IN4 w0.508: v2(103.81,92.75) 103.81,91.91 103.29,91.39 103.29,90.92 104.29,89.92 104.29,86.4 105.61,85.07 108.11,85.07 108.5,84.69 108.5,83.28 106.88,81.67 106.88,79.84 110.5,76.22 110.5,65.43 121.91,54.03 121.91,35.82 122.57,35.16 122.57,28.93 122.99,28.51 v2(122.99,26.84)
AC_PRESENT: length 10.9
  BOTTOM w0.089: 184.35,44.15 184.35,44.75 183.92,45.18 182.13,45.18 181.89,45.42 181.58,45.42 181.52,45.48 180.76,45.48 180.52,45.73 UH1.BB15
  BOTTOM w0.114: 184.35,44.15 184.97,43.54 RH533.1 184.97,43.07 185.13,42.91 v1(187.45,42.91) 188.24,42.12 DH1.2
ACDET_CHG: length 4.4
  TOP w0.203: PR716.2 v2(61.52,36.16) 61.36,36.16 60.93,35.73 PU700.6
  BOTTOM w0.114: v2(61.52,36.16) v1(61.02,36.16)
  BOTTOM w0.254: PR719.1 PC719.1 61.73,35.96 v2(61.52,36.16)
ACDRV_CHG: length 1.9
  TOP w0.203: PU700.4 62.11,34.93 PR705.2
AD0_1: length 2.3
  BOTTOM w0.114: UE4.31 v1(174.1,21.7) 174.1,22.09 RE27.1
AD0_2: length 1.5
  TOP w0.114: UE3.31 186.79,153.09 RE43.2
AD1_1: length 3.7
  BOTTOM w0.114: UE4.32 174.6,20.99 174.94,21.33 175.81,21.33 v1(176.14,21.67) 176.49,21.67 176.73,21.42 RE26.2
AD1_2: length 2.8
  TOP w0.114: v1(187.57,155.33) 187.13,154.89 RE40.2 186.34,153.59 UE3.32
AD2_1: length 3.6
  BOTTOM w0.114: v1(178.61,19.88) 178.24,20.25 177.21,20.25 RE29.1 176.7,19.74 UE4.1
AD2_2: length 2.9
  TOP w0.114: UE3.1 185.02,154.75 RE42.1 186.15,155.67 v1(186.91,156.42)
AD3_1: length 3.5
  BOTTOM w0.114: UE4.2 176.33,19.24 RE30.1 177.25,18.32 v1(178.51,18.32)
AD3_2: length 2.5
  TOP w0.114: UE3.2 184.52,154.74 185.04,155.27 RE44.1 v1(184.05,155.66)
AD_BID: length 5.1
  TOP w0.114: v1(103.14,24.34) 102.87,24.08 RE64.1 RE66.1 CE28.1 101.07,23.31 100.8,23.04 100.8,22.79 100.67,22.66 UE5.66
ADP_I: length 64
  TOP w0.114: PR717.2 63.4,38.81 63.82,38.39 v2(63.82,37.92) ; v2(101.49,22.7) 101.07,22.28 UE5.65 ; PR23.2 v3(78.6,15.69) 77.36,16.93 77.36,22.97 v2(77.57,23.18)
  IN2 w0.097: v2(63.82,37.92) 71.65,37.92 73.93,35.65 73.93,26.82 v2(77.57,23.18) 78.09,22.65 80.55,22.65 81.76,23.86 84.69,23.86 84.71,23.84 92.44,23.84 92.6,24 94.61,24 95.09,23.52 96.41,23.52 97.13,22.79 101.39,22.79 v2(101.49,22.7)
ADPIN: length 1.7
  TOP w0.114: v2(35.47,44.56) v3(34.91,44.56) ; v2(35.78,54.6) v3(35.78,54.04) ; v2(37.94,44.56) v3(38.5,44.56)
  vias: v2(34.39,54.6) v2(35.08,54.6) v2(36.16,44.56) v2(37.31,44.56)
ALERT#: length 31.2
  TOP w0.114: QG501.4 185.34,74.98 185.78,74.55 RG504.1 185.78,74.08 186.51,73.34 186.76,73.34 v2(187.35,72.74) 187.73,72.36 v1(187.73,72.2)
  IN2 w0.089: 190.7,78.19 190.7,78.78 189.07,80.42 184.23,80.42 182.77,81.88 181.81,81.88 181.21,81.27 181.21,79.95 180.95,79.69 180.65,79.69 180.1,80.24 v2(180.1,80.75)
  IN2 w0.097: v2(187.35,72.74) 187.58,72.97 188.43,72.97 188.79,72.62 188.79,71.6 189.25,71.14 190.3,71.14 190.7,71.54 190.7,78.19
  BOTTOM w0.114: UG9.BJ3 v2(180.1,80.75)
ALIEN_LED_B_DRV#: length 17.5
  TOP w0.114: v2(195.45,156.98) 195.86,157.39 JLOGO.5 ; v2(183.11,155.19) 183.02,155.09 UE3.5
  IN1 w0.097: v2(183.11,155.19) 183.11,154.95 183.42,154.64 186.01,154.64 186.45,154.2 189.28,154.2 190.11,155.03 191.09,155.03 191.91,155.85 191.91,156.59 192.8,157.48 195.05,157.48 195.45,157.08 v2(195.45,156.98)
  BOTTOM w0.114: v2(183.11,155.19) 183.11,155.63 v1(183.02,155.73)
ALIEN_LED_G_DRV#: length 19.6
  TOP w0.114: JLOGO.4 196.86,158.82 v2(196.47,159.21) ; v2(183.71,155.17) 183.52,154.97 UE3.4
  IN1 w0.097: v2(196.47,159.21) 196.47,159.2 195.23,157.95 192.61,157.95 191.4,156.74 191.4,156.04 190.9,155.54 189.69,155.54 189.12,156.11 189.12,156.42 188.99,156.55 188.04,156.55 187.3,155.81 184.35,155.81 v2(183.71,155.17)
  BOTTOM w0.114: v2(183.71,155.17) 183.71,154.89 184.46,154.14 v3(184.55,154.14)
ALIEN_LED_R_DRV#: length 21.4
  TOP w0.114: UE3.3 184.02,154.87 v2(184.3,155.15) ; v1(197.82,155.85) 197.82,156.11 197.86,156.15 JLOGO.3 197.86,158.69 v2(198.32,159.16)
  IN1 w0.097: v2(198.32,159.16) 196.86,157.69 192.67,157.69 191.66,156.68 191.66,155.92 191.02,155.28 189.56,155.28 189.31,155.54 188.8,155.54 187.66,154.4 186.53,154.4 186.03,154.9 184.55,154.9 v2(184.3,155.15)
AMD#_NV: length 236.1
  TOP w0.114: v1(70.99,4.52) 70.72,4.8 70.72,5.64 v2(70.75,5.68) 70.72,5.71 70.72,5.94 70.47,6.18 UE6.20 ; UE1.17 v2(268.62,47.84)
  IN3 w0.124: v2(70.75,5.68) 70.89,5.68 71.21,5.99 73.61,5.99 75.58,7.96 92.41,7.96 93.17,8.72 93.17,9.7 93.47,10.01 93.47,10.97 93.49,10.99 93.49,11.77 93.8,12.09 94.69,12.09 95.2,11.58 98.44,11.58 103.33,6.69 129.55,6.69 130.34,7.48 135.6,7.48 141.48,13.36 145.69,13.36 146.57,14.23 150.05,14.23 150.82,15.01 160.33,15.01 163.51,11.84 174.84,11.84 176.51,13.5 183.81,13.5 184.44,12.88 188.6,12.88 193.32,8.16 202.08,8.16 203.02,7.22 215.97,7.22 219.79,11.04 235.93,11.04 249.78,24.88 249.78,28.33 252.54,31.09 252.54,32.84 267.54,47.84 v2(268.62,47.84)
AMP_ASEL: length 0.9
  TOP w0.114: v2(27.26,25.66) 27.26,25.31 27.31,25.25 UA4.18
AMP_I2S_BCLK: length 26.9
  TOP w0.114: v1(32.53,43.88) v2(32.53,43.35) 32.53,42.68 32.53,42.67 RA29.2 CA38.1 ; v2(30.43,22.63) 30.33,22.53 30.2,22.53 29.9,22.22 UA4.10
  IN4 w0.137: v2(30.43,22.63) 29.94,23.11 29.94,24.21 31.85,26.12 31.85,28.19 31.7,28.35 31.7,33.8 32.33,34.43 32.33,35.09 33.79,36.55 33.79,37.19 34.22,37.62 34.22,38.23 33.54,38.91 33.45,38.91 32.53,39.82 v2(32.53,43.35)
AMP_I2S_BCLK_R: length 3.4
  TOP w0.114: RA29.1 31.56,42.62 v1(30.71,41.77) 30.42,41.48 v2(30.18,41.48)
  BOTTOM w0.114: v2(30.18,41.48) 29.77,41.48 29.52,41.22 29.34,41.22 29.21,41.35 UA1.56
AMP_I2S_MCLK: length 27
  TOP w0.114: v2(31.03,22.63) 30.54,22.14 v1(30.54,22.13) 30.23,21.82 UA4.9
  IN4 w0.137: v2(31.03,22.63) 32.38,23.98 32.38,24.96 32.91,25.49 32.91,28.73 32.75,28.88 32.75,32.6 34.38,34.22 34.38,34.58 35.57,35.78 35.57,39.08 33.61,41.04 v2(33.61,43.26)
  BOTTOM w0.114: v2(33.61,43.26) 33.46,43.1 CA39.1 RA27.2
AMP_I2S_MCLK_R: length 5.6
  BOTTOM w0.114: UA1.55 28.81,41 28.94,40.87 29.51,40.87 29.7,41.06 30.47,41.06 30.59,41.19 30.59,41.65 31.56,42.62 RA27.1 31.61,43.33 v1(31.85,43.57)
AUD_HP_OUT_L_CN: length 14.1
  TOP w0.114: v2(14.49,18.38) v3(14.01,17.9)
  TOP w0.254: v2(14.49,18.38) DA4.3 15.96,17.74 LA9.1 14.78,15.75 CA42.1
  BOTTOM w0.254: v2(14.49,18.38) 14.38,18.27 14.38,13.38 13.43,12.43 11.86,12.43 JACK1.1
AUD_HP_OUT_R_CN: length 17.1
  TOP w0.114: v2(14.99,20.83) 14.99,21.62 v3(14.75,21.87)
  TOP w0.254: v2(14.99,20.83) 15.51,20.31 DA4.2 16.13,20.48 LA10.1 16.13,23.41 CA43.1
  IN1 w0.254: v2(14.99,20.83) 14.99,21.4 12.55,23.84 6.8,23.84 5.99,23.02 JACK1.2
AUDIO_IRQ: length 3.1
  TOP w0.114: RA24.2 31.78,39.13 v2(31.23,38.58) 30.73,38.58 v1(30.31,39)
  BOTTOM w0.114: v2(31.23,38.58) 30.78,38.58 30.58,38.78 UA1.6
B+: length 622.7
  TOP w0.508: PQ3.4 49.27,11.07 49.48,11.28 50.12,11.28 PC10.1 51.4,10.66 PR12.1 52.46,10.18 52.66,10.37 57.1,10.37 62.45,15.72 67.4,15.72 68.59,16.92
  TOP w1.016: 119.74,142.95 121.11,141.58 132.35,141.58
  TOP w1.524: 119.74,150.16 119.74,142.95 118.03,141.24 110.29,141.24 108.47,139.42 108.47,130.07 105.17,126.77 105.17,124.8 100.36,120 95.33,120
  TOP w2.032: 203.56,17.16 202.34,15.94 197.14,15.94 195.23,17.86 185.6,17.86 183.04,15.3 180.45,15.3 179.68,14.53 176.25,14.53 174.3,12.57 168.77,12.57 164.03,7.83 164.03,5.19
  TOP w3.048: 245.5,4.4 248.37,7.27 248.37,35.27 245.94,37.71 245.94,41.02
  TOP w3.556: 87.83,118.85 85.67,116.69 85.67,101.26 83.58,91.82 83.58,80.65 85.04,79.19 85.04,69.74 77.17,61.87 77.17,55.22
  IN1 w2.54: 87.78,2.46 104.4,2.46
  IN2 w2.54: 87.48,2.46 87.76,2.18 104.34,2.18 104.62,2.46 ; 139.98,2.46 112.98,2.46
  IN2 w3.048: 179.92,2.84 167.18,2.84
  IN3 w2.54: 104.56,2.48 104.33,2.25 86.88,2.25 86.66,2.47 ; 139.62,2.47 112.98,2.47
  IN3 w3.048: 169.28,2.81 180.56,2.81
  IN4 w2.54: 104.94,2.47 104.59,2.12 87,2.12 86.66,2.47 ; 139.62,2.47 113.03,2.47
  IN4 w3.048: 168.4,2.79 179.3,2.79 179.31,2.81
  IN5 w2.54: 104.52,2.44 104.33,2.25 87.33,2.25 87.13,2.44 ; 139.71,2.44 112.99,2.44
  IN5 w3.048: 167.21,2.79 180.54,2.79
  BOTTOM w1.016: 163.21,146.14 163.21,143.66 160.1,140.55 133.59,140.55 132.87,141.27
  BOTTOM w3.048: 242.24,41.53 248.26,35.51 248.26,6.7 245.53,3.97
  BOTTOM w3.556: 75.83,55.84 75.83,60.41 84.69,69.27 84.69,81.07 83.89,81.87 83.89,87.96 85.67,89.74 85.67,115.67
  vias: v2(49.48,29.61) v2(49.52,27.86) v2(50.23,29.29) v2(50.23,28.66) v2(50.23,28.02) v2(50.79,29.62) v2(50.79,28.98) v2(50.79,28.35) v2(50.79,27.71) v2(50.79,27.08) v2(51.39,29.3) v2(51.39,28.66) v2(61.41,44.53) v2(61.41,43.89) v2(61.41,43.26) v2(61.41,42.62) v2(61.41,41.99) v2(61.42,41.36) v2(61.99,44.53) v2(61.99,43.89) v2(61.99,43.26) v2(61.99,42.62) v2(61.99,41.99) v2(62.02,41.35) v2(62.63,44.53) v2(62.63,43.89) v2(62.63,43.26) v2(62.63,42.62) v2(62.63,41.99) v2(62.63,41.35) v2(63.26,44.53) v2(63.26,43.89) v2(63.26,43.26) v2(63.26,42.62) v2(63.26,41.99) v2(63.26,41.35) v2(73.46,16.31) v2(73.48,15.33) v2(73.79,16.84) v2(73.79,15.83) v2(73.93,54.04) v2(73.93,53.34) v2(73.93,52.7) v2(73.94,52.09) v2(74.11,16.33) v2(74.11,15.32) v2(74.44,53.72) v2(74.44,53.02) v2(74.44,52.41) v2(74.43,16.84) v2(74.42,15.82) v2(74.73,16.31) v2(74.74,15.33) v2(74.94,53.31) v2(74.94,52.7) v2(74.94,52.07) v2(75.06,16.84) v2(75.05,15.83) v2(75.38,16.33) v2(75.39,15.33) v2(75.7,16.84) v2(75.7,15.83) v2(83.13,2.49) v2(83.13,1.43) v2(83.45,3.01) v2(83.45,1.95) v2(83.72,2.49) v2(83.72,1.43) v2(84.04,3.01) v2(84.04,1.95) v2(84.3,2.49) v2(84.3,1.43) v2(84.62,3.01) v2(84.62,1.95) v2(84.89,2.49) v2(84.89,1.43) v2(85.21,3.01) v2(85.21,1.95) v2(92.6,118.98) v2(92.6,118.28) v2(92.6,117.58) v2(93.23,118.98) v2(93.23,118.28) v2(93.23,117.58) v2(93.87,118.98) v2(93.87,118.28) v2(93.87,117.58) v2(94.5,118.98) v2(94.5,118.28) v2(94.5,117.58) v2(132.54,142.26) v2(133.11,142.45) v2(149.53,2.95) v2(149.53,2.19) v2(149.53,1.49) v2(150.23,2.95) v2(150.23,2.19) v2(150.23,1.49) v2(150.93,2.95) v2(150.93,2.19) v2(150.93,1.49) v2(164.28,3.98) v2(164.28,3.39) v2(164.35,2.79) v2(164.43,2.16) v2(164.71,1.54) v2(165,3.94) v2(165,3.35) v2(165,2.77) v2(165.01,2.15) v2(238.78,43.26) v2(238.8,42.67) v2(238.93,44.79) v2(238.94,43.84) v2(239.28,44.31) v2(239.48,43.26) v2(239.5,42.67) v2(239.63,44.79) v2(239.63,43.84) v2(239.98,44.31) v2(240.18,43.26) v2(240.33,44.79) v2(240.33,43.84) v2(240.68,44.31) v2(241.04,44.78) v2(241.4,44.3) v2(241.44,3.12) v2(241.44,2.07) v2(241.76,3.64) v2(241.76,2.59) v2(242.02,3.12) v2(242.02,2.07) v2(242.34,3.64) v2(242.34,2.59) v2(242.61,3.12) v2(242.61,2.07) v2(242.93,3.64) v2(242.93,2.59) v2(243.19,3.12) v2(243.19,2.07) v2(243.51,3.64) v2(243.51,2.59) v3(241.81,38.37)
B+_BIAS: length 203.9
  TOP w0.254: R179.2 201.35,1.89 199.51,1.89 199.09,2.31 197.54,2.31 196.79,1.56 185,1.56 v3(182.89,3.67) 182.88,3.67 v2(181.61,4.94)
  IN4 w1.524: 45.53,11.94 43.71,11.94 43.06,12.6 34.15,12.6 32.42,10.87 25.39,10.87 24.68,11.58 24.68,13.69 23.99,14.38 20.86,14.38 20.69,14.55
  IN5 w0.457: v2(181.61,4.94) 179.08,7.47 174.6,7.47 174.4,7.68 172.62,7.68 172.15,8.15 165.34,8.15 160.83,12.66 151.02,12.66 149.56,11.2 145.17,11.2 139.95,16.43 125.51,16.43 125.36,16.28 125.36,13.74 124.22,12.6 123.08,12.6 122.63,12.15 122.63,8.1 121.74,7.2 101.13,7.2 100.44,6.51 97.11,6.51 96.42,5.83 83.97,5.83 79.68,1.53 68.94,1.53 68.17,2.3 68.17,3.89 65.99,6.07 65.99,6.44 65.27,7.16 56.66,7.16 56.36,6.86 50.82,6.86 50.41,7.26 v2(47.83,7.26)
  vias: v2(18.81,15.03) v2(19.13,14.39) v2(19.44,15.03) v2(46.73,12.11) v2(47.23,12.43) v2(47.23,11.8)
B+_VCCIO:
  vias: v1(88.3,107.95) v2(89.61,108.25) v2(89.61,107.61)
BATDRV_CHG: length 1.8
  TOP w0.203: PR733.2 55.08,35.13 55.28,34.93 PU700.18
BATLOW#: length 9.2
  TOP w0.089: UT1.F2 144.57,158.28 144.35,158.06 143.66,158.06
  TOP w0.114: 143.66,158.06 143.5,158.06 143.15,157.7 v1(143.15,157.64) 143.22,157.57 143.22,156.69 142.91,156.39 142.5,156.39 141.67,155.56 140.76,155.56 140.62,155.42 140.62,154.24 140.17,153.79 139.66,153.79 139.35,153.48 RT31.2 RT14.1
BATSRC_CHG: length 2.6
  TOP w0.203: PU700.17 55.64,35.33 v2(55.56,35.41) 54.94,36.03 PR734.2
  BOTTOM w0.114: v1(56.08,35.53) 55.96,35.41 v2(55.56,35.41)
BATT+: length 0.8
  TOP w0.114: v2(68.23,21.26) v3(68.23,20.5)
  vias: v2(68.23,24.56) v2(68.87,24.56) v2(68.87,21.26) v2(69.5,24.56) v2(69.5,21.26)
BATT++: length 13.5
  TOP w0.254: PD700.2 63.02,28.54 61.67,28.54 v3(61.09,27.95) v3(61.09,25.91) 61.09,21.35 61.56,20.87 v3(62.19,20.87) 63.03,20.87 63.79,21.63 v2(64.12,21.63)
  vias: v2(63.98,20.81) v2(64.61,20.81) v2(64.67,18.15) v2(65.25,20.81) v2(65.26,18.15) v2(65.26,17.51) v2(65.26,16.88) v2(65.88,20.81) v2(65.86,18.14) v2(65.86,17.5) v2(65.86,16.87)
BATT_CHG_LED: length 6.9
  TOP w0.114: UE1.25 260.43,44.98 259.79,45.62 v1(259.49,45.62) 256.94,45.62 256.6,45.95 QE1.6 256.6,47.08 RE23.2
BATT_CHG_LED#: length 199.1
  TOP w0.114: UE5.90 91.07,20.14 v2(91.09,20.12) ; v2(257.57,45.11) 257.25,44.79 QE1.2
  IN1 w0.097: v2(257.57,45.11) 256.74,44.28 256.36,44.28 255.41,43.33 255.41,38.75 253.51,36.85 252.93,36.85 250.9,34.82 250.9,34.47 229.69,13.26 225.59,13.26 225.19,12.85 218.64,12.85 215.6,9.8 213.5,9.8 211.52,7.82 193.03,7.82 188.3,12.56 185.56,12.56 183.83,14.29 181.3,14.29 179.82,15.77 171.37,15.77 168.42,18.71 168.02,18.71 167.15,19.58 165.31,19.58 160.54,24.35 156.55,24.35 155.1,25.79 143.56,25.79 142.8,25.04 125.41,25.04 124.68,24.31 119.39,24.31 118.8,24.9 106.42,24.9 105.81,24.29 104.02,24.29 102.59,25.71 101.97,25.71 100.94,24.69 98.85,24.69 98.04,23.88 97.02,23.88 93.98,20.84 91.4,20.84 91.06,20.49 91.06,20.15 v2(91.09,20.12)
  BOTTOM w0.114: v2(91.09,20.12) v1(90.57,20.12)
BATT_LOW_LED: length 5.1
  TOP w0.114: QE3.6 262.79,49.24 RE21.2 264.44,48.58 v1(264.44,48.34) 264.62,48.16 UE1.22
BATT_LOW_LED#: length 208.8
  TOP w0.114: v2(88.98,20.15) 89.75,20.15 89.87,20.27 UE5.93 ; v2(251,43.41) 251,46.35 257.25,52.6 260.72,52.6 261.51,51.81 QE3.2 ; v2(222.33,22.44) 221.97,22.08 221.97,21.54 v3(220.94,20.51) 220.94,18.03 218.49,15.58 215.97,15.58 214,13.61 214,12.01 213.63,11.64 v2(186.31,11.64)
  IN1 w0.097: v2(88.98,20.15) 89.42,19.7 91.45,19.7 91.58,19.83 91.58,20.47 91.73,20.62 95.38,20.62 99.26,24.49 102.95,24.49 103.35,24.09 105.9,24.09 106.51,24.7 118.68,24.7 119.29,24.09 128.85,24.09 129.58,24.82 142.9,24.82 143.65,25.57 155.01,25.57 156.46,24.13 160.48,24.13 165.28,19.33 167.09,19.33 167.9,18.52 168.34,18.52 171.29,15.57 179.74,15.57 181.22,14.09 183.62,14.09 186.08,11.64 v2(186.31,11.64)
  IN4 w0.137: v2(251,43.41) 250.71,43.7 247.35,43.7 242.31,38.66 235.97,38.66 231.64,34.34 231.64,33.19 227.93,29.47 227.93,27.18 223.19,22.44 v2(222.33,22.44)
BATT_PRS: length 7.4
  TOP w0.114: v1(57.48,9.36) 57.79,9.05 v2(57.79,8.55)
  TOP w0.254: v2(57.79,8.55) PR22.1
  BOTTOM w0.254: PBATT1.6 56.85,9.5 v2(57.79,8.55)
BEEP#: length 95.2
  TOP w0.114: v2(31.16,24.36) 32.58,25.78 v3(32.58,30.43) 32.58,30.7 34.01,32.13 DA1.2 ; UE5.23 97.47,7.36 97.1,7.73 97.1,10.75 97.37,11.02 v2(97.37,11.12)
  IN5 w0.097: v2(31.16,24.36) 31.59,23.93 31.59,19.77 34.71,16.65 34.71,13.35 35.27,12.8 39.17,12.8 41.37,10.6 60.37,10.6 62,8.97 70.49,8.97 72.59,11.07 81.42,11.07 83.43,9.07 85.96,9.07 86.88,9.99 92.34,9.99 92.6,10.25 94.12,10.25 95.29,11.42 97.07,11.42 v2(97.37,11.12)
BKOFF#: length 206.2
  TOP w0.114: v2(88.47,16.72) 88.29,16.54 UE5.105
  IN3 w0.124: v2(133.54,153.34) 132.7,152.5 132.7,149.29 131.4,147.98 131.4,146.96 129.87,145.44 127.5,145.44 126.71,144.65 v2(126.71,144.64)
  IN4 w0.137: v2(126.71,144.64) 126.03,143.96 111.46,143.96 110.26,145.16 101.72,145.16 100.99,144.43 100.99,143.92 99.46,142.39 95.77,142.39 95.47,142.7 v2(95.47,144.97)
  IN5 w0.097: v2(88.47,16.72) 88.72,16.98 88.72,19.48 86.45,21.76 76.85,21.76 75.58,23.03 75.58,47.38 78.08,49.88 78.08,55.42 83.87,61.2 83.87,90.8 85.31,92.24 85.31,142.89 86.73,144.32 88.91,144.32 89.56,144.97 93.13,144.97 93.61,145.45 94.99,145.45 v2(95.47,144.97)
  BOTTOM w0.114: v2(133.54,153.34) 133.54,154.72 DV1.2 132.75,154.82 v1(132.14,155.44)
BST_1.2V: length 1.2
  TOP w0.114: v1(66.05,47.2) 65.68,47.58 PC204.1
BST_5V: length 1.3
  BOTTOM w0.114: PR109.1 v1(36.83,24.02)
BST_+1VALWP:
  vias: v1(211.71,17.75)
BST_VCCIO: length 0.5
  TOP w0.114: v2(89.74,104.86) v1(89.74,104.35)
BT_OFF#: length 212.7
  TOP w0.114: RN17.2 293.13,60.16 293.91,60.93 293.91,62.34 294.39,62.83 v2(295.29,62.83)
  IN2 w0.104: v2(295.29,62.83) 295.8,62.83 297,61.62 297.37,61.62 301.7,57.29 301.7,55.52 305.17,52.06 305.17,39.81 300.36,35 283.36,35 280.35,38.01 251.42,38.01 242.06,28.65 242.06,16.37 236.46,10.77 232.32,10.77 231.56,11.53 224.56,11.53 224.29,11.81 218.85,11.81 213.91,6.86 212.56,6.86 212.25,6.55 203.21,6.55 201.46,8.3 193.68,8.3 189.02,12.95 189.02,17.41 186.57,19.86 186.57,24.03 v2(186.62,24.09)
  IN5 w0.097: v2(186.62,24.09) 185.61,24.09 184.09,22.57 180.16,22.57 179.76,22.17 178.15,22.17 177.89,22.43 177.89,23.2 177.28,23.82 174.36,23.82 174.15,24.02 174.15,25.67 177.94,29.45 v2(177.94,29.73)
  BOTTOM w0.089: v2(177.94,29.73) 178.58,30.37 178.58,31.11 178.65,31.18 178.65,31.49 UH1.AV43
  BOTTOM w0.114: v1(177.54,29.33) v2(177.94,29.73)
BT_OFF#_R: length 14.4
  TOP w0.114: v2(290.21,62.76) 289.76,62.32 289.76,61.11 290.72,60.16 RN17.1 291.67,60.12 291.67,58.38 v1(292.3,57.75) 292.81,57.24 CN25.1 293.77,55.47 RN16.2
  BOTTOM w0.114: v2(290.21,62.76) 290.7,63.25 JWLAN.46
BTST_CHG: length 0.9
  TOP w0.114: 57.48,30.92 v1(56.62,30.92)
BUSPOWER#: length 2.9
  BOTTOM w0.076: UT4.F10 128.3,151.33 128.74,151.33 128.86,151.22 129.17,151.22
  BOTTOM w0.114: 129.17,151.22 129.24,151.22 129.68,150.77 130.06,150.77 130.38,151.09 RT74.2
CALDERA_ PWRGD: length 307.2
  TOP w0.114: v2(65.1,5.17) 65.1,4.6 65.42,4.28 65.93,4.28 66.31,3.9 67.52,3.9 67.65,4.02 UE6.15 ; v2(116.99,151.88) 115.98,151.88 114.26,153.59 114.26,163.17 114.63,163.54 114.63,165.7 116.03,167.09 116.03,168.87 116.44,169.28 117.39,169.28 117.81,169.7 v2(117.81,170.65) ; v2(153.43,137.18) 153.43,136.93 v3(154.57,135.79) 154.63,135.73 159.39,135.73 160.72,134.4 160.72,118.53 158.76,116.57 158.76,115.49 158.23,114.95 157.48,114.95 155.61,113.08 155.61,106.67 153.48,104.54 153.48,95.09 156.56,92.01 156.56,88.12 154.34,85.9 154.34,80.05 154.75,79.64 154.75,69.14 153.27,67.67 147.92,67.67 v2(146.45,66.19)
  IN2 w0.097: v2(153.43,137.18) 153.43,137.49 150.72,140.21 128.18,140.21 v2(125.44,142.95)
  IN4 w0.137: v2(146.45,66.19) 143.7,63.45 138.71,63.45 131.11,55.85 131.11,42.45 129.69,41.04 129.69,37.83 130.85,36.66 130.85,29.84 130.25,29.24 130.25,26.25 127.7,23.69 121.94,23.69 117.55,19.3 114.07,19.3 109.19,24.17 102.21,24.17 101.88,24.5 99.34,24.5 98.02,25.82 93.37,25.82 91.05,23.5 91.05,21.46 90.64,21.05 90.64,18.76 90.88,18.51 90.88,12.54 90.28,11.94 90.28,11.05 89.37,10.14 88.48,10.14 86.78,8.44 81.6,8.44 78.01,4.85 71.63,4.85 69.83,3.05 68.53,3.05 66.6,4.98 66.31,4.98 66.12,5.17 v2(65.1,5.17)
  IN5 w0.097: v2(125.44,142.95) 125.44,142.99 122.26,146.16 120.87,146.16 116.99,150.04 v2(116.99,151.88)
  BOTTOM w0.114: RM42.1 119.84,168.17 119.9,168.24 JCDRA.2 119.9,171.6 119.52,171.98 118.51,171.98 117.81,171.28 v2(117.81,170.65)
CALDERA_ON: length 205.8
  TOP w0.114: v2(89.55,15.65) 88.93,15.65 88.63,15.34 UE5.108
  IN4 w0.137: v2(117.16,168.86) 117.16,168.04 114.25,165.12 114.25,160.68 106.64,153.07 106.64,147.76 104.49,145.61 100.37,145.61 99.58,144.83 99.58,143.26 99.01,142.69 96.92,142.69 95.9,143.71 95.9,144.79 v2(96.06,144.96)
  IN5 w0.097: v2(89.55,15.65) 89.81,15.91 89.81,20.15 89.43,20.52 88.34,20.52 86.91,21.96 76.93,21.96 75.78,23.11 75.78,47.26 78.28,49.76 78.28,55.3 84.09,61.11 84.09,90.71 85.51,92.13 85.51,142.81 86.62,143.92 91.72,143.92 92.25,144.45 95.56,144.45 v2(96.06,144.96)
  BOTTOM w0.114: JCDRA.1 119.1,168.43 118.94,168.27 RM41.2 118.61,167.86 118.5,167.97 v1(118.5,168.78) 118.5,169.05 118.37,169.18 117.48,169.18 v2(117.16,168.86) UM7.2
CALDERA_PRSNT#: length 460.9
  TOP w0.114: v2(67.37,10.39) 67.35,10.39 66.94,9.98 66.94,9.68 67.15,9.47 UE6.5 ; UE1.28 260.16,42.58 v2(259.35,43.39)
  IN2 w0.097: v2(114.95,172.32) 113.68,171.05 113.68,153.57 110.95,150.83 v2(110.95,142.74)
  IN3 w0.124: v2(67.37,10.39) 67.42,10.44 69.74,10.44 71.96,8.22 90.25,8.22 91.99,9.96 91.99,11.93 92.72,12.66 95.01,12.66 95.64,12.03 98.81,12.03 103.65,7.2 129.3,7.2 130.76,8.66 136.03,8.66 141.24,13.87 145.56,13.87 146.38,14.69 149.86,14.69 150.69,15.52 162.74,15.52 165.09,13.17 166.19,13.17 166.45,12.91 174.47,12.91 175.62,14.06 189.22,14.06 194.67,8.61 202.29,8.61 203.16,7.73 214.45,7.73 218.87,12.15 231.85,12.15 232.6,12.9 234.76,12.9 238.35,16.5 238.35,16.94 249.08,27.67 249.08,28.69 252.03,31.64 252.03,33.1 259.35,40.42 v2(259.35,43.39)
  IN4 w0.137: v2(80.64,26.33) 80.64,17.64 73.44,10.44 67.42,10.44 v2(67.37,10.39)
  IN5 w0.097: v2(80.64,26.33) 80.24,26.33 78.56,28.01 78.56,45.68 81.08,48.2 81.08,54.14 86.67,59.72 86.67,76.01 94.38,83.72 94.38,91.17 97.93,94.72 97.93,102.53 98.69,103.29 98.69,105.58 97.89,106.38 97.89,110.39 89.51,118.77 89.51,127.37 89.09,127.79 89.01,127.87 89.01,130.17 87.74,131.44 87.74,132.66 88.37,133.3 88.37,135.97 87.74,136.6 87.74,139.82 88.11,140.18 91.7,140.18 92.84,141.32 97.41,141.32 97.8,141.72 109.92,141.72 v2(110.95,142.74)
  BOTTOM w0.114: v2(110.95,142.74) 110.73,142.96 v1(110.73,143.46) 110.73,144.63 109.73,145.63 109.73,146.22 108.78,147.16 RM61.1 ; v2(114.95,172.32) 127.19,172.32 127.85,171.65 JCDRA.21 127.85,169.2 127.65,169 127.65,168.87 127.27,168.49 126.1,168.49 125.92,168.31 RM5.2
