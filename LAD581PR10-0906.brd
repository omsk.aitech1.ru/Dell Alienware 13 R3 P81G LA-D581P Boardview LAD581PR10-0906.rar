# Allegro board LAD581PR10-0906.brd (continued)
## Nets (continued)
CPU_DP2_N0_C: CT28.2 UT1.AC15
CPU_DP2_N1: CPU1.G38 CT30.1
CPU_DP2_N1_C: CT30.2 UT1.AC17
CPU_DP2_N2: CPU1.F35 CT32.1
CPU_DP2_N2_C: CT32.2 UT1.AC19
CPU_DP2_N3: CPU1.E36 CT34.1
CPU_DP2_N3_C: CT34.2 UT1.AC21
CPU_DP2_P0: CPU1.H34 CT27.1
CPU_DP2_P0_C: CT27.2 UT1.AB15
CPU_DP2_P1: CPU1.F37 CT29.1
CPU_DP2_P1_C: CT29.2 UT1.AB17
CPU_DP2_P2: CPU1.F34 CT31.1
CPU_DP2_P2_C: CT31.2 UT1.AB19
CPU_DP2_P3: CPU1.E37 CT33.1
CPU_DP2_P3_C: CT33.2 UT1.AB21
CPU_EDP_AUX: CPU1.C26 CV434.2
CPU_EDP_AUX#: CPU1.B26 CV435.2
CPU_EDP_AUX#_C: CV435.1 UV21.29
CPU_EDP_AUX_C: CV434.1 UV21.30
CPU_EDP_N0_C: CV427.1 UV21.12
CPU_EDP_N1_C: CV429.1 UV21.15
CPU_EDP_N2_C: CV431.1 UV21.17
CPU_EDP_N3_C: CV433.1 UV21.20
CPU_EDP_P0_C: CV426.1 UV21.11
CPU_EDP_P1_C: CV428.1 UV21.14
CPU_EDP_P2_C: CV430.1 UV21.16
CPU_EDP_P3_C: CV432.1 UV21.19
CPU_EDP_TX0N: CPU1.E29 CV427.2
CPU_EDP_TX0P: CPU1.D29 CV426.2
CPU_EDP_TX1N: CPU1.E28 CV429.2
CPU_EDP_TX1P: CPU1.F28 CV428.2
CPU_EDP_TX2N: CPU1.B29 CV431.2
CPU_EDP_TX2P: CPU1.A29 CV430.2
CPU_EDP_TX3N: CPU1.B28 CV433.2
CPU_EDP_TX3P: CPU1.C28 CV432.2
CPU_FAN_FB: DF1.2 RF1.1 UE5.28
CPU_FAN_PWM: JFAN1.3 RF2.1 UE5.26
CPU_ID: RH23.1 RH24.1 UH1.AL35
CPU_TRIGGER: RH192.1 UH1.AK1
CPU_XDP_TRST#: CPU1.BP30 JPCMC.28 RH497.2 UH1.AY5
CRX_N8: JCDRA.16 UM8.42
CRX_N9: JCDRA.19 UM8.37
CRX_N10: JCDRA.25 UM8.39
CRX_N11: JCDRA.31 UM8.44
CRX_P8: JCDRA.15 UM8.43
CRX_P9: JCDRA.18 UM8.38
CRX_P10: JCDRA.24 UM8.40
CRX_P11: JCDRA.30 UM8.45
CS1: PR106.2 PU100.1
CS2: PR105.2 PU100.5
CS_1.2V: PR201.2 PU201.13
CSON_1: PC717.2 PC721.1 PR712.3 PR723.2
CSOP_1: PC716.2 PC717.1 PR712.2 PR722.2
CSSN_1: PR702.3 PR704.1
CSSN_2: PC708.2 PC709.1 PR704.2 PU700.1
CSSN_B+: PR6100.3 RG59.1
CSSN_NVVDD: PR6101.3 RG64.1
CSSN_NVVDDS: PR6200.3 RG138.1
CSSP_1: PR702.2 PR703.1
CSSP_2: PC707.2 PC708.1 PR703.2 PU700.2
CSSP_B+: PR6100.2 RG62.1
CSSP_NVVDD: PR6101.2 RG66.1
CSSP_NVVDDS: PR6200.2 RG137.1
CTL1: UE6.7 UU1.6
CTL2: UE6.8 UU1.7
DAT_SMB: PBATT1.5 PR21.1
DDR_A_ACT#: CPU1.AU3 JDIMM1.114
DDR_A_ALERT#: CPU1.AU5 JDIMM1.116
DDR_A_BG0: CPU1.AU1 JDIMM1.115
DDR_A_BG1: CPU1.AU2 JDIMM1.113
DDR_A_BS0: CPU1.AH5 JDIMM1.150
DDR_A_BS1: CPU1.AH1 JDIMM1.145
DDR_A_CAS#: CPU1.AD1 JDIMM1.156
DDR_A_D0: CPU1.BR6 JDIMM1.4
DDR_A_D1: CPU1.BT6 JDIMM1.3
DDR_A_D2: CPU1.BP3 JDIMM1.20
DDR_A_D3: CPU1.BR3 JDIMM1.17
DDR_A_D4: CPU1.BN5 JDIMM1.8
DDR_A_D5: CPU1.BP6 JDIMM1.7
DDR_A_D6: CPU1.BP2 JDIMM1.16
DDR_A_D7: CPU1.BN3 JDIMM1.21
DDR_A_D8: CPU1.BL4 JDIMM1.29
DDR_A_D9: CPU1.BL5 JDIMM1.25
DDR_A_D10: CPU1.BL2 JDIMM1.41
DDR_A_D11: CPU1.BM1 JDIMM1.42
DDR_A_D12: CPU1.BK4 JDIMM1.24
DDR_A_D13: CPU1.BK5 JDIMM1.28
DDR_A_D14: CPU1.BK1 JDIMM1.38
DDR_A_D15: CPU1.BK2 JDIMM1.37
DDR_A_D16: CPU1.BG4 JDIMM1.45
DDR_A_D17: CPU1.BG5 JDIMM1.49
DDR_A_D18: CPU1.BF4 JDIMM1.63
DDR_A_D19: CPU1.BF5 JDIMM1.59
DDR_A_D20: CPU1.BG2 JDIMM1.50
DDR_A_D21: CPU1.BG1 JDIMM1.46
DDR_A_D22: CPU1.BF1 JDIMM1.62
DDR_A_D23: CPU1.BF2 JDIMM1.58
DDR_A_D24: CPU1.BD2 JDIMM1.67
DDR_A_D25: CPU1.BD1 JDIMM1.70
DDR_A_D26: CPU1.BC4 JDIMM1.79
DDR_A_D27: CPU1.BC5 JDIMM1.83
DDR_A_D28: CPU1.BD5 JDIMM1.66
DDR_A_D29: CPU1.BD4 JDIMM1.71
DDR_A_D30: CPU1.BC1 JDIMM1.80
DDR_A_D31: CPU1.BC2 JDIMM1.84
DDR_A_D32: CPU1.AB1 JDIMM1.174
DDR_A_D33: CPU1.AB2 JDIMM1.169
DDR_A_D34: CPU1.AA4 JDIMM1.186
DDR_A_D35: CPU1.AA5 JDIMM1.182
DDR_A_D36: CPU1.AB5 JDIMM1.170
DDR_A_D37: CPU1.AB4 JDIMM1.173
DDR_A_D38: CPU1.AA2 JDIMM1.183
DDR_A_D39: CPU1.AA1 JDIMM1.187
DDR_A_D40: CPU1.V5 JDIMM1.190
DDR_A_D41: CPU1.V2 JDIMM1.195
DDR_A_D42: CPU1.U1 JDIMM1.207
DDR_A_D43: CPU1.U2 JDIMM1.203
DDR_A_D44: CPU1.V1 JDIMM1.191
DDR_A_D45: CPU1.V4 JDIMM1.194
DDR_A_D46: CPU1.U5 JDIMM1.208
DDR_A_D47: CPU1.U4 JDIMM1.204
DDR_A_D48: CPU1.R2 JDIMM1.211
DDR_A_D49: CPU1.P5 JDIMM1.228
DDR_A_D50: CPU1.R4 JDIMM1.212
DDR_A_D51: CPU1.P4 JDIMM1.224
DDR_A_D52: CPU1.R5 JDIMM1.216
DDR_A_D53: CPU1.P2 JDIMM1.225
DDR_A_D54: CPU1.R1 JDIMM1.215
DDR_A_D55: CPU1.P1 JDIMM1.229
DDR_A_D56: CPU1.M4 JDIMM1.233
DDR_A_D57: CPU1.M1 JDIMM1.236
DDR_A_D58: CPU1.L4 JDIMM1.245
DDR_A_D59: CPU1.L2 JDIMM1.246
DDR_A_D60: CPU1.M5 JDIMM1.237
DDR_A_D61: CPU1.M2 JDIMM1.232
DDR_A_D62: CPU1.L5 JDIMM1.249
DDR_A_D63: CPU1.L1 JDIMM1.250
DDR_A_DQS0: CPU1.BP5 JDIMM1.13
DDR_A_DQS1: CPU1.BK3 JDIMM1.34
DDR_A_DQS2: CPU1.BF3 JDIMM1.55
DDR_A_DQS3: CPU1.BC3 JDIMM1.76
DDR_A_DQS4: CPU1.AB3 JDIMM1.179
DDR_A_DQS5: CPU1.V3 JDIMM1.200
DDR_A_DQS6: CPU1.R3 JDIMM1.221
DDR_A_DQS7: CPU1.M3 JDIMM1.242
DDR_A_DQS#0: CPU1.BR5 JDIMM1.11
DDR_A_DQS#1: CPU1.BL3 JDIMM1.32
DDR_A_DQS#2: CPU1.BG3 JDIMM1.53
DDR_A_DQS#3: CPU1.BD3 JDIMM1.74
DDR_A_DQS#4: CPU1.AA3 JDIMM1.177
DDR_A_DQS#5: CPU1.U3 JDIMM1.198
DDR_A_DQS#6: CPU1.P3 JDIMM1.219
DDR_A_DQS#7: CPU1.L3 JDIMM1.240
DDR_A_MA0: CPU1.AH3 JDIMM1.144
DDR_A_MA1: CPU1.AP4 JDIMM1.133
DDR_A_MA2: CPU1.AN4 JDIMM1.132
DDR_A_MA3: CPU1.AP5 JDIMM1.131
DDR_A_MA4: CPU1.AP2 JDIMM1.128
DDR_A_MA5: CPU1.AP1 JDIMM1.126
DDR_A_MA6: CPU1.AP3 JDIMM1.127
DDR_A_MA7: CPU1.AN1 JDIMM1.122
DDR_A_MA8: CPU1.AN3 JDIMM1.125
DDR_A_MA9: CPU1.AT4 JDIMM1.121
DDR_A_MA10: CPU1.AH2 JDIMM1.146
DDR_A_MA11: CPU1.AN2 JDIMM1.120
DDR_A_MA12: CPU1.AU4 JDIMM1.119
DDR_A_MA13: CPU1.AE3 JDIMM1.158
DDR_A_PAR: CPU1.AG3 JDIMM1.143
DDR_A_RAS#: CPU1.AH4 JDIMM1.152
DDR_A_WE#: CPU1.AG4 JDIMM1.151
DDR_B_ACT#: CPU1.AT9 JDIMM2.114
DDR_B_ALERT#: CPU1.AR8 JDIMM2.116
DDR_B_BG0: CPU1.AR9 JDIMM2.115
DDR_B_BG1: CPU1.AR7 JDIMM2.113
DDR_B_BS0: CPU1.AH8 JDIMM2.150
DDR_B_BS1: CPU1.AH9 JDIMM2.145
DDR_B_CAS#: CPU1.AF8 JDIMM2.156
DDR_B_D0: CPU1.BT11 JDIMM2.3
DDR_B_D1: CPU1.BR11 JDIMM2.8
DDR_B_D2: CPU1.BT8 JDIMM2.16
DDR_B_D3: CPU1.BR8 JDIMM2.21
DDR_B_D4: CPU1.BP11 JDIMM2.7
DDR_B_D5: CPU1.BN11 JDIMM2.4
DDR_B_D6: CPU1.BP8 JDIMM2.17
DDR_B_D7: CPU1.BN8 JDIMM2.20
DDR_B_D8: CPU1.BL12 JDIMM2.24
DDR_B_D9: CPU1.BL11 JDIMM2.28
DDR_B_D10: CPU1.BL8 JDIMM2.25
DDR_B_D11: CPU1.BJ8 JDIMM2.42
DDR_B_D12: CPU1.BJ11 JDIMM2.37
DDR_B_D13: CPU1.BJ10 JDIMM2.41
DDR_B_D14: CPU1.BL7 JDIMM2.29
DDR_B_D15: CPU1.BJ7 JDIMM2.38
DDR_B_D16: CPU1.BG11 JDIMM2.45
DDR_B_D17: CPU1.BG10 JDIMM2.49
DDR_B_D18: CPU1.BG8 JDIMM2.50
DDR_B_D19: CPU1.BF8 JDIMM2.59
DDR_B_D20: CPU1.BF11 JDIMM2.62
DDR_B_D21: CPU1.BF10 JDIMM2.58
DDR_B_D22: CPU1.BG7 JDIMM2.46
DDR_B_D23: CPU1.BF7 JDIMM2.63
DDR_B_D24: CPU1.BB11 JDIMM2.84
DDR_B_D25: CPU1.BC11 JDIMM2.67
DDR_B_D26: CPU1.BB8 JDIMM2.79
DDR_B_D27: CPU1.BC8 JDIMM2.66
DDR_B_D28: CPU1.BC10 JDIMM2.71
DDR_B_D29: CPU1.BB10 JDIMM2.80
DDR_B_D30: CPU1.BC7 JDIMM2.70
DDR_B_D31: CPU1.BB7 JDIMM2.83
DDR_B_D32: CPU1.AA11 JDIMM2.187
DDR_B_D33: CPU1.AA10 JDIMM2.183
DDR_B_D34: CPU1.AC11 JDIMM2.174
DDR_B_D35: CPU1.AC10 JDIMM2.170
DDR_B_D36: CPU1.AA7 JDIMM2.182
DDR_B_D37: CPU1.AA8 JDIMM2.186
DDR_B_D38: CPU1.AC8 JDIMM2.169
DDR_B_D39: CPU1.AC7 JDIMM2.173
DDR_B_D40: CPU1.W8 JDIMM2.191
DDR_B_D41: CPU1.W7 JDIMM2.195
DDR_B_D42: CPU1.V10 JDIMM2.203
DDR_B_D43: CPU1.V11 JDIMM2.207
DDR_B_D44: CPU1.W11 JDIMM2.190
DDR_B_D45: CPU1.W10 JDIMM2.194
DDR_B_D46: CPU1.V7 JDIMM2.208
DDR_B_D47: CPU1.V8 JDIMM2.204
DDR_B_D48: CPU1.R11 JDIMM2.216
DDR_B_D49: CPU1.P11 JDIMM2.228
DDR_B_D50: CPU1.P7 JDIMM2.225
DDR_B_D51: CPU1.R8 JDIMM2.215
DDR_B_D52: CPU1.R10 JDIMM2.211
DDR_B_D53: CPU1.P10 JDIMM2.224
DDR_B_D54: CPU1.R7 JDIMM2.212
DDR_B_D55: CPU1.P8 JDIMM2.229
DDR_B_D56: CPU1.L11 JDIMM2.245
DDR_B_D57: CPU1.M11 JDIMM2.236
DDR_B_D58: CPU1.L7 JDIMM2.250
DDR_B_D59: CPU1.M8 JDIMM2.232
DDR_B_D60: CPU1.L10 JDIMM2.249
DDR_B_D61: CPU1.M10 JDIMM2.233
DDR_B_D62: CPU1.M7 JDIMM2.237
DDR_B_D63: CPU1.L8 JDIMM2.246
DDR_B_DQS0: CPU1.BR9 JDIMM2.13
DDR_B_DQS1: CPU1.BJ9 JDIMM2.34
DDR_B_DQS2: CPU1.BF9 JDIMM2.55
DDR_B_DQS3: CPU1.BB9 JDIMM2.76
DDR_B_DQS4: CPU1.AA9 JDIMM2.179
DDR_B_DQS5: CPU1.V9 JDIMM2.200
DDR_B_DQS6: CPU1.P9 JDIMM2.221
DDR_B_DQS7: CPU1.L9 JDIMM2.242
DDR_B_DQS#0: CPU1.BP9 JDIMM2.11
DDR_B_DQS#1: CPU1.BL9 JDIMM2.32
DDR_B_DQS#2: CPU1.BG9 JDIMM2.53
DDR_B_DQS#3: CPU1.BC9 JDIMM2.74
DDR_B_DQS#4: CPU1.AC9 JDIMM2.177
DDR_B_DQS#5: CPU1.W9 JDIMM2.198
DDR_B_DQS#6: CPU1.R9 JDIMM2.219
DDR_B_DQS#7: CPU1.M9 JDIMM2.240
DDR_B_MA0: CPU1.AJ9 JDIMM2.144
DDR_B_MA1: CPU1.AK6 JDIMM2.133
DDR_B_MA2: CPU1.AK5 JDIMM2.132
DDR_B_MA3: CPU1.AL5 JDIMM2.131
DDR_B_MA4: CPU1.AL6 JDIMM2.128
DDR_B_MA5: CPU1.AM6 JDIMM2.126
DDR_B_MA6: CPU1.AN7 JDIMM2.127
DDR_B_MA7: CPU1.AN10 JDIMM2.122
DDR_B_MA8: CPU1.AN8 JDIMM2.125
DDR_B_MA9: CPU1.AR11 JDIMM2.121
DDR_B_MA10: CPU1.AH7 JDIMM2.146
DDR_B_MA11: CPU1.AN11 JDIMM2.120
DDR_B_MA12: CPU1.AR10 JDIMM2.119
DDR_B_MA13: CPU1.AF9 JDIMM2.158
DDR_B_PAR: CPU1.AJ7 JDIMM2.143
DDR_B_RAS#: CPU1.AH10 JDIMM2.152
DDR_B_WE#: CPU1.AH11 JDIMM2.151
DDR_CKE0_DIMMA: CPU1.AT1 JDIMM1.109
DDR_CKE1_DIMMA: CPU1.AT2 JDIMM1.110
DDR_CKE2_DIMMB: CPU1.AT8 JDIMM2.109
DDR_CKE3_DIMMB: CPU1.AT10 JDIMM2.110
DDR_CS0_DIMMA#: CPU1.AD5 JDIMM1.149
DDR_CS1_DIMMA#: CPU1.AE2 JDIMM1.157
DDR_CS2_DIMMB#: CPU1.AF11 JDIMM2.149
DDR_CS3_DIMMB#: CPU1.AE7 JDIMM2.157
DDR_RCOMP0: CPU1.G1 RH148.2
DDR_RCOMP1: CPU1.H1 RH149.2
DDR_RCOMP2: CPU1.J2 RH150.2
DDR_VTT_PG_CTRL: CPU1.BT13 UC1.2
DEBUG_CTL1: RT66.2 UT4.E4
DEBUG_CTL2: RT67.2 UT4.D5
DEMB0: RM75.2 RM79.2 UM8.53
DEMB1: RM62.2 RM86.2 UM8.54
DEPOP#_EC: DA2.3 UE6.2
DET: JEDP.28 RH584.1 RH585.2 UH1.R35
DEVSLP0: JSSD1.38 UH1.AG42
DEVSLP3: JSSD2.38 UH1.AB41
DGPU_ENBKL: RG501.1 UG9.BB1 UV22.11
DGPU_ENVDD: QG506.2 RG151.1 UG9.BH3 UV22.5
DGPU_HOLD_RST#: RG3.2 RG13.1 UG10.1 UH1.AL36
DGPU_INV_PWM: RG536.2 UG24.6 UV22.2
DGPU_PEX_RST#: DG1.1 QG6.2 QG6.5 QG7.2 QG7.5 QG501.2 QG501.5 QV96.2 QV96.5 RG6.2 RG7.2 RG25.1 UG9.BK26 UG22.1 UX1.2 UX2.2
DGPU_PRSNT#: RH135.2 UH1.BC19
DGPU_PWR_EN: RG551.1 RH537.1 UE5.1 UH1.AJ39
DGPU_PWROK: RH516.2 UE6.19 UH1.AJ44
DGPU_ROM_CS#: RG74.2 RG538.1 UG13.1 UG16.11
DGPU_ROM_SCLK: RG75.1 UG13.6
DGPU_ROM_SI: RG77.1 UG13.5
DGPU_ROM_SO: RG76.1 RG539.1 UG16.8
DGPU_ROM_SO_R: RG76.2 UG13.2
DH_1.2V: PQ200.4 PU201.17
DH_CHG: PQ704.4 PU700.26
DIMM_CHA_SA0: JDIMM1.256 RD28.1
DIMM_CHA_SA1: JDIMM1.260 RD29.1
DIMM_CHA_SA2: JDIMM1.166 RD30.1
DIMM_CHB_SA0: JDIMM2.256 RD38.1
DIMM_CHB_SA1: JDIMM2.260 RD5.2
DIMM_CHB_SA2: JDIMM2.166 RD40.1
DISP_CEC: JDP.6 RV18.2
DISP_CLK_AUXP_CONN: JDP.16 RV15.2 UV3.4
DISP_DAT_AUXN_CONN: JDP.18 RV16.2 UV3.7
DISPOFF#: DV1.1 JEDP.35 RV1.1
DL_1.2V: PQ201.4 PU201.15
DL_CHG: PQ706.4 PU700.23
DMI_CRX_PTX_N0: CPU1.E8 UH1.C27
DMI_CRX_PTX_N1: CPU1.F6 UH1.B28
DMI_CRX_PTX_N2: CPU1.E5 UH1.B29
DMI_CRX_PTX_N3: CPU1.J9 UH1.B30
DMI_CRX_PTX_P0: CPU1.D8 UH1.B27
DMI_CRX_PTX_P1: CPU1.E6 UH1.A28
DMI_CRX_PTX_P2: CPU1.D5 UH1.C29
DMI_CRX_PTX_P3: CPU1.J8 UH1.A30
DMI_CTX_PRX_N0: CPU1.A8 UH1.L27
DMI_CTX_PRX_N1: CPU1.B6 UH1.E24
DMI_CTX_PRX_N2: CPU1.A5 UH1.G27
DMI_CTX_PRX_N3: CPU1.B4 UH1.L29
DMI_CTX_PRX_P0: CPU1.B8 UH1.N27
DMI_CTX_PRX_P1: CPU1.C6 UH1.G24
DMI_CTX_PRX_P2: CPU1.B5 UH1.E26
DMI_CTX_PRX_P3: CPU1.D4 UH1.K29
DMIC_CLK1_R: LA6.2 UA1.53
DMIC_DATA1_R: RA19.2 UA1.54
DP_AUXN_C: CV25.1 UV3.5
DP_AUXP_C: CV24.1 UV3.2
DP_CBL_DET: JDP.4 RV17.1 UV3.1
DP_HPD_GPU#: QV97.6 RX5.2 UG9.BE3
DP_HPD_PCH: QX2.3 RX4.1 UH1.AT44 UX1.1
DPSNK_RBIAS: RT19.1 UT1.Y18
DPSRC_RBIAS: RT5.1 UT1.N6
EAPD#: DA3.2 RA21.2 RA22.1 UA1.52
EC_1V8_AON_EN: RG552.1 UE10.22
EC_3V3_SYS_EN: RG567.1 UE10.20
EC_AC_BAT#: RG16.1 UE6.9 UG9.BE6
EC_ESB_CLK: RE642.2 UE5.17 UE6.1 UE10.1
EC_ESB_DAT: RE643.2 UE5.18 UE6.4 UE10.4
EC_FBVDD/Q_EN: RG570.2 UE10.16
EC_MUTE#: DA3.3 UE10.11
EC_NVVDD1_EN: RG568.2 UE10.15
EC_NVVDD2_EN: RG569.2 UE10.19
EC_ON: PD100.2 UE5.112
EC_PEX_VDD_EN: PR823.2 UE10.17
EC_RSMRST#: DE2.2 RH88.2 UE5.100 UH1.BA11
EC_RTCRST: QE5.2 RE650.1 UE5.34
EC_RX: JEC.7 JWLAN.32 UE5.31
EC_SCI#: RH521.2 UE5.20 UH1.AV29
EC_SMB_CK1: PD2.2 PR19.2 PR721.2 RE92.2 UE5.77
EC_SMB_CK2: QG6.3 QH5.1 RE94.2 RM89.1 RM99.1 RT60.1 U2407.10 UE5.79
EC_SMB_DA1: PD2.3 PR21.2 PR720.2 RE93.2 UE5.78
EC_SMB_DA2: QG6.6 QH5.4 RE95.2 RM90.1 RM100.1 RT59.1 U2407.9 UE5.80
EC_TX: JEC.6 JWLAN.30 RM31.1 UE5.30
ECAGND: CE33.2 CE35.1 LE2.2 PH1.2 UE5.69
EDP_AUX#_C: CV13.1 JEDP.14
EDP_AUX_C: CV12.1 JEDP.13
EDP_HPD: JEDP.16 UV21.44
EDP_HPD_CPU: RH9.1 UH1.BD7 UV21.13
EDP_HPD_GPU: QG500.5 RG519.1 UV21.3
EDP_HPD_GPU#: QG500.3 RG500.2 RG555.2 RG556.2
EDP_RCOMP: CPU1.D37 RC30.1
EDP_SW: RV659.1 UE5.98 UH1.AV44 UV21.54 UV22.1
EDP_TX0#_C: CV2.1 JEDP.2
EDP_TX0_C: CV1.1 JEDP.1
EDP_TX1#_C: CV4.1 JEDP.5
EDP_TX1_C: CV3.1 JEDP.4
EDP_TX2#_C: CV6.1 JEDP.8
EDP_TX2_C: CV8.1 JEDP.7
EDP_TX3#_C: CV11.1 JEDP.11
EDP_TX3_C: CV7.1 JEDP.10
ELC_8051_C2CK_RST#: JELC.2 RE7.2 UE1.9
ELC_8051_C2D_P3: JELC.3 UE1.10
ELC_EC#: QE13.5 QE21.5 QE22.5 UE10.6
EN_0.6VSP: PC214.1 PR209.2 PR211.1 PU201.7
EN_1.2V: PC213.1 PR208.1 PU201.8
EN_+1VALWP: PC300.1 PR300.2 PU300.3
EN_INVPWR: QV2.2 UE5.68
EN_TPLED: C2509.1 Q2409.3 Q2410.1 R179.1 R180.1
EN_WOL#: CL42.1 RE79.2 UE10.14 UL2.4
ENBKL: UE5.76 UV22.9
ENVDD: RV600.2 UV17.4 UV22.7
EQA0: RM81.2 RM84.2 UM8.20
EQA1: RM70.2 RM76.2 UM8.19
EQB0: RM82.2 RM85.2 UM8.46
EQB1: RM23.2 RM26.2 UM8.47
FB_1.0VS_VGAP: PC809.2 PR804.2 PR805.1 PU800.14
FB_3V: PR101.2 PR103.2 PU100.4
FB_5V: PR102.1 PR104.1 PU100.2
FB_+1.8VGS: PC816.2 PR810.1 PR811.1 PU802.6
FB_+1VALWP: PR307.1 PR308.1 PU300.4
FB_VDDQ_SENSE: PC8218.1 PR8209.1 PU8200.12 UG9.E52
FBA_CLK0: RG102.1 UG1.J12 UG9.AG45
FBA_CLK0#: RG523.1 UG1.J11 UG9.AG46
FBA_CLK1: RG103.1 UG2.J12 UG9.AK46
FBA_CLK1#: RG524.1 UG2.J11 UG9.AK45
FBA_CMD0: UG1.G3 UG9.Y51
FBA_CMD1: RG47.2 UG1.J3 UG9.Y52
FBA_CMD2: RG54.1 UG1.J2 UG9.Y49
FBA_CMD3: UG1.L3 UG9.AA52
FBA_CMD4: UG1.K5 UG9.AA51
FBA_CMD5: UG1.K4 UG9.AA50
FBA_CMD6: UG1.J5 UG9.AC50
FBA_CMD7: UG1.J4 UG9.AC51
FBA_CMD8: UG1.H5 UG9.AC52
FBA_CMD9: UG1.H4 UG9.AC49
FBA_CMD10: UG1.G12 UG9.AD52
FBA_CMD11: UG1.H10 UG9.AD51
FBA_CMD12: UG1.H11 UG9.AD50
FBA_CMD13: UG1.K11 UG9.AF50
FBA_CMD14: UG1.K10 UG9.AF51
FBA_CMD15: UG1.L12 UG9.AF52
FBA_CMD16: UG2.L3 UG9.AN50
FBA_CMD17: RG48.2 UG2.J3 UG9.AN51
FBA_CMD18: RG53.1 UG2.J2 UG9.AN52
FBA_CMD19: UG2.G3 UG9.AM49
FBA_CMD20: UG2.H5 UG9.AM52
FBA_CMD21: UG2.H4 UG9.AM51
FBA_CMD22: UG2.J5 UG9.AM50
FBA_CMD23: UG2.J4 UG9.AK50
FBA_CMD24: UG2.K5 UG9.AK51
FBA_CMD25: UG2.K4 UG9.AK52
FBA_CMD26: UG2.L12 UG9.AJ49
FBA_CMD27: UG2.K10 UG9.AJ52
FBA_CMD28: UG2.K11 UG9.AJ51
FBA_CMD29: UG2.H11 UG9.AJ50
FBA_CMD30: UG2.H10 UG9.AG50
FBA_CMD31: UG2.G12 UG9.AG51
FBA_D0: UG1.U4 UG9.U51
FBA_D1: UG1.U2 UG9.U48
FBA_D2: UG1.T4 UG9.U50
FBA_D3: UG1.T2 UG9.U49
FBA_D4: UG1.N4 UG9.R51
FBA_D5: UG1.N2 UG9.R50
FBA_D6: UG1.M4 UG9.R47
FBA_D7: UG1.M2 UG9.U46
FBA_D8: UG1.U11 UG9.V46
FBA_D9: UG1.U13 UG9.Y45
FBA_D10: UG1.T11 UG9.Y47
FBA_D11: UG1.T13 UG9.Y46
FBA_D12: UG1.N11 UG9.V50
FBA_D13: UG1.N13 UG9.V47
FBA_D14: UG1.M11 UG9.U52
FBA_D15: UG1.M13 UG9.V51
FBA_D16: UG1.A11 UG9.AJ44
FBA_D17: UG1.A13 UG9.AG48
FBA_D18: UG1.B11 UG9.AJ45
FBA_D19: UG1.B13 UG9.AG49
FBA_D20: UG1.E11 UG9.AF46
FBA_D21: UG1.E13 UG9.AF47
FBA_D22: UG1.F11 UG9.AF48
FBA_D23: UG1.F13 UG9.AD47
FBA_D24: UG1.A4 UG9.AD49
FBA_D25: UG1.A2 UG9.AD48
FBA_D26: UG1.B4 UG9.AC46
FBA_D27: UG1.B2 UG9.AC47
FBA_D28: UG1.E4 UG9.AA47
FBA_D29: UG1.E2 UG9.AA46
FBA_D30: UG1.F4 UG9.AA45
FBA_D31: UG1.F2 UG9.Y44
FBA_D32: UG2.A4 UG9.AW51
FBA_D33: UG2.A2 UG9.BA52
FBA_D34: UG2.B4 UG9.AW50
FBA_D35: UG2.B2 UG9.BA51
FBA_D36: UG2.E4 UG9.BA50
FBA_D37: UG2.E2 UG9.BB50
FBA_D38: UG2.F4 UG9.BA49
FBA_D39: UG2.F2 UG9.AW49
FBA_D40: UG2.A11 UG9.AV48
FBA_D41: UG2.A13 UG9.AT49
FBA_D42: UG2.B11 UG9.AT47
FBA_D43: UG2.B13 UG9.AT48
FBA_D44: UG2.E11 UG9.AT46
FBA_D45: UG2.E13 UG9.AV51
FBA_D46: UG2.F11 UG9.AV52
FBA_D47: UG2.F13 UG9.AV49
FBA_D48: UG2.U11 UG9.AJ48
FBA_D49: UG2.U13 UG9.AJ46
FBA_D50: UG2.T11 UG9.AJ47
FBA_D51: UG2.T13 UG9.AK49
FBA_D52: UG2.N11 UG9.AM47
FBA_D53: UG2.N13 UG9.AM46
FBA_D54: UG2.M11 UG9.AN48
FBA_D55: UG2.M13 UG9.AN49
FBA_D56: UG2.U4 UG9.AM44
FBA_D57: UG2.U2 UG9.AM45
FBA_D58: UG2.T4 UG9.AN45
FBA_D59: UG2.T2 UG9.AN46
FBA_D60: UG2.N4 UG9.AR48
FBA_D61: UG2.N2 UG9.AN47
FBA_D62: UG2.M4 UG9.AR47
FBA_D63: UG2.M2 UG9.AR46
FBA_DBI0: UG1.P2 UG9.U47
FBA_DBI1: UG1.P13 UG9.Y48
FBA_DBI2: UG1.D13 UG9.AG47
FBA_DBI3: UG1.D2 UG9.AC48
FBA_DBI4: UG2.D2 UG9.BB51
FBA_DBI5: UG2.D13 UG9.AV50
FBA_DBI6: UG2.P13 UG9.AM48
FBA_DBI7: UG2.P2 UG9.AR49
FBA_EDC0: UG1.R2 UG9.R48
FBA_EDC1: UG1.R13 UG9.V48
FBA_EDC2: UG1.C13 UG9.AF44
FBA_EDC3: UG1.C2 UG9.AA48
FBA_EDC4: UG2.C2 UG9.BB52
FBA_EDC5: UG2.C13 UG9.AT50
FBA_EDC6: UG2.R13 UG9.AK48
FBA_EDC7: UG2.R2 UG9.AR51
FBA_WCK01: UG1.P4 UG9.U45
FBA_WCK01#: UG1.P5 UG9.U44
FBA_WCK23: UG1.D4 UG9.AC45
FBA_WCK23#: UG1.D5 UG9.AC44
FBA_WCK45: UG2.D4 UG9.AV47
FBA_WCK45#: UG2.D5 UG9.AV46
FBA_WCK67: UG2.P4 UG9.AR45
FBA_WCK67#: UG2.P5 UG9.AR44
FBB_CLK0: RG113.1 UG3.J12 UG9.H42
FBB_CLK0#: RG525.1 UG3.J11 UG9.G42
FBB_CLK1: RG114.1 UG4.J12 UG9.F47
FBB_CLK1#: RG526.1 UG4.J11 UG9.E47
FBB_CMD0: UG3.G3 UG9.B35
FBB_CMD1: RG49.2 UG3.J3 UG9.A35
FBB_CMD2: RG56.1 UG3.J2 UG9.D35
FBB_CMD3: UG3.L3 UG9.A36
FBB_CMD4: UG3.K5 UG9.B36
FBB_CMD5: UG3.K4 UG9.C36
FBB_CMD6: UG3.J5 UG9.C38
FBB_CMD7: UG3.J4 UG9.B38
FBB_CMD8: UG3.H5 UG9.A38
FBB_CMD9: UG3.H4 UG9.D38
FBB_CMD10: UG3.G12 UG9.A39
FBB_CMD11: UG3.H10 UG9.B39
FBB_CMD12: UG3.H11 UG9.C39
FBB_CMD13: UG3.K11 UG9.C41
FBB_CMD14: UG3.K10 UG9.B41
FBB_CMD15: UG3.L12 UG9.A41
FBB_CMD16: UG4.L3 UG9.B49
FBB_CMD17: RG50.2 UG4.J3 UG9.A49
FBB_CMD18: RG55.1 UG4.J2 UG9.A48
FBB_CMD19: UG4.G3 UG9.D47
FBB_CMD20: UG4.H5 UG9.A47
FBB_CMD21: UG4.H4 UG9.B47
FBB_CMD22: UG4.J5 UG9.C47
FBB_CMD23: UG4.J4 UG9.C45
FBB_CMD24: UG4.K5 UG9.B45
FBB_CMD25: UG4.K4 UG9.A45
FBB_CMD26: UG4.L12 UG9.D44
FBB_CMD27: UG4.K10 UG9.A44
FBB_CMD28: UG4.K11 UG9.B44
FBB_CMD29: UG4.H11 UG9.C44
FBB_CMD30: UG4.H10 UG9.C42
FBB_CMD31: UG4.G12 UG9.B42
FBB_D0: UG3.U4 UG9.H32
FBB_D1: UG3.U2 UG9.D32
FBB_D2: UG3.T4 UG9.A33
FBB_D3: UG3.T2 UG9.B32
FBB_D4: UG3.N4 UG9.E32
FBB_D5: UG3.N2 UG9.G32
FBB_D6: UG3.M4 UG9.J30
FBB_D7: UG3.M2 UG9.F32
FBB_D8: UG3.U11 UG9.H36
FBB_D9: UG3.U13 UG9.G36
FBB_D10: UG3.T11 UG9.J36
FBB_D11: UG3.T13 UG9.F36
FBB_D12: UG3.N11 UG9.F33
FBB_D13: UG3.N13 UG9.D33
FBB_D14: UG3.M11 UG9.J32
FBB_D15: UG3.M13 UG9.G33
FBB_D16: UG3.A11 UG9.E45
FBB_D17: UG3.A13 UG9.D45
FBB_D18: UG3.B11 UG9.F45
FBB_D19: UG3.B13 UG9.G45
FBB_D20: UG3.E11 UG9.D42
FBB_D21: UG3.E13 UG9.E42
FBB_D22: UG3.F11 UG9.F42
FBB_D23: UG3.F13 UG9.H41
FBB_D24: UG3.A4 UG9.E41
FBB_D25: UG3.A2 UG9.F39
FBB_D26: UG3.B4 UG9.E39
FBB_D27: UG3.B2 UG9.D39
FBB_D28: UG3.E4 UG9.F38
FBB_D29: UG3.E2 UG9.E38
FBB_D30: UG3.F4 UG9.D36
FBB_D31: UG3.F2 UG9.E36
FBB_D32: UG4.A4 UG9.M50
FBB_D33: UG4.A2 UG9.P48
FBB_D34: UG4.B4 UG9.M51
FBB_D35: UG4.B2 UG9.M49
FBB_D36: UG4.E4 UG9.P47
FBB_D37: UG4.E2 UG9.P52
FBB_D38: UG4.F4 UG9.R46
FBB_D39: UG4.F2 UG9.P46
FBB_D40: UG4.A11 UG9.L50
FBB_D41: UG4.A13 UG9.L51
FBB_D42: UG4.B11 UG9.L52
FBB_D43: UG4.B13 UG9.L49
FBB_D44: UG4.E11 UG9.M46
FBB_D45: UG4.E13 UG9.L47
FBB_D46: UG4.F11 UG9.M48
FBB_D47: UG4.F13 UG9.M47
FBB_D48: UG4.U11 UG9.D48
FBB_D49: UG4.U13 UG9.C50
FBB_D50: UG4.T11 UG9.C48
FBB_D51: UG4.T13 UG9.C49
FBB_D52: UG4.N11 UG9.E49
FBB_D53: UG4.N13 UG9.E50
FBB_D54: UG4.M11 UG9.F49
FBB_D55: UG4.M13 UG9.F48
FBB_D56: UG4.U4 UG9.F50
FBB_D57: UG4.U2 UG9.D52
FBB_D58: UG4.T4 UG9.J50
FBB_D59: UG4.T2 UG9.H48
FBB_D60: UG4.N4 UG9.H51
FBB_D61: UG4.N2 UG9.J51
FBB_D62: UG4.M4 UG9.H49
FBB_D63: UG4.M2 UG9.H52
FBB_DBI0: UG3.P2 UG9.C32
FBB_DBI1: UG3.P13 UG9.E33
FBB_DBI2: UG3.D13 UG9.E44
FBB_DBI3: UG3.D2 UG9.G39
FBB_DBI4: UG4.D2 UG9.P49
FBB_DBI5: UG4.D13 UG9.L48
FBB_DBI6: UG4.P13 UG9.D50
FBB_DBI7: UG4.P2 UG9.H50
FBB_EDC0: UG3.R2 UG9.B33
FBB_EDC1: UG3.R13 UG9.E35
FBB_EDC2: UG3.C13 UG9.G44
FBB_EDC3: UG3.C2 UG9.H38
FBB_EDC4: UG4.C2 UG9.P50
FBB_EDC5: UG4.C13 UG9.J48
FBB_EDC6: UG4.R13 UG9.D51
FBB_EDC7: UG4.R2 UG9.F51
FBB_WCK01: UG3.P4 UG9.J33
FBB_WCK01#: UG3.P5 UG9.H33
FBB_WCK23: UG3.D4 UG9.J39
FBB_WCK23#: UG3.D5 UG9.H39
FBB_WCK45: UG4.D4 UG9.L46
FBB_WCK45#: UG4.D5 UG9.L45
FBB_WCK67: UG4.P4 UG9.H47
FBB_WCK67#: UG4.P5 UG9.H46
FBC_CLK0: RG124.1 UG5.J12 UG9.G15
FBC_CLK0#: RG527.1 UG5.J11 UG9.F15
FBC_CLK1: RG125.1 UG6.J12 UG9.H21
FBC_CLK1#: RG528.1 UG6.J11 UG9.J21
FBC_CMD0: UG5.G3 UG9.C11
FBC_CMD1: RG51.2 UG5.J3 UG9.B11
FBC_CMD2: RG58.1 UG5.J2 UG9.A11
FBC_CMD3: UG5.L3 UG9.D11
FBC_CMD4: UG5.K5 UG9.A12
FBC_CMD5: UG5.K4 UG9.B12
FBC_CMD6: UG5.J5 UG9.C12
FBC_CMD7: UG5.J4 UG9.C14
FBC_CMD8: UG5.H5 UG9.B14
FBC_CMD9: UG5.H4 UG9.A14
FBC_CMD10: UG5.G12 UG9.D14
FBC_CMD11: UG5.H10 UG9.A15
FBC_CMD12: UG5.H11 UG9.B15
FBC_CMD13: UG5.K11 UG9.C15
FBC_CMD14: UG5.K10 UG9.C17
FBC_CMD15: UG5.L12 UG9.B17
FBC_CMD16: UG6.L3 UG9.B24
FBC_CMD17: RG52.2 UG6.J3 UG9.A24
FBC_CMD18: RG57.1 UG6.J2 UG9.D23
FBC_CMD19: UG6.G3 UG9.A23
FBC_CMD20: UG6.H5 UG9.B23
FBC_CMD21: UG6.H4 UG9.C23
FBC_CMD22: UG6.J5 UG9.C21
FBC_CMD23: UG6.J4 UG9.B21
FBC_CMD24: UG6.K5 UG9.A21
FBC_CMD25: UG6.K4 UG9.D20
FBC_CMD26: UG6.L12 UG9.A20
FBC_CMD27: UG6.K10 UG9.B20
FBC_CMD28: UG6.K11 UG9.C20
FBC_CMD29: UG6.H11 UG9.C18
FBC_CMD30: UG6.H10 UG9.B18
FBC_CMD31: UG6.G12 UG9.A18
FBC_D0: UG5.U4 UG9.C6
FBC_D1: UG5.U2 UG9.D6
FBC_D2: UG5.T4 UG9.A6
FBC_D3: UG5.T2 UG9.B6
FBC_D4: UG5.N4 UG9.B4
FBC_D5: UG5.N2 UG9.A4
FBC_D6: UG5.M4 UG9.B3
FBC_D7: UG5.M2 UG9.C4
FBC_D8: UG5.U11 UG9.D9
FBC_D9: UG5.U13 UG9.C9
FBC_D10: UG5.T11 UG9.E9
FBC_D11: UG5.T13 UG9.B9
FBC_D12: UG5.N11 UG9.B8
FBC_D13: UG5.N13 UG9.A8
FBC_D14: UG5.M11 UG9.F6
FBC_D15: UG5.M13 UG9.E6
FBC_D16: UG5.A11 UG9.F18
FBC_D17: UG5.A13 UG9.G18
FBC_D18: UG5.B11 UG9.E18
FBC_D19: UG5.B13 UG9.H18
FBC_D20: UG5.E11 UG9.D15
FBC_D21: UG5.E13 UG9.E15
FBC_D22: UG5.F11 UG9.G17
FBC_D23: UG5.F13 UG9.H17
FBC_D24: UG5.A4 UG9.J15
FBC_D25: UG5.A2 UG9.H15
FBC_D26: UG5.B4 UG9.E14
FBC_D27: UG5.B2 UG9.F14
FBC_D28: UG5.E4 UG9.H11
FBC_D29: UG5.E2 UG9.G11
FBC_D30: UG5.F4 UG9.F11
FBC_D31: UG5.F2 UG9.E11
FBC_D32: UG6.A4 UG9.J29
FBC_D33: UG6.A2 UG9.F30
FBC_D34: UG6.B4 UG9.H29
FBC_D35: UG6.B2 UG9.G30
FBC_D36: UG6.E4 UG9.B30
FBC_D37: UG6.E2 UG9.A30
FBC_D38: UG6.F4 UG9.H30
FBC_D39: UG6.F2 UG9.C30
FBC_D40: UG6.A11 UG9.D27
FBC_D41: UG6.A13 UG9.J26
FBC_D42: UG6.B11 UG9.F27
FBC_D43: UG6.B13 UG9.G27
FBC_D44: UG6.E11 UG9.C27
FBC_D45: UG6.E13 UG9.B27
FBC_D46: UG6.F11 UG9.A27
FBC_D47: UG6.F13 UG9.G29
FBC_D48: UG6.U11 UG9.H20
FBC_D49: UG6.U13 UG9.D18
FBC_D50: UG6.T11 UG9.G20
FBC_D51: UG6.T13 UG9.E20
FBC_D52: UG6.N11 UG9.F23
FBC_D53: UG6.N13 UG9.E21
FBC_D54: UG6.M11 UG9.D21
FBC_D55: UG6.M13 UG9.E23
FBC_D56: UG6.U4 UG9.G24
FBC_D57: UG6.U2 UG9.H26
FBC_D58: UG6.T4 UG9.F24
FBC_D59: UG6.T2 UG9.G26
FBC_D60: UG6.N4 UG9.F26
FBC_D61: UG6.N2 UG9.D26
FBC_D62: UG6.M4 UG9.B26
FBC_D63: UG6.M2 UG9.C26
FBC_DBI0: UG5.P2 UG9.A5
FBC_DBI1: UG5.P13 UG9.C8
FBC_DBI2: UG5.D13 UG9.J18
FBC_DBI3: UG5.D2 UG9.F12
FBC_DBI4: UG6.D2 UG9.D29
FBC_DBI5: UG6.D13 UG9.E27
FBC_DBI6: UG6.P13 UG9.F20
FBC_DBI7: UG6.P2 UG9.E26
FBC_EDC0: UG5.R2 UG9.D5
FBC_EDC1: UG5.R13 UG9.D8
FBC_EDC2: UG5.C13 UG9.E17
FBC_EDC3: UG5.C2 UG9.E12
FBC_EDC4: UG6.C2 UG9.E30
FBC_EDC5: UG6.C13 UG9.B29
FBC_EDC6: UG6.R13 UG9.G21
FBC_EDC7: UG6.R2 UG9.E24
FBC_WCK01: UG5.P4 UG9.F8
FBC_WCK01#: UG5.P5 UG9.G8
FBC_WCK23: UG5.D4 UG9.H12
FBC_WCK23#: UG5.D5 UG9.G12
FBC_WCK45: UG6.D4 UG9.J27
FBC_WCK45#: UG6.D5 UG9.H27
FBC_WCK67: UG6.P4 UG9.G23
FBC_WCK67#: UG6.P5 UG9.H23
FBCAL_GND: RG68.1 UG9.P44
FBCAL_TERM: RG69.1 UG9.R45
FBCAL_VDDQ: RG67.1 UG9.R44
FBVDD/Q_EN: PR8216.1 RG557.1 RG570.1 UG27.4
FBVDD/Q_ENP: PC8211.1 PR8216.2 PR8220.2 PU8200.3
FCCM_GT: PR585.1 PR594.1 PU500.11
FCCM_SA: PR5006.1 PU500.34
FCCM_VCORE: PR556.1 PR566.1 PR576.1 PU500.24
FRAME_LOCK#: QG506.3 RG502.2 UG9.BG2
G-SYNC#: JEDP.21 QG506.1 RG517.2
GC6_EVENT#: DG2.1 UH1.AR24
GC6_EVENT#_D: DG2.2 RG8.1 UG9.BD1
GC6_FB_EN: QG511.1 RG561.2 UE10.9 UH1.AW27
GPIO3_OC_WARN#: QG5.1 RG522.1 UG9.BB4
GPIO_1: DA2.2 UA1.2
GPU_ALERT#: QG501.3 RE644.1 UE10.10
GPU_AUXN/DDC: CV425.2 RV670.1 UG9.BF11
GPU_AUXN/DDC_C: CV425.1 UV21.27
GPU_AUXP/DDC: CV424.2 RV669.1 UG9.BE11
GPU_AUXP/DDC_C: CV424.1 UV21.28
GPU_B+: PJP8200.2 PR6100.4 PR6101.1 PR6200.1
GPU_BUFRST#: T6.1(TP-1) UG9.BF9
GPU_DPC_AUX: CV24.2 RV619.1
GPU_DPC_AUX#: CV25.2 RV618.1
GPU_FAN_FB: DF2.2 RF4.1 UE5.29
GPU_FAN_PWM: JFAN2.3 RF5.1 UE5.27
GPU_GC6_FB_EN: QG511.3 RG22.1 RG553.1 RG563.2 UG9.BB5 UG27.1
GPU_GC6_FB_EN_R: RG563.1 UH1.BD32
GPU_ID: RH25.1 RH26.1 UH1.AJ43
GPU_INV_PWM: RG150.1 UG9.BD7 UG24.5
GPU_MDP_N0: CV27.1 UG9.BG17
GPU_MDP_N1: CV30.1 UG9.BF15
GPU_MDP_N2: CV33.1 UG9.BF14
GPU_MDP_N3: CV31.1 UG9.BG14
GPU_MDP_P0: CV26.1 UG9.BH17
GPU_MDP_P1: CV28.1 UG9.BG15
GPU_MDP_P2: CV32.1 UG9.BE14
GPU_MDP_P3: CV29.1 UG9.BH14
GPU_OVERT#: DG3.1 QG502.3 RG505.2 UE6.21 UG23.6
GPU_PEX_RST_HOLD#: DG1.3 RG14.1 UG9.BG3
GPU_PWR_EN: RG551.2 RG552.2 UG25.2 UG26.1 UG28.1
GPU_TX0N: CV417.2 UG9.BM17
GPU_TX0N_C: CV417.1 UV21.2
GPU_TX0P: CV416.2 UG9.BM18
GPU_TX0P_C: CV416.1 UV21.1
GPU_TX1N: CV419.2 UG9.BK17
GPU_TX1N_C: CV419.1 UV21.5
GPU_TX1P: CV418.2 UG9.BL17
GPU_TX1P_C: CV418.1 UV21.4
GPU_TX2N: CV421.2 UG9.BL15
GPU_TX2N_C: CV421.1 UV21.7
GPU_TX2P: CV420.2 UG9.BK15
GPU_TX2P_C: CV420.1 UV21.6
GPU_TX3N: CV423.2 UG9.BM14
GPU_TX3N_C: CV423.1 UV21.10
GPU_TX3P: CV422.2 UG9.BM15
GPU_TX3P_C: CV422.1 UV21.9
H_CPUPWRGD: CH194.1 CPU1.BT31 UH1.AM3
H_DRAMRST#: CD69.1 CD91.1 CD92.1 JDIMM1.108 JDIMM2.108 RD35.2 UH1.BC14
H_PECI: CPU1.BT34 RE76.2 RH73.2
H_PECI_R: RH73.1 UH1.AL3
H_PM_DOWN: RH155.1 UH1.AH2
H_PM_SYNC_R: CPU1.BM34 UH1.AJ4
H_PROCHOT#: PQ8.1 PR724.1 QE2.1 RE78.2 RH158.1 RH165.2
H_THERMTRIP#: CPU1.J31 RH79.2 RH163.2
H_THERMTRIP#_R: RH79.1 UH1.AJ3
H_VCCST_PWRGD: CH193.1 Q7.3 RH154.1 RH164.2 UE5.123
HDA_SPKR: DA1.3 UH1.BD26
HDD_DET#: RH513.1 UH1.AG35
HDMI_CTRLCLK: QV96.4 RV648.2 UG9.BK9
HDMI_CTRLDAT: QV96.1 RV652.2 UG9.BL9
HDMI_DOWN: LX1.2 LX2.2 LX3.2 LX4.2 LX5.2 LX6.2 LX7.2 LX8.2 QX1.1
HDMI_HPD_GPU#: QV97.3 RX7.2 UG9.BA4
HDMI_HPD_PCH: QX3.3 RX8.1 UH1.AU41 UX2.1
HDMI_HPLUG: CX2.1 JHDMI.19 RX6.2
HP2_D_L1_JK: CA50.1 DA6.3 JACK2.1 LA12.1
HP2_D_L_C: CA49.2 RA43.1
HP2_D_L_R: LA12.2 RA41.2 RA43.2 RA44.1 RA46.1
HP2_D_R1_JK: CA48.1 DA6.2 JACK2.2 LA11.1
HP2_D_R_C: CA47.2 RA42.1
HP2_D_R_R: LA11.2 RA40.2 RA42.2 RA45.1 RA47.1
HP_LINE1_JD: CA41.1 RA32.2 RA34.1 RA36.1 UA1.9
HP_MUTE#: DA2.1 RA13.2 UA2.B1 UA3.B1
HPOUT-L: RA35.1 UA1.32
HPOUT-R: RA37.1 UA1.33
HPOUT_JD: JACK1.6 RA34.2
I2C0_SCL_EC: RA56.1 UA1.12 UE5.83
I2C0_SCL_EC_R: RA50.2 RA56.2 UA4.8
I2C0_SDA_EC: RA55.1 UA1.11 UE5.84
I2C0_SDA_EC_R: RA53.2 RA55.2 UA4.7
I2C_CLK: CE58.1 RE2.2 RM97.1 UE1.29 UE3.25 UE4.25
I2C_CTL_EN: RV21.1 RV22.1 UV21.53
I2C_DAT: RE1.2 RM98.1 UE1.30 UE3.26 UE4.26
I2CC_SCL: QG7.3 RG60.2 UG9.BG9 UG11.6
I2CC_SCL_R: QG7.4 RG12.2
I2CC_SDA: QG7.6 RG61.2 UG9.BH9 UG11.7
I2CC_SDA_R: QG7.1 RG11.2
I2S_DATA_OUT: RA33.2 UA4.14
I2S_DATA_OUT_R: CA40.1 RA33.1 UA1.5
I2S_LRCK: CA37.1 RA30.2 UA4.11
I2S_LRCK_R: RA30.1 UA1.1
I2S_OUT: CA36.1 RA31.2 UA4.12
I2S_OUT_R: RA31.1 UA1.3
I_SYS: PR526.1 PR728.2 PU700.9
IFPAB_RSET: RG36.1 UG9.BD23
IFPCD_RSET: RG37.1 UG9.BD20
IFPEF_RSET: RG38.1 UG9.BD17
IGPU_ENBKL: UH1.W35 UV22.10
IGPU_ENVDD: UH1.W42 UV22.6
IGPU_INV_PWM: UH1.W36 UV22.3
IGPU_ROM_CS#: RG147.2 UG15.1 UG16.2
IGPU_ROM_SCLK: RG148.1 UG15.6
IGPU_ROM_SI: RG149.1 UG15.5
IGPU_ROM_SO: RG146.1 UG16.5
IGPU_ROM_SO_R: RG146.2 UG15.2
IMVP_VR_ON: CE38.1 PR523.2 Q7.6 UE5.121
IN1_PEQ#: RV628.1 RV629.1 UV21.52
IN2_PEQ#: RV630.1 RV631.1 UV21.51
INV_PWM: JEDP.36 RV8.1 UV22.4
ISEN1_GT: PC528.2 PR587.2 PR589.2 PU500.9
ISEN1_VCORE: PC527.1 PR558.2 PR560.2 PR561.2 PU500.21
ISEN2_GT: PC525.2 PR596.2 PR598.2 PU500.10
ISEN2_VCORE: PC526.1 PR568.2 PR570.2 PR571.2 PU500.22
ISEN3_VCORE: PC524.1 PR578.2 PR580.2 PR581.2 PU500.23
ISENSEP_L: RA58.2 RA77.2 UA4.25
ISENSEP_L_R: CA254.1 LA50.2 RA57.1 RA58.1
ISENSEP_R: RA63.2 RA80.2 UA4.28
ISENSEP_R_R: CA256.1 LA52.2 RA60.1 RA63.1
ISUMN_GT: PC516.2 PC517.2 PC523.1 PC525.1 PC528.1 PH502.2 PR535.2 PR538.1 PR540.1 PR588.1 PR597.1
ISUMN_SA: PC510.1 PC511.1 PC512.1 PH501.1 PR524.2 PR528.1 PR529.1 PR5027.1
ISUMN_VCORE: PC524.2 PC526.2 PC527.2 PC529.1 PC530.1 PC531.1 PH503.1 PR541.2 PR542.1 PR543.2 PR559.1 PR569.1 PR579.1
ISUMP_GT: PC516.1 PC517.1 PR534.1 PR535.1 PR572.2 PR586.1 PR595.1 PU500.7
ISUMP_SA: PC510.2 PC512.2 PR529.2 PR530.2 PR582.2 PR5003.2 PU500.32
ISUMP_VCORE: PC530.2 PC531.2 PR542.2 PR544.2 PR557.1 PR562.2 PR567.1 PR577.1 PU500.19
IVSENSE_L: RA59.2 RA78.2 UA4.26
IVSENSE_R: RA64.2 RA81.2 UA4.29
JKSI0: JKB.30 RE471.1
JKSI1: JKB.29 RE474.1
JKSI2: JKB.28 RE466.1
JKSI3: JKB.27 RE467.1
JKSI4: JKB.26 RE461.1
JKSI5: JKB.25 RE460.1
JKSI6: JKB.24 RE455.1
JKSI7: JKB.23 RE454.1
JKSI8: JKB.22 RE396.1
JKSI9: JKB.21 RE399.1
JKSI10: JKB.20 RE476.1
JKSI11: JKB.19 RE480.1
JKSI12: JKB.18 RE482.1
JKSI13: JKB.17 RE486.1
JKSI14: JKB.16 RE488.1
JKSI15: JKB.15 RE492.1
JKSI16: JKB.14 RE495.1
JKSI17: JKB.13 RE498.1
JKSI18: JKB.12 RE502.1
JKSI19: JKB.11 RE503.1
JKSI20: JKB.10 RE507.1
JKSI21: JKB.9 RE510.1
JKSO0: JKB.8 QE49.6 QE54.6
JKSO1: JKB.7 QE50.6 QE54.3
JKSO2: JKB.6 QE51.6 QE55.6
JKSO3: JKB.5 QE52.6 QE55.3
JKSO4: JKB.4 QE53.6 QE56.6
JRTC1: PD5.2 PR2.1
JTAG_TCLK: T10.1(TP-1) UG9.BK24
JTAG_TDI: T12.1(TP-1) UG9.BM23
JTAG_TDO: T13.1(TP-1) UG9.BM24
JTAG_TMS: T11.1(TP-1) UG9.BL23
JTAG_TRST#: RG518.1 UG9.BL24
KB_LED_B1_DRV#: JKBBL.5 UE4.5
KB_LED_B2_DRV#: JKBBL.8 UE4.9
KB_LED_B3_DRV#: JKBBL.11 UE4.14
KB_LED_B4_DRV#: JKBBL.14 UE4.17
KB_LED_G1_DRV#: JKBBL.4 UE4.4
KB_LED_G2_DRV#: JKBBL.7 UE4.8
KB_LED_G3_DRV#: JKBBL.10 UE4.11
KB_LED_G4_DRV#: JKBBL.13 UE4.16
KB_LED_R1_DRV#: JKBBL.3 UE4.3
KB_LED_R2_DRV#: JKBBL.6 UE4.6
KB_LED_R3_DRV#: JKBBL.9 UE4.10
KB_LED_R4_DRV#: JKBBL.12 UE4.15
KB_RST#: RE646.2 RH518.1 UH1.AT17
KSI0: QE42.3 RE469.2 UE5.55
KSI1: QE42.6 RE470.2 UE5.56
KSI2: QE41.3 RE464.2 UE5.57
KSI3: QE41.6 RE463.2 UE5.58
KSI4: JEC.4 QE40.3 RE459.2 UE5.59
KSI5: JEC.5 QE40.6 RE457.2 UE5.60
KSI6: JEC.2 QE39.3 RE452.2 UE5.61
KSI7: JEC.3 QE39.6 RE451.2 UE5.62
KSI8: QE29.3 RE398.2 UE5.47
KSI9: QE29.6 RE400.2 UE5.48
KSI10: QE43.3 RE475.2 UE5.49
KSI11: QE43.6 RE477.2 UE5.50
KSI12: QE44.3 RE481.2 UE5.51
KSI13: QE44.6 RE483.2 UE5.52
KSI14: QE45.3 RE487.2 UE5.53
KSI15: QE45.6 RE489.2 UE5.54
KSI16: QE46.3 RE493.2 UE5.45
KSI17: QE46.6 RE494.2 UE5.46
KSI18: QE47.3 RE500.2 UE5.81
KSI19: QE47.6 RE499.2 UE5.82
KSI20: QE48.3 RE505.2 UE5.85
KSI21: QE48.6 RE506.2 UE5.86
KSO0: RE513.1 UE5.39
KSO1: RE531.1 UE5.40
KSO2: RE534.1 UE5.41
KSO3: JEC.1 RE536.1 UE5.42
KSO4: RE540.1 UE5.43
LAN_ACTIVITY#: CL27.1 JLAN.10 UL1.38
LAN_LED2#: CL29.1 JLAN.13 RL15.1
LAN_LED2#_R: RL15.2 UL1.23
LAN_LINK#: CL28.1 JLAN.11 RL13.1
LAN_LINK#_R: QL3.2 RL4.2 UL1.39
LAN_MDIN0: TL1.11 UL1.12
LAN_MDIN1: TL1.7 UL1.15
LAN_MDIN2: TL1.5 UL1.18
LAN_MDIN3: TL1.1 UL1.21
LAN_MDIP0: TL1.12 UL1.11
LAN_MDIP1: TL1.8 UL1.14
LAN_MDIP2: TL1.6 UL1.17
LAN_MDIP3: TL1.2 UL1.20
LCD_TEST: JEDP.31 UE5.72
LDO2-CAP: CA28.1 CA29.1 RA12.2 UA1.22
LG_3V: PQ101.4 PU100.11
LG_5V: PQ103.4 PU100.15
LG_+1VALWP: PQ301.4 PU300.6
LID_SW: DE1.2 RE8.2 UE1.23
LID_SW#: CE43.1 CH1.1 DE1.1 RE70.2 UE5.115 UH5.3
LINE1_JD: JACK2.5 RA36.2
LINE1_L: CA49.1 UA1.35
LINE1_R: CA47.1 UA1.34
LINE1_VREFO_L: RA41.1 UA1.40
LINE1_VREFO_R: RA40.1 UA1.39
LINE-IN-L: LA9.2 RA35.2 RA38.1
LINE-IN-R: LA10.2 RA37.2 RA39.1
LOGO_LED_B_DRV#: JLOGO.8 UE3.9
LOGO_LED_G_DRV#: JLOGO.7 UE3.8
LOGO_LED_R_DRV#: JLOGO.6 UE3.6
LPC_AD0: UE5.10 UH1.AT22
LPC_AD1: UE5.8 UH1.AV22
LPC_AD2: UE5.7 UH1.AT19
LPC_AD3: UE5.5 UH1.BD16
LPC_FRAME#: UE5.4 UH1.BE16
LX_1.0VS_VGAP: PC808.2 PL800.1 PR803.1 PU800.6 PU800.19 PU800.20
LX_3V: PC105.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ101.5 PR110.1 PU100.8
LX_5V: PC106.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ103.5 PR111.1 PU100.18
LX_+1.8VGS: PL801.1 PR809.1 PU802.2 PU802.3
LX_CHG: PC702.1 PL700.1 PQ704.1 PQ704.2 PQ704.3 PQ706.5 PR713.1 PU700.27
LX_VCCIO: PC593.2 PL509.1 PR5009.1 PU509.6 PU509.19 PU509.20
M2_SLOT1_PEDET: JSSD1.69 R363.1 UH1.AG36
M2_SLOT2_PEDET: JSSD2.69 R365.1 UH1.AD35
M_CLK_DDR0: CPU1.AG1 JDIMM1.137
M_CLK_DDR1: CPU1.AK2 JDIMM1.138
M_CLK_DDR2: CPU1.AM9 JDIMM2.137
M_CLK_DDR3: CPU1.AM7 JDIMM2.138
M_CLK_DDR#0: CPU1.AG2 JDIMM1.139
M_CLK_DDR#1: CPU1.AK1 JDIMM1.140
M_CLK_DDR#2: CPU1.AN9 JDIMM2.139
M_CLK_DDR#3: CPU1.AM8 JDIMM2.140
M_ODT0: CPU1.AD3 JDIMM1.155
M_ODT1: CPU1.AE4 JDIMM1.161
M_ODT2: CPU1.AF7 JDIMM2.155
M_ODT3: CPU1.AE8 JDIMM2.161
MDP_AUX#_SDA: RV618.2 RV665.1 UG9.BL8 UV3.6 UV3.13
MDP_AUX_SCL: RV619.2 RV664.1 UG9.BK8 UV3.3 UV3.10
MDP_HPD: CX1.1 JDP.2 RX2.2
MDP_LANE_N0_C: CV27.2 JDP.5
MDP_LANE_N1_C: CV30.2 JDP.11
MDP_LANE_N2_C: CV33.2 JDP.17
MDP_LANE_N3_C: CV31.2 JDP.12
MDP_LANE_P0_C: CV26.2 JDP.3
MDP_LANE_P1_C: CV28.2 JDP.9
MDP_LANE_P2_C: CV32.2 JDP.15
MDP_LANE_P3_C: CV29.2 JDP.10
ME_EN: RH16.1 UE5.99
ME_SUS_PWR_ACK: RH506.1 UE5.71 UH1.BD19
MEM_VDD_CTL: PR8214.1 UG9.BH4
MEM_VREF: QG2.2 QG3.2 QG4.2 RG24.1 UG9.BD3
MIC1-VREFO_L: RA26.1 RA28.1 UA1.38
MIC_CLK: CA34.1 JEDP.23 LA6.1 RV13.1
MIC_DATA: CA35.1 JEDP.22 RA19.1
MUX_EDP_A0N: CV2.2 UV21.45
MUX_EDP_A0P: CV1.2 UV21.46
MUX_EDP_A1N: CV4.2 UV21.42
MUX_EDP_A1P: CV3.2 UV21.43
MUX_EDP_A2N: CV6.2 UV21.39
MUX_EDP_A2P: CV8.2 UV21.40
MUX_EDP_A3N: CV11.2 UV21.36
MUX_EDP_A3P: CV7.2 UV21.37
MUX_EDP_AUXN: CV13.2 RV19.2 UV21.31
MUX_EDP_AUXP: CV12.2 RV20.1 UV21.32
NC_B4: RT45.1 RT86.2 UT1.B4
NC_B5: RT46.1 UT1.B5
NC_G2: RT47.1 UT1.G2
NVVDD1_EN: CG442.1 DG7.1 PR6102.1 PR6103.2 PU6100.3 QG509.2 RG549.2 RG568.1
NVVDD1_PGOOD: DG4.1 PR6107.1 PR6201.1 PU6100.13 UG29.2
NVVDD1_PSI: PR6108.2 PR6132.2 PR6133.2 PU6100.4
NVVDD2_EN: PR6201.2 PR6202.1 PR8217.2 PU6200.3 QG507.2 RG569.1 UG28.4
NVVDD2_PGOOD: DG4.2 PR801.2 PR6205.1 PU6200.13 QG502.4 RG506.2
NVVDD2_PSI: PR6228.2 PR6229.2 PR6230.1 PU6200.4
NVVDD_B+: PC6101.1 PC6102.1 PC6103.1 PC6104.1 PC6105.1 PC6106.1 PC6111.1 PC6112.1 PC6113.1 PC6114.1 PC6115.1 PC6116.1 PC6122.1 PC6123.1 PC6124.1 PC6130.2 PC6131.2 PC6132.2 PC6133.2 PC6134.2 PC6135.2 PQ6100.2 PQ6101.2 PQ6102.2 PQ6103.2 PR6101.4
NVVDD_BST1: PR6104.1 PU6100.1
NVVDD_BST2: PR6105.1 PU6100.15
NVVDD_COMP: PC6109.2 PR6109.2 PR6112.2 PU6100.12
NVVDD_HG1: PQ6100.1 PQ6101.1 PU6100.2
NVVDD_HG2: PQ6102.1 PQ6103.1 PU6100.14
NVVDD_LG1: PQ6100.6 PQ6101.6 PU6100.19
NVVDD_LG2: PQ6102.6 PQ6103.6 PU6100.17
NVVDD_PSI: PR6108.1 RG15.1 RG565.1 RG566.2
NVVDD_SW1: PC6107.1 PL6100.1 PL6100.2 PQ6100.7 PQ6101.7 PR6129.1 PU6100.20
NVVDD_SW2: PC6108.1 PL6101.1 PL6101.2 PQ6102.7 PQ6103.7 PR6130.1 PU6100.16
NVVDD_VCC_SENSE: PR6123.1 PR6126.2 UG9.BK45
NVVDD_VID: PR6110.1 UG9.BD6
NVVDD_VIDBUF: PR6119.1 PU6100.6
NVVDD_VREF: PC6120.2 PR6127.1 PU6100.8
NVVDD_VSS_SENSE: PR6122.1 PR6128.2 UG9.BL45
NVVDDS_B+: PC6201.1 PC6202.1 PC6203.1 PC6204.1 PC6205.1 PC6206.1 PC6217.1 PC6219.2 PC6220.2 PC6221.2 PQ6200.2 PQ6201.2 PR6200.4
NVVDDS_BST1: PR6203.1 PU6200.1
NVVDDS_COMP: PC6209.2 PR6207.2 PR6210.2 PU6200.12
NVVDDS_HG1: PQ6200.1 PQ6201.1 PU6200.2
NVVDDS_LG1: PQ6200.6 PQ6201.6 PU6200.19
NVVDDS_PSI: PR6228.1 RG503.1 RG564.2 RG565.2
NVVDDS_SW1: PC6207.1 PL6200.1 PL6200.2 PQ6200.7 PQ6201.7 PR6226.1 PU6200.20
NVVDDS_VCC_SENSE: PR6220.1 PR6223.2 UG9.BM45
NVVDDS_VID: PR6208.1 UG9.BE4
NVVDDS_VIDBUF: PR6216.1 PU6200.6
NVVDDS_VREF: PC6214.2 PR6224.1 PU6200.8
NVVDDS_VSS_SENSE: PR6219.1 PR6225.2 UG9.BM44
ON/OFF#: CE27.1 JPWR.3 JPWR.4 RE63.1 SW1.2 SW2.2 UE5.114
OUT_A: CA67.1 CA87.1 LA50.1 UA4.55
OUT_B: CA68.1 CA88.1 LA51.1 UA4.52
OUT_C: CA69.1 CA89.1 LA52.1 UA4.47
OUT_D: CA70.1 CA90.1 LA53.1 UA4.44
OVERT#: RG9.1 UG9.BG5 UG23.5
P1: PC701.1 PQ700.3 PQ701.1 PQ701.2 PQ701.3 PQ702.1 PQ702.2 PQ702.3 PQ707.1 PQ707.2 PQ707.3 PR701.2 PR706.1
P2: PQ702.5 PR702.1
PA_USB2_RBIAS: RT43.1 UT1.H19
PB_USB2_RBIAS: RT44.1 UT1.F19
PBTN_OUT#: CH174.1 RH2.2 UE5.106 UH1.AT13
PC0: RV624.1 RV625.1 UV21.38
PC1: RV626.1 RV627.1 UV21.55
PC_BEEP: DA1.1 RA9.1 RA15.1
PCH_AZ_BITCLK: RP2.5 UH1.BA9
PCH_AZ_CODEC_BITCLK: RA2.1 RP2.4 UA1.13
PCH_AZ_CODEC_RST#: RA17.2 RP2.3
PCH_AZ_CODEC_RST#_R: RA17.1 UA1.15
PCH_AZ_CODEC_SDIN0: RA18.1 UH1.BE7
PCH_AZ_CODEC_SDOUT: RA10.1 RP2.1 UA1.17
PCH_AZ_CODEC_SYNC: RP2.2 UA1.14
PCH_AZ_RST#: RP2.6 UH1.BD8
PCH_AZ_SDOUT: RH16.2 RP2.8 UH1.BB7
PCH_AZ_SYNC: RP2.7 UH1.BD9
PCH_BATLOW#: RH515.1 RT14.2 UH1.BD13
PCH_CPU_BCLK_N: CPU1.A32 UH1.H2
PCH_CPU_BCLK_P: CPU1.B31 UH1.G2
PCH_CPU_PCIBCLK_N: CPU1.C36 UH1.J1
PCH_CPU_PCIBCLK_P: CPU1.D35 UH1.J2
PCH_DPWROK: DE4.2 RH90.2 UE5.127 UH1.AV11
PCH_JTAG_TCK: CPU1.BR28 JPCMC.32 RC35.1 UH1.AR3
PCH_PLTRST#: UG10.2 UH1.BB27 UH3.1 UH3.2 UM3.2
PCH_PWR_EN: C268.1 PR300.1 RE74.1 U18.4
PCH_PWROK: CE44.1 DE3.2 RE75.1 UE5.32 UH1.AW11
PCH_RTCRST#: CH53.1 CLRP1.1 QE5.1 RH84.2 UH1.BC10
PCH_RTCX1: CH45.1 RH70.1 UH1.BC9 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH1.BD10 YH1.2
PCH_SATALED#: RH512.1 UH1.AD44
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JTP.15 RH463.2 UH1.AW44
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JTP.16 RH462.2 UH1.BB43
PCH_SPI_CLK: RH104.1 UH4.6
PCH_SPI_CLK_R: RH104.2 UH1.BC31
PCH_SPI_CS#: UH1.BD31 UH4.1
PCH_SPI_HOLD#: RPH5.4 UH4.7
PCH_SPI_HOLD#_R: RH78.2 RPH5.5 UH1.BD30
PCH_SPI_SI: RPH5.2 UH4.5
PCH_SPI_SI_R: RH1.2 RH489.1 RPH5.7 UH1.BB29
PCH_SPI_SO: RPH5.3 UH4.2
PCH_SPI_SO_R: RPH5.6 UH1.BE30
PCH_SPI_WP#: RPH5.1 UH4.3
PCH_SPI_WP#_R: RC354.2 RH75.2 RPH5.8 UH1.BC29
PCH_SRTCRST#: CH52.1 RH83.2 UH1.BB10
PCH_SYS_PWROK_XDP: RH489.2 RH493.2
PCH_TRIGGER: RH167.1 UH1.AL2
PCH_XDP_CLK_N: T19.1(TP-1) UH1.L1
PCH_XDP_CLK_P: T21.1(TP-1) UH1.L2
PCIE_GEN3#_GEN2: UE1.18 UE6.11
PCIE_PRX_DTX_N5: CL2.2 UH1.K19
PCIE_PRX_DTX_N5_C: CL2.1 UL1.29
PCIE_PRX_DTX_N6: JWLAN.35 UH1.G22
PCIE_PRX_DTX_N9: JSSD1.43 UH1.G31
PCIE_PRX_DTX_N10: JSSD1.29 UH1.G29
PCIE_PRX_DTX_N11: JSSD1.17 UH1.L31
PCIE_PRX_DTX_N12: JSSD1.5 UH1.G33
PCIE_PRX_DTX_N13: JSSD2.5 UH1.G35
PCIE_PRX_DTX_N14: JSSD2.17 UH1.D39
PCIE_PRX_DTX_N15: JSSD2.29 UH1.F41
PCIE_PRX_DTX_N16: JSSD2.43 UH1.D43
PCIE_PRX_DTX_P5: CL1.2 UH1.L19
PCIE_PRX_DTX_P5_C: CL1.1 UL1.30
PCIE_PRX_DTX_P6: JWLAN.33 UH1.E22
PCIE_PRX_DTX_P9: JSSD1.41 UH1.H31
PCIE_PRX_DTX_P10: JSSD1.31 UH1.E29
PCIE_PRX_DTX_P11: JSSD1.19 UH1.K31
PCIE_PRX_DTX_P12: JSSD1.7 UH1.H33
PCIE_PRX_DTX_P13: JSSD2.7 UH1.E35
PCIE_PRX_DTX_P14: JSSD2.19 UH1.E37
PCIE_PRX_DTX_P15: JSSD2.31 UH1.E41
PCIE_PRX_DTX_P16: JSSD2.41 UH1.E42
PCIE_PTX_DRX_N5: CL4.2 UH1.D22
PCIE_PTX_DRX_N5_C: CL4.1 UL1.36
PCIE_PTX_DRX_N6: CN24.2 UH1.B22
PCIE_PTX_DRX_N6_C: CN24.1 JWLAN.29
PCIE_PTX_DRX_N9: CH210.1 JSSD1.47
PCIE_PTX_DRX_N9_C: CH210.2 UH1.C31
PCIE_PTX_DRX_N10: CH212.1 JSSD1.35
PCIE_PTX_DRX_N10_C: CH212.2 UH1.C32
PCIE_PTX_DRX_N11: CH203.2 JSSD1.23
PCIE_PTX_DRX_N11_C: CH203.1 UH1.C33
PCIE_PTX_DRX_N12: CH209.2 JSSD1.11
PCIE_PTX_DRX_N12_C: CH209.1 UH1.B35
PCIE_PTX_DRX_N13: CH206.2 JSSD2.11
PCIE_PTX_DRX_N13_C: CH206.1 UH1.C36
PCIE_PTX_DRX_N14: CH204.2 JSSD2.23
PCIE_PTX_DRX_N14_C: CH204.1 UH1.B38
PCIE_PTX_DRX_N15: CH214.1 JSSD2.35
PCIE_PTX_DRX_N15_C: CH214.2 UH1.B39
PCIE_PTX_DRX_N16: CH216.1 JSSD2.47
PCIE_PTX_DRX_N16_C: CH216.2 UH1.A41
PCIE_PTX_DRX_P5: CL3.2 UH1.C22
PCIE_PTX_DRX_P5_C: CL3.1 UL1.35
PCIE_PTX_DRX_P6: CN23.2 UH1.A23
PCIE_PTX_DRX_P6_C: CN23.1 JWLAN.27
PCIE_PTX_DRX_P9: CH211.1 JSSD1.49
PCIE_PTX_DRX_P9_C: CH211.2 UH1.B31
PCIE_PTX_DRX_P10: CH213.1 JSSD1.37
PCIE_PTX_DRX_P10_C: CH213.2 UH1.B32
PCIE_PTX_DRX_P11: CH202.2 JSSD1.25
PCIE_PTX_DRX_P11_C: CH202.1 UH1.B33
PCIE_PTX_DRX_P12: CH208.2 JSSD1.13
PCIE_PTX_DRX_P12_C: CH208.1 UH1.A35
PCIE_PTX_DRX_P13: CH207.2 JSSD2.13
PCIE_PTX_DRX_P13_C: CH207.1 UH1.B36
PCIE_PTX_DRX_P14: CH205.2 JSSD2.25
PCIE_PTX_DRX_P14_C: CH205.1 UH1.C38
PCIE_PTX_DRX_P15: CH215.1 JSSD2.37
PCIE_PTX_DRX_P15_C: CH215.2 UH1.A39
PCIE_PTX_DRX_P16: CH217.1 JSSD2.49
PCIE_PTX_DRX_P16_C: CH217.2 UH1.A40
PCIE_RBIAS: RT3.1 UT1.N16
PCIE_WAKE#: RH4.1 RL1.2 UE5.64 UL1.3
PCIECOMP: RH193.1 UH1.C17
PCIECOMP#: RH193.2 UH1.B18
PCIRST#: CE34.1 JSSD1.50 JSSD2.50 JWLAN.44 RC355.2 RH199.1 RT1.1 UE5.13 UH3.4 UL1.2
PD_EE_CLK: RT101.2 UT4.A3
PD_EE_CS_N: RT100.2 UT4.B3
PD_EE_DI: RT98.2 UT4.B4
PD_EE_DO: RT99.2 UT4.A4
PD_IRQ#: RT107.2 UE5.89 UT4.B6
PD_RESET: RT109.1 UE10.8
PD_UART: RT62.1 UT4.E2 UT4.F2
PECI_KB9012: RE76.1 UE5.118
PEG_CRX_GTX_C_N8: CM66.2 UM8.4
PEG_CRX_GTX_C_N9: CM65.2 UM8.8
PEG_CRX_GTX_C_N10: CM62.2 UM8.6
PEG_CRX_GTX_C_N11: CM69.2 UM8.2
PEG_CRX_GTX_C_P8: CM63.2 UM8.3
PEG_CRX_GTX_C_P9: CM64.2 UM8.7
PEG_CRX_GTX_C_P10: CM68.2 UM8.5
PEG_CRX_GTX_C_P11: CM67.2 UM8.1
PEG_CRX_GTX_N0: CG9.1 CPU1.E10
PEG_CRX_GTX_N0_C: CG9.2 UG9.BH26
PEG_CRX_GTX_N1: CG16.1 CPU1.E11
PEG_CRX_GTX_N1_C: CG16.2 UG9.BE26
PEG_CRX_GTX_N2: CG25.1 CPU1.E12
PEG_CRX_GTX_N2_C: CG25.2 UG9.BG27
PEG_CRX_GTX_N3: CG27.1 CPU1.E13
PEG_CRX_GTX_N3_C: CG27.2 UG9.BH29
PEG_CRX_GTX_N4: CG29.1 CPU1.E14
PEG_CRX_GTX_N4_C: CG29.2 UG9.BE29
PEG_CRX_GTX_N5: CG31.1 CPU1.E15
PEG_CRX_GTX_N5_C: CG31.2 UG9.BG30
PEG_CRX_GTX_N6: CG33.1 CPU1.E16
PEG_CRX_GTX_N6_C: CG33.2 UG9.BH32
PEG_CRX_GTX_N7: CG36.1 CPU1.E17
PEG_CRX_GTX_N7_C: CG36.2 UG9.BE32
PEG_CRX_GTX_N8: CM66.1 CPU1.F18
PEG_CRX_GTX_N9: CM65.1 CPU1.D19
PEG_CRX_GTX_N10: CM62.1 CPU1.F20
PEG_CRX_GTX_N11: CM69.1 CPU1.D21
PEG_CRX_GTX_P0: CG8.1 CPU1.F10
PEG_CRX_GTX_P0_C: CG8.2 UG9.BG26
PEG_CRX_GTX_P1: CG10.1 CPU1.D11
PEG_CRX_GTX_P1_C: CG10.2 UG9.BF26
PEG_CRX_GTX_P2: CG22.1 CPU1.F12
PEG_CRX_GTX_P2_C: CG22.2 UG9.BF27
PEG_CRX_GTX_P3: CG26.1 CPU1.D13
PEG_CRX_GTX_P3_C: CG26.2 UG9.BG29
PEG_CRX_GTX_P4: CG28.1 CPU1.F14
PEG_CRX_GTX_P4_C: CG28.2 UG9.BF29
PEG_CRX_GTX_P5: CG30.1 CPU1.D15
PEG_CRX_GTX_P5_C: CG30.2 UG9.BF30
PEG_CRX_GTX_P6: CG32.1 CPU1.F16
PEG_CRX_GTX_P6_C: CG32.2 UG9.BG32
PEG_CRX_GTX_P7: CG35.1 CPU1.D17
PEG_CRX_GTX_P7_C: CG35.2 UG9.BF32
PEG_CRX_GTX_P8: CM63.1 CPU1.E18
PEG_CRX_GTX_P9: CM64.1 CPU1.E19
PEG_CRX_GTX_P10: CM68.1 CPU1.E20
PEG_CRX_GTX_P11: CM67.1 CPU1.E21
PEG_CRX_TTX_N12: CPU1.F22 CT16.1
PEG_CRX_TTX_N12_C: CT16.2 UT1.V22
PEG_CRX_TTX_N13: CPU1.D23 CT2.1
PEG_CRX_TTX_N13_C: CT2.2 UT1.P22
PEG_CRX_TTX_N14: CPU1.F24 CT108.1
PEG_CRX_TTX_N14_C: CT108.2 UT1.K22
PEG_CRX_TTX_N15: CPU1.D25 CT110.1
PEG_CRX_TTX_N15_C: CT110.2 UT1.F22
PEG_CRX_TTX_P12: CPU1.E22 CT14.1
PEG_CRX_TTX_P12_C: CT14.2 UT1.V23
PEG_CRX_TTX_P13: CPU1.E23 CT12.1
PEG_CRX_TTX_P13_C: CT12.2 UT1.P23
PEG_CRX_TTX_P14: CPU1.E24 CT109.1
PEG_CRX_TTX_P14_C: CT109.2 UT1.K23
PEG_CRX_TTX_P15: CPU1.E25 CT111.1
PEG_CRX_TTX_P15_C: CT111.2 UT1.F23
PEG_CTX_C_GRX_N0: CC1.2 UG9.BK27
PEG_CTX_C_GRX_N1: CC2.2 UG9.BL29
PEG_CTX_C_GRX_N2: CC3.2 UG9.BM30
PEG_CTX_C_GRX_N3: CC4.2 UG9.BK30
PEG_CTX_C_GRX_N4: CC5.2 UG9.BL32
PEG_CTX_C_GRX_N5: CC6.2 UG9.BM33
PEG_CTX_C_GRX_N6: CC7.2 UG9.BK33
PEG_CTX_C_GRX_N7: CC8.2 UG9.BL35
PEG_CTX_C_GRX_N8: CC9.2 JCDRA.4
PEG_CTX_C_GRX_N9: CC10.2 JCDRA.7
PEG_CTX_C_GRX_N10: CC11.2 JCDRA.10
PEG_CTX_C_GRX_N11: CC12.2 JCDRA.13
PEG_CTX_C_GRX_P0: CC13.2 UG9.BL27
PEG_CTX_C_GRX_P1: CC14.2 UG9.BK29
PEG_CTX_C_GRX_P2: CC15.2 UG9.BM29
PEG_CTX_C_GRX_P3: CC16.2 UG9.BL30
PEG_CTX_C_GRX_P4: CC17.2 UG9.BK32
PEG_CTX_C_GRX_P5: CC18.2 UG9.BM32
PEG_CTX_C_GRX_P6: CC19.2 UG9.BL33
PEG_CTX_C_GRX_P7: CC20.2 UG9.BK35
PEG_CTX_C_GRX_P8: CC21.2 JCDRA.3
PEG_CTX_C_GRX_P9: CC22.2 JCDRA.6
PEG_CTX_C_GRX_P10: CC23.2 JCDRA.9
PEG_CTX_C_GRX_P11: CC24.2 JCDRA.12
PEG_CTX_GRX_N0: CC1.1 CPU1.B10
PEG_CTX_GRX_N1: CC2.1 CPU1.B11
PEG_CTX_GRX_N2: CC3.1 CPU1.B12
PEG_CTX_GRX_N3: CC4.1 CPU1.B13
PEG_CTX_GRX_N4: CC5.1 CPU1.B14
PEG_CTX_GRX_N5: CC6.1 CPU1.B15
PEG_CTX_GRX_N6: CC7.1 CPU1.B16
PEG_CTX_GRX_N7: CC8.1 CPU1.B17
PEG_CTX_GRX_N8: CC9.1 CPU1.C18
PEG_CTX_GRX_N9: CC10.1 CPU1.A19
PEG_CTX_GRX_N10: CC11.1 CPU1.C20
PEG_CTX_GRX_N11: CC12.1 CPU1.A21
PEG_CTX_GRX_P0: CC13.1 CPU1.C10
PEG_CTX_GRX_P1: CC14.1 CPU1.A11
PEG_CTX_GRX_P2: CC15.1 CPU1.C12
PEG_CTX_GRX_P3: CC16.1 CPU1.A13
PEG_CTX_GRX_P4: CC17.1 CPU1.C14
PEG_CTX_GRX_P5: CC18.1 CPU1.A15
PEG_CTX_GRX_P6: CC19.1 CPU1.C16
PEG_CTX_GRX_P7: CC20.1 CPU1.A17
PEG_CTX_GRX_P8: CC21.1 CPU1.B18
PEG_CTX_GRX_P9: CC22.1 CPU1.B19
PEG_CTX_GRX_P10: CC23.1 CPU1.B20
PEG_CTX_GRX_P11: CC24.1 CPU1.B21
PEG_CTX_TRX_N12: CPU1.C22 CT15.1
PEG_CTX_TRX_N12_C: CT15.2 UT1.Y22
PEG_CTX_TRX_N13: CPU1.A23 CT13.1
PEG_CTX_TRX_N13_C: CT13.2 UT1.T22
PEG_CTX_TRX_N14: CPU1.C24 CT18.1
PEG_CTX_TRX_N14_C: CT18.2 UT1.M22
PEG_CTX_TRX_N15: CPU1.A25 CT21.1
PEG_CTX_TRX_N15_C: CT21.2 UT1.H22
PEG_CTX_TRX_P12: CPU1.B22 CT3.1
PEG_CTX_TRX_P12_C: CT3.2 UT1.Y23
PEG_CTX_TRX_P13: CPU1.B23 CT1.1
PEG_CTX_TRX_P13_C: CT1.2 UT1.T23
PEG_CTX_TRX_P14: CPU1.B24 CT4.1
PEG_CTX_TRX_P14_C: CT4.2 UT1.M23
PEG_CTX_TRX_P15: CPU1.B25 CT5.1
PEG_CTX_TRX_P15_C: CT5.2 UT1.H23
PEG_RCOMP: CPU1.G2 RC2.2
PEX_CLKREQ#: QG510.3 RG2.1 UG9.BL26
PEX_TERMP: RG23.2 UG9.BL44
PEX_VDD_ENP: PC801.1 PR801.1 PR802.1 PR823.1 PR8217.1 PU800.11
PI0: RV622.1 RV623.1 UV21.56
PLTRST_CPU#: CH195.1 CPU1.BP35 UH1.AK2
PM_SLP_S3#: CE41.1 Q8.2 QE1.5 UE5.6 UH1.AW15
PM_SLP_S3_H: Q7.2 Q7.5 Q8.5 Q8.6 R307.2
PM_SLP_S4#: PR1301.2 Q9.2 UE5.73 UH1.BD15
PM_SLP_S4_H: Q9.5 Q9.6 R325.2
PM_SLP_S5#: CE45.1 QE4.5 UE5.14 UH1.BA13
PM_SLP_SUS#: UE5.38 UH1.BB13
POK: DE2.1 DE3.1 DE4.1 PR14.1 PR17.2 PU100.7
POWER_LED: QE4.6 QE8.2 RE28.2 UE7.4
PQ703_S: PC725.2 PL700.2 PQ703.1 PQ703.2 PQ703.3 PR712.1 PR734.1
PROC_DETECT#: RH519.1 UH1.Y44
PS_ID: PR3.1 PR4.2 UE5.16
PSID: PJPDC1.2 PL2.2
PSID-1: PQ2.2 PR6.1 PR9.2
PSID-2: PQ2.1 PQ7.2 PR8.2
PSID-3: PQ7.3 PR4.1
PWM1_GT: PR590.1 PU500.12
PWM1_VCORE: PR552.1 PU500.25
PWM2_GT: PR591.1 PU500.13
PWM2_VCORE: PR563.1 PU500.26
PWM3_VCORE: PR573.1 PU500.27
PWM_SA: PR5001.2 PU500.35
PWR_B#: JPWR.7 JPWR.8 QE13.3 RE153.1 RE154.2
PWR_B_7313#: QE13.4 UE3.17
PWR_B_EC: QE13.2 UE6.22
PWR_G#: JPWR.5 JPWR.6 QE21.3 RE155.1 RE156.2
PWR_G_7313#: QE21.4 UE3.16
PWR_G_EC: QE21.2 UE6.10
PWR_LED#: QE4.2 UE5.92
PWR_R#: JPWR.9 JPWR.10 QE22.3 RE157.1 RE158.2
PWR_R_7313#: QE22.4 UE3.15
PWR_R_EC: QE22.2 UE6.6
PWR_SRC_ON: CV15.2 QV1.3 RV9.2 RV12.1
PWR_VGA_CORE_BOOT1: PR8205.2 PU8200.1
PWR_VGA_CORE_BOOT1_1: PC8206.2 PR8205.1
PWR_VGA_CORE_BOOT2: PR8207.2 PU8200.15
PWR_VGA_CORE_BOOT2_1: PC8212.2 PR8207.1
PWR_VGA_CORE_LGATE1: PQ8200.6 PR8206.2 PU8200.19
PWR_VGA_CORE_LGATE2: PQ8201.6 PU8200.17
PWR_VGA_CORE_PHASE1: PC8206.1 PL8200.1 PQ8200.7 PR8203.1 PU8200.20
PWR_VGA_CORE_PHASE2: PC8212.1 PL8201.1 PQ8201.7 PR8210.1 PU8200.16
PWR_VGA_CORE_SS: PC8217.1 PU8200.11
PWR_VGA_CORE_TON: PR8202.1 PU8200.9
PWR_VGA_CORE_TON_1: PC8205.1 PR8201.1 PR8202.2
PWR_VGA_CORE_UGATE1: PQ8200.1 PU8200.2
PWR_VGA_CORE_UGATE2: PQ8201.1 PU8200.14
PWRSHARE_EN_EC#: UE5.119 UU1.5
REGN_CHG: PC710.1 PR714.1 PU700.24
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 R368.1
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 R368.2 U2407.3
REMOTE3+: C2510.1 C2511.1 Q2411.1 Q2411.2 U2407.5
REMOTE3-: C2510.2 C2511.2 Q2411.3 R185.2
RESET_N: RT102.1 UT4.F11
RF_+1VALWP: PR306.1 PU300.5
RING2: LA8.2 RA28.2 UA1.36
RING2_R: CA46.1 CA92.1 DA5.2 JACK1.4 LA8.1
RJ45_CT: CL30.2 RL9.2 RL10.2 RL11.2 RL12.2
RJ45_CT0: RL12.1 TL1.15
RJ45_CT1: RL11.1 TL1.16
RJ45_CT2: RL10.1 TL1.21
RJ45_CT3: RL9.1 TL1.22
RJ45_MDI0+: JLAN.1 TL1.13
RJ45_MDI0-: JLAN.2 TL1.14
RJ45_MDI1+: JLAN.3 TL1.17
RJ45_MDI1-: JLAN.6 TL1.18
RJ45_MDI2+: JLAN.4 TL1.19
RJ45_MDI2-: JLAN.5 TL1.20
RJ45_MDI3+: JLAN.7 TL1.23
RJ45_MDI3-: JLAN.8 TL1.24
ROM_CS#: RG538.2 UG9.BJ4 UG16.1
ROM_SCLK: RG75.2 RG86.1 RG89.2 RG148.2 UG9.BK3
ROM_SI: RG77.2 RG84.1 RG87.2 RG149.2 UG9.BK2
ROM_SO: RG85.1 RG88.2 RG539.2 UG9.BK4 UG16.4
RPD_G1: RT64.1 UT4.K9
RPD_G2: RT65.1 UT4.K10
RST#: CE55.2 RE91.2 UE6.3
RT8812_PVCC: PC8200.1 PR8200.1 PU8200.18
RTD3_CIO_PWR_EN: RT16.2 UH1.AR44
RTD3_CIO_PWR_EN_R: RT16.1 RT36.1 UT1.F1
RTD3_USB_PWR_EN: RT12.2 UH1.AR41
RTD3_USB_PWR_EN_R: RT12.1 RT37.1 UT1.D4
SERIRQ: RH111.1 UE5.3 UH1.BA17
SLEEVE: LA7.2 RA26.2 UA1.37
SLEEVE_R: CA45.1 CA91.1 DA5.3 JACK1.3 LA7.1
SLP_S3: QE1.3 RE15.2 UE1.26
SLP_S5: QE4.3 RE16.2 UE1.21
SM_PG_CTRL: PR211.2 RH525.2 UC1.4
SML0CLK: RH501.2 UH1.AY44 UM4.11
SML0DATA: RH502.2 UH1.BB39 UM4.10
SML1CLK: QH5.6 RH460.2 UH1.AW42
SML1DATA: QH5.3 RH461.2 UH1.AW45
SNB_1.0VS_VGAP: PC802.1 PR803.2
SNB_VCCIO: PC591.1 PR5009.2
SNUB_CHG: PC715.1 PR713.2
SPEAKER_SEL: JSPK.5 UE10.2
SPI_MOCLK: CE57.1 RE11.2 UE1.2
SPI_MOCS#: RE12.2 UE1.31 UE2.1
SPI_MOSI: RE9.2 UE1.32
SPI_MOSO: RE10.2 UE1.1
SPK_L+_CONN: CA255.1 DA7.2 JSPK.4 LA51.2 RA61.1
SPK_L-_CONN: DA7.3 JSPK.3 RA57.2 RA59.1
SPK_R+_CONN: CA257.1 DA8.2 JSPK.2 LA53.2 RA65.1
SPK_R-_CONN: DA8.3 JSPK.1 RA60.2 RA64.1
STRAP0: RG78.1 RG90.2 UG9.BL3
STRAP1: RG79.1 RG91.2 UG9.BL4
STRAP2: RG80.1 RG92.2 UG9.BM4
STRAP3: DG8.2 RG81.1 RG93.2 UG9.BM5
STRAP3_PCH: DG8.1 RG558.2 UH1.L43
STRAP4: RG82.1 RG94.2 UG9.BK5
STRAP5: DG9.2 RG83.1 RG95.2 UG9.BJ5
STRAP5_PCH: DG9.1 RG559.2 UH1.L44
SUSACK#: UE5.97 UH1.BB19
SUSCLK: JSSD1.68 JSSD2.68 JWLAN.42 UH1.AN15
SUSP#: PR209.1 PR807.2 PR5007.1 Q8.3 R174.1 RT15.2 U16.4 U17.3 U20.4 UE5.116 UZ21.3
SUSP#_R: RT15.1 RT30.2 UT1.D2
SW_1.2V: PC204.2 PL201.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR202.1 PU201.16
SW_+1VALWP: PC305.2 PL300.1 PQ300.1 PQ300.2 PQ300.3 PQ301.5 PR305.1 PU300.8
SW_USB20_N1: LU3.1 UU1.11
SW_USB20_P1: LU3.4 UU1.10
SYNC_OUT: TC24.1(TP-1) UA4.38
SYS_PEX_RST_MON#: DG1.2 RG21.1 RG537.2 UG9.BE2
SYS_PWROK: CE46.1 UE5.74 UH1.AY1
SYS_RESET#: CH175.1 RH5.2 RH571.1 UH1.AW1
SYSON: CE42.1 PR208.2 Q9.3 U19.4 UE5.95
TB_STAT#_CHG: PQ705.2 PR718.1 PU700.16
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC1.B7 LT3.3
TBT_A_USB20_L_NT: DT10.2 DT10.8 JUSBC1.A7 LT2.2
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC1.B6 LT3.2
TBT_A_USB20_L_PT: DT10.1 DT10.9 JUSBC1.A6 LT2.3
TBT_A_USB20_N: UT1.D20 UT4.K5
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.1 UT4.L6
TBT_A_USB20_P: UT1.E20 UT4.L5
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.4 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH1.AN43 UT1.W2
TBT_EE_CLK: RT101.1 UT1.AB4 UT2.6
TBT_EE_CS_N: RT50.2 RT100.1 UT1.AC3 UT2.1
TBT_EE_DI: RT98.1 UT1.AB3 UT2.5
TBT_EE_DO: RT49.1 RT99.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_FORCE_PWR: RT13.2 UH1.P43
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HDMI_DDC_CLK: T9.1(TP-1) UT1.Y2
TBT_HDMI_DDC_DATA: T7.1(TP-1) UT1.Y1
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 UT1.U2 UT4.D2
TBT_I2C_SDA: RT26.2 UT1.U1 UT4.D1
TBT_PCIE_WAKE#: RT10.2 UE5.70
TBT_PCIE_WAKE_N: RT10.1 RT28.2 UT1.W1
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT23.1 RT80.2 RT102.2 UT1.F4
TBT_RESET_N_EC: RT23.2 UE5.15
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: RT1.2 UT1.L4
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: JTAG.4 RT7.2 UT1.T4
TBT_TDI: JTAG.2 RT9.2 UT1.Y4
TBT_TDO: JTAG.5 RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: JTAG.3 RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 T2.1(TP-1) UT1.V2
TBT_XTAL_25_IN: CT37.1 UT1.D22 YT1.1
TBT_XTAL_25_OUT: CT38.1 UT1.D23 YT1.3
TBTA_CC1: CT112.1 DT11.1 JUSBC1.A5 UT4.L9
TBTA_CC2: CT113.1 DT12.1 JUSBC1.B5 UT4.L10
TBTA_DEBUG1: RT71.1 UT4.L2
TBTA_DEBUG2: RT72.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 UT4.K3
TBTA_DIG_AUD_P: RT68.1 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_I2C_INT: RT32.2 UT1.J4 UT4.C1
TBTA_I2C_SCL1_R: RT57.2 RT60.2 UT4.B5
TBTA_I2C_SDA1_R: RT58.2 RT59.2 UT4.A5
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTA_SBU1: DT13.1 JUSBC1.A8 UT4.K8
TBTA_SBU2: DT14.1 JUSBC1.B8 UT4.L8
TBTB_I2C_INT: RT33.2 UT1.E2
THERMDA: UT1.AB23 UT1.AC23
TMDS_C_TX0N: CV1060.1 LV4.1 RV643.1 RX31.1
TMDS_C_TX0P: CV1059.1 LV4.4 RV646.1 RX32.1
TMDS_C_TX1N: CV1062.1 LV5.1 RV642.1 RX35.1
TMDS_C_TX1P: CV1061.1 LV5.4 RV639.1 RX36.1
TMDS_C_TX2N: CV1064.1 LV6.1 RV645.1 RX37.1
TMDS_C_TX2P: CV1063.1 LV6.4 RV638.1 RX38.1
TMDS_C_TXCN: CV1057.1 LV3.1 RV641.1 RX33.1
TMDS_C_TXCP: CV1058.1 LV3.4 RV640.1 RX34.1
