# Allegro board LAD581PR10-0906.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
KC3810_QFN24_4X4-S
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.438x2.438 smd: 25(1.25,1.975)
KC_FBMA-L10-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
KC_FBMA-L11-453215800LMA90T_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
L03ESDL5V0CG3-2_SOT-523-3
  oval 0.406x0.787 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_10X10X4_M
  custom 0.953x0.953 smd: 1(0,0) 4(9.2,0)
  rect 0.762x0.508 smd: 2(1.524,0) 3(7.676,0)
LCN_DAN05-67306-0102_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
LCN_DAN05-67406-0103_75P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
LL4148_LL34-2
  oval 0.889x1.803 smd: 1(0,0) 2(3.5,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MAX9892ERTLFT_UCSP_6P
  round 0.267 smd: A1(0,0) A2(0.5,0) A3(1,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5)
MDU1512RH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MESS138W-G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
MHPC_NS692417_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
MMDT3904-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG121SN1D_L0402_2P
  rect 0.457x0.711 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BD601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX121SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
N17E-G1_BGA_2152P
  round 0.381 smd: A2(0.7,0) A3(1.4,0) A4(2.1,0) A49(33.6,0) A50(34.3,0) A51(35,0) B1(0,-0.7) B2(0.7,-0.7) B3(1.4,-0.7) B50(34.3,-0.7) B51(35,-0.7) B52(35.7,-0.7) BJ1(0,-33.6) BJ52(35.7,-33.6) BK1(0,-34.3) BK2(0.7,-34.3) BK51(35,-34.3) BK52(35.7,-34.3) BL1(0,-35) BL2(0.7,-35) BL3(1.4,-35) BL50(34.3,-35) BL51(35,-35) BL52(35.7,-35) BM2(0.7,-35.7) BM3(1.4,-35.7) BM4(2.1,-35.7) BM49(33.6,-35.7) BM50(34.3,-35.7) BM51(35,-35.7) C1(0,-1.4) C2(0.7,-1.4) C51(35,-1.4) C52(35.7,-1.4) D1(0,-2.1) D52(35.7,-2.1)
  round 0.356 smd: A5(2.8,0) A6(3.5,0) A8(4.9,0) A9(5.6,0) A11(7,0) A12(7.7,0) A14(9.1,0) A15(9.8,0) A17(11.2,0) A18(11.9,0) A20(13.3,0) A21(14,0) A23(15.4,0) A24(16.1,0) A26(17.5,0) A27(18.2,0) A29(19.6,0) A30(20.3,0) A32(21.7,0) A33(22.4,0) A35(23.8,0) A36(24.5,0) A38(25.9,0) A39(26.6,0) A41(28,0) A42(28.7,0) A44(30.1,0) A45(30.8,0) A47(32.2,0) A48(32.9,0) AA1(0,-14) AA2(0.7,-14) AA3(1.4,-14) AA4(2.1,-14) AA5(2.8,-14) AA6(3.5,-14) AA7(4.2,-14) AA8(4.9,-14) AA9(5.6,-14) AA10(6.3,-14) AA11(7,-14) AA14(9.1,-14) AA15(9.8,-14) AA16(10.5,-14) AA17(11.2,-14) AA18(11.9,-14) AA19(12.6,-14) AA20(13.3,-14) AA21(14,-14) AA22(14.7,-14) AA23(15.4,-14) AA24(16.1,-14) AA25(16.8,-14) AA26(17.5,-14) AA27(18.2,-14) AA28(18.9,-14) AA29(19.6,-14) AA30(20.3,-14) AA31(21,-14) AA32(21.7,-14) AA33(22.4,-14) AA34(23.1,-14) AA35(23.8,-14) AA36(24.5,-14) AA37(25.2,-14) AA38(25.9,-14) AA39(26.6,-14) AA42(28.7,-14) AA43(29.4,-14) AA44(30.1,-14) AA45(30.8,-14) AA46(31.5,-14) AA47(32.2,-14) AA48(32.9,-14) AA49(33.6,-14) AA50(34.3,-14) AA51(35,-14) AA52(35.7,-14) AB2(0.7,-14.7) AB4(2.1,-14.7) AB6(3.5,-14.7) AB8(4.9,-14.7) AB10(6.3,-14.7) AB13(8.4,-14.7) AB14(9.1,-14.7) AB15(9.8,-14.7) AB16(10.5,-14.7) AB17(11.2,-14.7) AB18(11.9,-14.7) AB19(12.6,-14.7) AB20(13.3,-14.7) AB21(14,-14.7) AB22(14.7,-14.7) AB23(15.4,-14.7) AB24(16.1,-14.7) AB25(16.8,-14.7) AB26(17.5,-14.7) AB27(18.2,-14.7) AB28(18.9,-14.7) AB29(19.6,-14.7) AB30(20.3,-14.7) AB31(21,-14.7) AB32(21.7,-14.7) AB33(22.4,-14.7) AB34(23.1,-14.7) AB35(23.8,-14.7) AB36(24.5,-14.7) AB37(25.2,-14.7) AB38(25.9,-14.7) AB39(26.6,-14.7) AB40(27.3,-14.7) AB43(29.4,-14.7) AB45(30.8,-14.7) AB47(32.2,-14.7) AB49(33.6,-14.7) AB51(35,-14.7) AC1(0,-15.4) AC2(0.7,-15.4) AC3(1.4,-15.4) AC4(2.1,-15.4) AC5(2.8,-15.4) AC6(3.5,-15.4) AC7(4.2,-15.4) AC8(4.9,-15.4) AC9(5.6,-15.4) AC10(6.3,-15.4) AC11(7,-15.4) AC14(9.1,-15.4) AC15(9.8,-15.4) AC16(10.5,-15.4) AC17(11.2,-15.4) AC18(11.9,-15.4) AC19(12.6,-15.4) AC20(13.3,-15.4) AC21(14,-15.4) AC22(14.7,-15.4) AC23(15.4,-15.4) AC24(16.1,-15.4) AC25(16.8,-15.4) AC26(17.5,-15.4) AC27(18.2,-15.4) AC28(18.9,-15.4) AC29(19.6,-15.4) AC30(20.3,-15.4) AC31(21,-15.4) AC32(21.7,-15.4) AC33(22.4,-15.4) AC34(23.1,-15.4) AC35(23.8,-15.4) AC36(24.5,-15.4) AC37(25.2,-15.4) AC38(25.9,-15.4) AC39(26.6,-15.4) AC42(28.7,-15.4) AC43(29.4,-15.4) AC44(30.1,-15.4) AC45(30.8,-15.4) AC46(31.5,-15.4) AC47(32.2,-15.4) AC48(32.9,-15.4) AC49(33.6,-15.4) AC50(34.3,-15.4) AC51(35,-15.4) AC52(35.7,-15.4) AD1(0,-16.1) AD2(0.7,-16.1) AD3(1.4,-16.1) AD4(2.1,-16.1) AD5(2.8,-16.1) AD6(3.5,-16.1) AD7(4.2,-16.1) AD8(4.9,-16.1) AD9(5.6,-16.1) AD10(6.3,-16.1) AD11(7,-16.1) AD14(9.1,-16.1) AD15(9.8,-16.1) AD16(10.5,-16.1) AD17(11.2,-16.1) AD18(11.9,-16.1) AD19(12.6,-16.1) AD20(13.3,-16.1) AD21(14,-16.1) AD22(14.7,-16.1) AD23(15.4,-16.1) AD24(16.1,-16.1) AD25(16.8,-16.1) AD26(17.5,-16.1) AD27(18.2,-16.1) AD28(18.9,-16.1) AD29(19.6,-16.1) AD30(20.3,-16.1) AD31(21,-16.1) AD32(21.7,-16.1) AD33(22.4,-16.1) AD34(23.1,-16.1) AD35(23.8,-16.1) AD36(24.5,-16.1) AD37(25.2,-16.1) AD38(25.9,-16.1) AD39(26.6,-16.1) AD42(28.7,-16.1) AD43(29.4,-16.1) AD44(30.1,-16.1) AD45(30.8,-16.1) AD46(31.5,-16.1) AD47(32.2,-16.1) AD48(32.9,-16.1) AD49(33.6,-16.1) AD50(34.3,-16.1) AD51(35,-16.1) AD52(35.7,-16.1) AE2(0.7,-16.8) AE4(2.1,-16.8) AE6(3.5,-16.8) AE8(4.9,-16.8) AE10(6.3,-16.8) AE14(9.1,-16.8) AE15(9.8,-16.8) AE16(10.5,-16.8) AE17(11.2,-16.8) AE18(11.9,-16.8) AE19(12.6,-16.8) AE20(13.3,-16.8) AE21(14,-16.8) AE22(14.7,-16.8) AE23(15.4,-16.8) AE24(16.1,-16.8) AE25(16.8,-16.8) AE26(17.5,-16.8) AE27(18.2,-16.8) AE28(18.9,-16.8) AE29(19.6,-16.8) AE30(20.3,-16.8) AE31(21,-16.8) AE32(21.7,-16.8) AE33(22.4,-16.8) AE34(23.1,-16.8) AE35(23.8,-16.8) AE36(24.5,-16.8) AE37(25.2,-16.8) AE38(25.9,-16.8) AE39(26.6,-16.8) AE43(29.4,-16.8) AE45(30.8,-16.8) AE47(32.2,-16.8) AE49(33.6,-16.8) AE51(35,-16.8) AF1(0,-17.5) AF2(0.7,-17.5) AF3(1.4,-17.5) AF4(2.1,-17.5) AF5(2.8,-17.5) AF6(3.5,-17.5) AF7(4.2,-17.5) AF8(4.9,-17.5) AF9(5.6,-17.5) AF10(6.3,-17.5) AF11(7,-17.5) AF13(8.4,-17.5) AF14(9.1,-17.5) AF15(9.8,-17.5) AF16(10.5,-17.5) AF17(11.2,-17.5) AF18(11.9,-17.5) AF19(12.6,-17.5) AF20(13.3,-17.5) AF21(14,-17.5) AF22(14.7,-17.5) AF23(15.4,-17.5) AF24(16.1,-17.5) AF25(16.8,-17.5) AF26(17.5,-17.5) AF27(18.2,-17.5) AF28(18.9,-17.5) AF29(19.6,-17.5) AF30(20.3,-17.5) AF31(21,-17.5) AF32(21.7,-17.5) AF33(22.4,-17.5) AF34(23.1,-17.5) AF35(23.8,-17.5) AF36(24.5,-17.5) AF37(25.2,-17.5) AF38(25.9,-17.5) AF39(26.6,-17.5) AF40(27.3,-17.5) AF42(28.7,-17.5) AF43(29.4,-17.5) AF44(30.1,-17.5) AF45(30.8,-17.5) AF46(31.5,-17.5) AF47(32.2,-17.5) AF48(32.9,-17.5) AF49(33.6,-17.5) AF50(34.3,-17.5) AF51(35,-17.5) AF52(35.7,-17.5) AG1(0,-18.2) AG2(0.7,-18.2) AG3(1.4,-18.2) AG4(2.1,-18.2) AG5(2.8,-18.2) AG6(3.5,-18.2) AG7(4.2,-18.2) AG8(4.9,-18.2) AG9(5.6,-18.2) AG10(6.3,-18.2) AG11(7,-18.2) AG13(8.4,-18.2) AG14(9.1,-18.2) AG15(9.8,-18.2) AG16(10.5,-18.2) AG17(11.2,-18.2) AG18(11.9,-18.2) AG19(12.6,-18.2) AG20(13.3,-18.2) AG21(14,-18.2) AG22(14.7,-18.2) AG23(15.4,-18.2) AG24(16.1,-18.2) AG25(16.8,-18.2) AG26(17.5,-18.2) AG27(18.2,-18.2) AG28(18.9,-18.2) AG29(19.6,-18.2) AG30(20.3,-18.2) AG31(21,-18.2) AG32(21.7,-18.2) AG33(22.4,-18.2) AG34(23.1,-18.2) AG35(23.8,-18.2) AG36(24.5,-18.2) AG37(25.2,-18.2) AG38(25.9,-18.2) AG39(26.6,-18.2) AG40(27.3,-18.2) AG42(28.7,-18.2) AG43(29.4,-18.2) AG44(30.1,-18.2) AG45(30.8,-18.2) AG46(31.5,-18.2) AG47(32.2,-18.2) AG48(32.9,-18.2) AG49(33.6,-18.2) AG50(34.3,-18.2) AG51(35,-18.2) AG52(35.7,-18.2) AH2(0.7,-18.9) AH4(2.1,-18.9) AH6(3.5,-18.9) AH8(4.9,-18.9) AH10(6.3,-18.9) AH14(9.1,-18.9) AH15(9.8,-18.9) AH16(10.5,-18.9) AH17(11.2,-18.9) AH18(11.9,-18.9) AH19(12.6,-18.9) AH20(13.3,-18.9) AH21(14,-18.9) AH22(14.7,-18.9) AH23(15.4,-18.9) AH24(16.1,-18.9) AH25(16.8,-18.9) AH26(17.5,-18.9) AH27(18.2,-18.9) AH28(18.9,-18.9) AH29(19.6,-18.9) AH30(20.3,-18.9) AH31(21,-18.9) AH32(21.7,-18.9) AH33(22.4,-18.9) AH34(23.1,-18.9) AH35(23.8,-18.9) AH36(24.5,-18.9) AH37(25.2,-18.9) AH38(25.9,-18.9) AH39(26.6,-18.9) AH43(29.4,-18.9) AH45(30.8,-18.9) AH47(32.2,-18.9) AH49(33.6,-18.9) AH51(35,-18.9) AJ1(0,-19.6) AJ2(0.7,-19.6) AJ3(1.4,-19.6) AJ4(2.1,-19.6) AJ5(2.8,-19.6) AJ6(3.5,-19.6) AJ7(4.2,-19.6) AJ8(4.9,-19.6) AJ9(5.6,-19.6) AJ10(6.3,-19.6) AJ11(7,-19.6) AJ14(9.1,-19.6) AJ15(9.8,-19.6) AJ16(10.5,-19.6) AJ17(11.2,-19.6) AJ18(11.9,-19.6) AJ19(12.6,-19.6) AJ20(13.3,-19.6) AJ21(14,-19.6) AJ22(14.7,-19.6) AJ23(15.4,-19.6) AJ24(16.1,-19.6) AJ25(16.8,-19.6) AJ26(17.5,-19.6) AJ27(18.2,-19.6) AJ28(18.9,-19.6) AJ29(19.6,-19.6) AJ30(20.3,-19.6) AJ31(21,-19.6) AJ32(21.7,-19.6) AJ33(22.4,-19.6) AJ34(23.1,-19.6) AJ35(23.8,-19.6) AJ36(24.5,-19.6) AJ37(25.2,-19.6) AJ38(25.9,-19.6) AJ39(26.6,-19.6) AJ42(28.7,-19.6) AJ43(29.4,-19.6) AJ44(30.1,-19.6) AJ45(30.8,-19.6) AJ46(31.5,-19.6) AJ47(32.2,-19.6) AJ48(32.9,-19.6) AJ49(33.6,-19.6) AJ50(34.3,-19.6) AJ51(35,-19.6) AJ52(35.7,-19.6) AK1(0,-20.3) AK2(0.7,-20.3) AK3(1.4,-20.3) AK4(2.1,-20.3) AK5(2.8,-20.3) AK6(3.5,-20.3) AK7(4.2,-20.3) AK8(4.9,-20.3) AK9(5.6,-20.3) AK10(6.3,-20.3) AK11(7,-20.3) AK14(9.1,-20.3) AK15(9.8,-20.3) AK16(10.5,-20.3) AK17(11.2,-20.3) AK18(11.9,-20.3) AK19(12.6,-20.3) AK20(13.3,-20.3) AK21(14,-20.3) AK22(14.7,-20.3) AK23(15.4,-20.3) AK24(16.1,-20.3) AK25(16.8,-20.3) AK26(17.5,-20.3) AK27(18.2,-20.3) AK28(18.9,-20.3) AK29(19.6,-20.3) AK30(20.3,-20.3) AK31(21,-20.3) AK32(21.7,-20.3) AK33(22.4,-20.3) AK34(23.1,-20.3) AK35(23.8,-20.3) AK36(24.5,-20.3) AK37(25.2,-20.3) AK38(25.9,-20.3) AK39(26.6,-20.3) AK42(28.7,-20.3) AK43(29.4,-20.3) AK44(30.1,-20.3) AK45(30.8,-20.3) AK46(31.5,-20.3) AK47(32.2,-20.3) AK48(32.9,-20.3) AK49(33.6,-20.3) AK50(34.3,-20.3) AK51(35,-20.3) AK52(35.7,-20.3) AL2(0.7,-21) AL4(2.1,-21) AL6(3.5,-21) AL8(4.9,-21) AL10(6.3,-21) AL13(8.4,-21) AL14(9.1,-21) AL15(9.8,-21) AL16(10.5,-21) AL17(11.2,-21) AL18(11.9,-21) AL19(12.6,-21) AL20(13.3,-21) AL21(14,-21) AL22(14.7,-21) AL23(15.4,-21) AL24(16.1,-21) AL25(16.8,-21) AL26(17.5,-21) AL27(18.2,-21) AL28(18.9,-21) AL29(19.6,-21) AL30(20.3,-21) AL31(21,-21) AL32(21.7,-21) AL33(22.4,-21) AL34(23.1,-21) AL35(23.8,-21) AL36(24.5,-21) AL37(25.2,-21) AL38(25.9,-21) AL39(26.6,-21) AL40(27.3,-21) AL43(29.4,-21) AL45(30.8,-21) AL47(32.2,-21) AL49(33.6,-21) AL51(35,-21) AM1(0,-21.7) AM2(0.7,-21.7) AM3(1.4,-21.7) AM4(2.1,-21.7) AM5(2.8,-21.7) AM6(3.5,-21.7) AM7(4.2,-21.7) AM8(4.9,-21.7) AM9(5.6,-21.7) AM10(6.3,-21.7) AM11(7,-21.7) AM14(9.1,-21.7) AM15(9.8,-21.7) AM16(10.5,-21.7) AM17(11.2,-21.7) AM18(11.9,-21.7) AM19(12.6,-21.7) AM20(13.3,-21.7) AM21(14,-21.7) AM22(14.7,-21.7) AM23(15.4,-21.7) AM24(16.1,-21.7) AM25(16.8,-21.7) AM26(17.5,-21.7) AM27(18.2,-21.7) AM28(18.9,-21.7) AM29(19.6,-21.7) AM30(20.3,-21.7) AM31(21,-21.7) AM32(21.7,-21.7) AM33(22.4,-21.7) AM34(23.1,-21.7) AM35(23.8,-21.7) AM36(24.5,-21.7) AM37(25.2,-21.7) AM38(25.9,-21.7) AM39(26.6,-21.7) AM42(28.7,-21.7) AM43(29.4,-21.7) AM44(30.1,-21.7) AM45(30.8,-21.7) AM46(31.5,-21.7) AM47(32.2,-21.7) AM48(32.9,-21.7) AM49(33.6,-21.7) AM50(34.3,-21.7) AM51(35,-21.7) AM52(35.7,-21.7) AN1(0,-22.4) AN2(0.7,-22.4) AN3(1.4,-22.4) AN4(2.1,-22.4) AN5(2.8,-22.4) AN6(3.5,-22.4) AN7(4.2,-22.4) AN8(4.9,-22.4) AN9(5.6,-22.4) AN10(6.3,-22.4) AN11(7,-22.4) AN14(9.1,-22.4) AN15(9.8,-22.4) AN16(10.5,-22.4) AN17(11.2,-22.4) AN18(11.9,-22.4) AN19(12.6,-22.4) AN20(13.3,-22.4) AN21(14,-22.4) AN22(14.7,-22.4) AN23(15.4,-22.4) AN24(16.1,-22.4) AN25(16.8,-22.4) AN26(17.5,-22.4) AN27(18.2,-22.4) AN28(18.9,-22.4) AN29(19.6,-22.4) AN30(20.3,-22.4) AN31(21,-22.4) AN32(21.7,-22.4) AN33(22.4,-22.4) AN34(23.1,-22.4) AN35(23.8,-22.4) AN36(24.5,-22.4) AN37(25.2,-22.4) AN38(25.9,-22.4) AN39(26.6,-22.4) AN42(28.7,-22.4) AN43(29.4,-22.4) AN44(30.1,-22.4) AN45(30.8,-22.4) AN46(31.5,-22.4) AN47(32.2,-22.4) AN48(32.9,-22.4) AN49(33.6,-22.4) AN50(34.3,-22.4) AN51(35,-22.4) AN52(35.7,-22.4) AP2(0.7,-23.1) AP4(2.1,-23.1) AP6(3.5,-23.1) AP8(4.9,-23.1) AP10(6.3,-23.1) AP14(9.1,-23.1) AP15(9.8,-23.1) AP16(10.5,-23.1) AP17(11.2,-23.1) AP18(11.9,-23.1) AP19(12.6,-23.1) AP20(13.3,-23.1) AP21(14,-23.1) AP22(14.7,-23.1) AP23(15.4,-23.1) AP24(16.1,-23.1) AP25(16.8,-23.1) AP26(17.5,-23.1) AP27(18.2,-23.1) AP28(18.9,-23.1) AP29(19.6,-23.1) AP30(20.3,-23.1) AP31(21,-23.1) AP32(21.7,-23.1) AP33(22.4,-23.1) AP34(23.1,-23.1) AP35(23.8,-23.1) AP36(24.5,-23.1) AP37(25.2,-23.1) AP38(25.9,-23.1) AP39(26.6,-23.1) AP43(29.4,-23.1) AP45(30.8,-23.1) AP47(32.2,-23.1) AP49(33.6,-23.1) AP51(35,-23.1) AR1(0,-23.8) AR2(0.7,-23.8) AR3(1.4,-23.8) AR4(2.1,-23.8) AR5(2.8,-23.8) AR6(3.5,-23.8) AR7(4.2,-23.8) AR8(4.9,-23.8) AR9(5.6,-23.8) AR10(6.3,-23.8) AR11(7,-23.8) AR13(8.4,-23.8) AR14(9.1,-23.8) AR15(9.8,-23.8) AR16(10.5,-23.8) AR17(11.2,-23.8) AR18(11.9,-23.8) AR19(12.6,-23.8) AR20(13.3,-23.8) AR21(14,-23.8) AR22(14.7,-23.8) AR23(15.4,-23.8) AR24(16.1,-23.8) AR25(16.8,-23.8) AR26(17.5,-23.8) AR27(18.2,-23.8) AR28(18.9,-23.8) AR29(19.6,-23.8) AR30(20.3,-23.8) AR31(21,-23.8) AR32(21.7,-23.8) AR33(22.4,-23.8) AR34(23.1,-23.8) AR35(23.8,-23.8) AR36(24.5,-23.8) AR37(25.2,-23.8) AR38(25.9,-23.8) AR39(26.6,-23.8) AR40(27.3,-23.8) AR42(28.7,-23.8) AR43(29.4,-23.8) AR44(30.1,-23.8) AR45(30.8,-23.8) AR46(31.5,-23.8) AR47(32.2,-23.8) AR48(32.9,-23.8) AR49(33.6,-23.8) AR50(34.3,-23.8) AR51(35,-23.8) AR52(35.7,-23.8) AT1(0,-24.5) AT2(0.7,-24.5) AT3(1.4,-24.5) AT4(2.1,-24.5) AT5(2.8,-24.5) AT6(3.5,-24.5) AT7(4.2,-24.5) AT8(4.9,-24.5) AT9(5.6,-24.5) AT10(6.3,-24.5) AT11(7,-24.5) AT14(9.1,-24.5) AT15(9.8,-24.5) AT16(10.5,-24.5) AT17(11.2,-24.5) AT18(11.9,-24.5) AT19(12.6,-24.5) AT20(13.3,-24.5) AT21(14,-24.5) AT22(14.7,-24.5) AT23(15.4,-24.5) AT24(16.1,-24.5) AT25(16.8,-24.5) AT26(17.5,-24.5) AT27(18.2,-24.5) AT28(18.9,-24.5) AT29(19.6,-24.5) AT30(20.3,-24.5) AT31(21,-24.5) AT32(21.7,-24.5) AT33(22.4,-24.5) AT34(23.1,-24.5) AT35(23.8,-24.5) AT36(24.5,-24.5) AT37(25.2,-24.5) AT38(25.9,-24.5) AT39(26.6,-24.5) AT42(28.7,-24.5) AT43(29.4,-24.5) AT44(30.1,-24.5) AT45(30.8,-24.5) AT46(31.5,-24.5) AT47(32.2,-24.5) AT48(32.9,-24.5) AT49(33.6,-24.5) AT50(34.3,-24.5) AT51(35,-24.5) AT52(35.7,-24.5) AU2(0.7,-25.2) AU4(2.1,-25.2) AU6(3.5,-25.2) AU8(4.9,-25.2) AU10(6.3,-25.2) AU14(9.1,-25.2) AU15(9.8,-25.2) AU16(10.5,-25.2) AU17(11.2,-25.2) AU18(11.9,-25.2) AU19(12.6,-25.2) AU20(13.3,-25.2) AU21(14,-25.2) AU22(14.7,-25.2) AU23(15.4,-25.2) AU24(16.1,-25.2) AU25(16.8,-25.2) AU26(17.5,-25.2) AU27(18.2,-25.2) AU28(18.9,-25.2) AU29(19.6,-25.2) AU30(20.3,-25.2) AU31(21,-25.2) AU32(21.7,-25.2) AU33(22.4,-25.2) AU34(23.1,-25.2) AU35(23.8,-25.2) AU36(24.5,-25.2) AU37(25.2,-25.2) AU38(25.9,-25.2) AU39(26.6,-25.2) AU43(29.4,-25.2) AU45(30.8,-25.2) AU47(32.2,-25.2) AU49(33.6,-25.2) AU51(35,-25.2) AV1(0,-25.9) AV2(0.7,-25.9) AV3(1.4,-25.9) AV4(2.1,-25.9) AV5(2.8,-25.9) AV6(3.5,-25.9) AV7(4.2,-25.9) AV8(4.9,-25.9) AV9(5.6,-25.9) AV10(6.3,-25.9) AV11(7,-25.9) AV14(9.1,-25.9) AV15(9.8,-25.9) AV16(10.5,-25.9) AV17(11.2,-25.9) AV18(11.9,-25.9) AV19(12.6,-25.9) AV20(13.3,-25.9) AV21(14,-25.9) AV22(14.7,-25.9) AV23(15.4,-25.9) AV24(16.1,-25.9) AV25(16.8,-25.9) AV26(17.5,-25.9) AV27(18.2,-25.9) AV28(18.9,-25.9) AV29(19.6,-25.9) AV30(20.3,-25.9) AV31(21,-25.9) AV32(21.7,-25.9) AV33(22.4,-25.9) AV34(23.1,-25.9) AV35(23.8,-25.9) AV36(24.5,-25.9) AV37(25.2,-25.9) AV38(25.9,-25.9) AV39(26.6,-25.9) AV42(28.7,-25.9) AV43(29.4,-25.9) AV44(30.1,-25.9) AV45(30.8,-25.9) AV46(31.5,-25.9) AV47(32.2,-25.9) AV48(32.9,-25.9) AV49(33.6,-25.9) AV50(34.3,-25.9) AV51(35,-25.9) AV52(35.7,-25.9) AW1(0,-26.6) AW2(0.7,-26.6) AW3(1.4,-26.6) AW4(2.1,-26.6) AW5(2.8,-26.6) AW6(3.5,-26.6) AW7(4.2,-26.6) AW8(4.9,-26.6) AW9(5.6,-26.6) AW10(6.3,-26.6) AW11(7,-26.6) AW13(8.4,-26.6) AW14(9.1,-26.6) AW15(9.8,-26.6) AW16(10.5,-26.6) AW17(11.2,-26.6) AW18(11.9,-26.6) AW19(12.6,-26.6) AW20(13.3,-26.6) AW21(14,-26.6) AW22(14.7,-26.6) AW23(15.4,-26.6) AW24(16.1,-26.6) AW25(16.8,-26.6) AW26(17.5,-26.6) AW27(18.2,-26.6) AW28(18.9,-26.6) AW29(19.6,-26.6) AW30(20.3,-26.6) AW31(21,-26.6) AW32(21.7,-26.6) AW33(22.4,-26.6) AW34(23.1,-26.6) AW35(23.8,-26.6) AW36(24.5,-26.6) AW37(25.2,-26.6) AW38(25.9,-26.6) AW39(26.6,-26.6) AW40(27.3,-26.6) AW42(28.7,-26.6) AW43(29.4,-26.6) AW44(30.1,-26.6) AW45(30.8,-26.6) AW46(31.5,-26.6) AW47(32.2,-26.6) AW48(32.9,-26.6) AW49(33.6,-26.6) AW50(34.3,-26.6) AW51(35,-26.6) AW52(35.7,-26.6) AY2(0.7,-27.3) AY4(2.1,-27.3) AY6(3.5,-27.3) AY8(4.9,-27.3) AY10(6.3,-27.3) AY14(9.1,-27.3) AY18(11.9,-27.3) AY22(14.7,-27.3) AY26(17.5,-27.3) AY27(18.2,-27.3) AY31(21,-27.3) AY35(23.8,-27.3) AY39(26.6,-27.3) AY43(29.4,-27.3) AY45(30.8,-27.3) AY47(32.2,-27.3) AY49(33.6,-27.3) AY51(35,-27.3) B4(2.1,-0.7) B5(2.8,-0.7) B6(3.5,-0.7) B7(4.2,-0.7) B8(4.9,-0.7) B9(5.6,-0.7) B10(6.3,-0.7) B11(7,-0.7) B12(7.7,-0.7) B13(8.4,-0.7) B14(9.1,-0.7) B15(9.8,-0.7) B16(10.5,-0.7) B17(11.2,-0.7) B18(11.9,-0.7) B19(12.6,-0.7) B20(13.3,-0.7) B21(14,-0.7) B22(14.7,-0.7) B23(15.4,-0.7) B24(16.1,-0.7) B25(16.8,-0.7) B26(17.5,-0.7) B27(18.2,-0.7) B28(18.9,-0.7) B29(19.6,-0.7) B30(20.3,-0.7) B31(21,-0.7) B32(21.7,-0.7) B33(22.4,-0.7) B34(23.1,-0.7) B35(23.8,-0.7) B36(24.5,-0.7) B37(25.2,-0.7) B38(25.9,-0.7) B39(26.6,-0.7) B40(27.3,-0.7) B41(28,-0.7) B42(28.7,-0.7) B43(29.4,-0.7) B44(30.1,-0.7) B45(30.8,-0.7) B46(31.5,-0.7) B47(32.2,-0.7) B48(32.9,-0.7) B49(33.6,-0.7) BA1(0,-28) BA2(0.7,-28) BA3(1.4,-28) BA4(2.1,-28) BA5(2.8,-28) BA6(3.5,-28) BA7(4.2,-28) BA8(4.9,-28) BA9(5.6,-28) BA10(6.3,-28) BA43(29.4,-28) BA44(30.1,-28) BA45(30.8,-28) BA46(31.5,-28) BA47(32.2,-28) BA48(32.9,-28) BA49(33.6,-28) BA50(34.3,-28) BA51(35,-28) BA52(35.7,-28) BB1(0,-28.7) BB2(0.7,-28.7) BB3(1.4,-28.7) BB4(2.1,-28.7) BB5(2.8,-28.7) BB6(3.5,-28.7) BB7(4.2,-28.7) BB8(4.9,-28.7) BB14(9.1,-28.7) BB15(9.8,-28.7) BB17(11.2,-28.7) BB18(11.9,-28.7) BB20(13.3,-28.7) BB21(14,-28.7) BB23(15.4,-28.7) BB24(16.1,-28.7) BB26(17.5,-28.7) BB27(18.2,-28.7) BB29(19.6,-28.7) BB30(20.3,-28.7) BB32(21.7,-28.7) BB33(22.4,-28.7) BB35(23.8,-28.7) BB36(24.5,-28.7) BB38(25.9,-28.7) BB39(26.6,-28.7) BB45(30.8,-28.7) BB46(31.5,-28.7) BB47(32.2,-28.7) BB48(32.9,-28.7) BB49(33.6,-28.7) BB50(34.3,-28.7) BB51(35,-28.7) BB52(35.7,-28.7) BC2(0.7,-29.4) BC4(2.1,-29.4) BC6(3.5,-29.4) BC8(4.9,-29.4) BC12(7.7,-29.4) BC13(8.4,-29.4) BC14(9.1,-29.4) BC15(9.8,-29.4) BC16(10.5,-29.4) BC17(11.2,-29.4) BC18(11.9,-29.4) BC19(12.6,-29.4) BC20(13.3,-29.4) BC21(14,-29.4) BC22(14.7,-29.4) BC23(15.4,-29.4) BC24(16.1,-29.4) BC25(16.8,-29.4) BC26(17.5,-29.4) BC27(18.2,-29.4) BC28(18.9,-29.4) BC29(19.6,-29.4) BC30(20.3,-29.4) BC31(21,-29.4) BC32(21.7,-29.4) BC33(22.4,-29.4) BC34(23.1,-29.4) BC35(23.8,-29.4) BC36(24.5,-29.4) BC37(25.2,-29.4) BC38(25.9,-29.4) BC39(26.6,-29.4) BC40(27.3,-29.4) BC41(28,-29.4) BC45(30.8,-29.4) BC47(32.2,-29.4) BC49(33.6,-29.4) BC51(35,-29.4) BD1(0,-30.1) BD2(0.7,-30.1) BD3(1.4,-30.1) BD4(2.1,-30.1) BD5(2.8,-30.1) BD6(3.5,-30.1) BD7(4.2,-30.1) BD12(7.7,-30.1) BD14(9.1,-30.1) BD15(9.8,-30.1) BD17(11.2,-30.1) BD18(11.9,-30.1) BD20(13.3,-30.1) BD21(14,-30.1) BD23(15.4,-30.1) BD24(16.1,-30.1) BD26(17.5,-30.1) BD27(18.2,-30.1) BD29(19.6,-30.1) BD30(20.3,-30.1) BD32(21.7,-30.1) BD33(22.4,-30.1) BD35(23.8,-30.1) BD36(24.5,-30.1) BD38(25.9,-30.1) BD39(26.6,-30.1) BD41(28,-30.1) BD46(31.5,-30.1) BD47(32.2,-30.1) BD48(32.9,-30.1) BD49(33.6,-30.1) BD50(34.3,-30.1) BD51(35,-30.1) BD52(35.7,-30.1) BE1(0,-30.8) BE2(0.7,-30.8) BE3(1.4,-30.8) BE4(2.1,-30.8) BE5(2.8,-30.8) BE6(3.5,-30.8) BE7(4.2,-30.8) BE10(6.3,-30.8) BE11(7,-30.8) BE12(7.7,-30.8) BE13(8.4,-30.8) BE14(9.1,-30.8) BE15(9.8,-30.8) BE16(10.5,-30.8) BE17(11.2,-30.8) BE18(11.9,-30.8) BE19(12.6,-30.8) BE20(13.3,-30.8) BE21(14,-30.8) BE22(14.7,-30.8) BE23(15.4,-30.8) BE24(16.1,-30.8) BE25(16.8,-30.8) BE26(17.5,-30.8) BE27(18.2,-30.8) BE28(18.9,-30.8) BE29(19.6,-30.8) BE30(20.3,-30.8) BE31(21,-30.8) BE32(21.7,-30.8) BE33(22.4,-30.8) BE34(23.1,-30.8) BE35(23.8,-30.8) BE36(24.5,-30.8) BE37(25.2,-30.8) BE38(25.9,-30.8) BE39(26.6,-30.8) BE40(27.3,-30.8) BE41(28,-30.8) BE42(28.7,-30.8) BE43(29.4,-30.8) BE46(31.5,-30.8) BE47(32.2,-30.8) BE48(32.9,-30.8) BE49(33.6,-30.8) BE50(34.3,-30.8) BE51(35,-30.8) BE52(35.7,-30.8) BF2(0.7,-31.5) BF4(2.1,-31.5) BF6(3.5,-31.5) BF8(4.9,-31.5) BF9(5.6,-31.5) BF11(7,-31.5) BF12(7.7,-31.5) BF14(9.1,-31.5) BF15(9.8,-31.5) BF17(11.2,-31.5) BF18(11.9,-31.5) BF20(13.3,-31.5) BF21(14,-31.5) BF23(15.4,-31.5) BF24(16.1,-31.5) BF26(17.5,-31.5) BF27(18.2,-31.5) BF29(19.6,-31.5) BF30(20.3,-31.5) BF32(21.7,-31.5) BF33(22.4,-31.5) BF35(23.8,-31.5) BF36(24.5,-31.5) BF38(25.9,-31.5) BF39(26.6,-31.5) BF41(28,-31.5) BF42(28.7,-31.5) BF44(30.1,-31.5) BF45(30.8,-31.5) BF47(32.2,-31.5) BF49(33.6,-31.5) BF51(35,-31.5) BG1(0,-32.2) BG2(0.7,-32.2) BG3(1.4,-32.2) BG4(2.1,-32.2) BG5(2.8,-32.2) BG6(3.5,-32.2) BG7(4.2,-32.2) BG8(4.9,-32.2) BG9(5.6,-32.2) BG10(6.3,-32.2) BG11(7,-32.2) BG12(7.7,-32.2) BG13(8.4,-32.2) BG14(9.1,-32.2) BG15(9.8,-32.2) BG16(10.5,-32.2) BG17(11.2,-32.2) BG18(11.9,-32.2) BG19(12.6,-32.2) BG20(13.3,-32.2) BG21(14,-32.2) BG22(14.7,-32.2) BG23(15.4,-32.2) BG24(16.1,-32.2) BG25(16.8,-32.2) BG26(17.5,-32.2) BG27(18.2,-32.2) BG28(18.9,-32.2) BG29(19.6,-32.2) BG30(20.3,-32.2) BG31(21,-32.2) BG32(21.7,-32.2) BG33(22.4,-32.2) BG34(23.1,-32.2) BG35(23.8,-32.2) BG36(24.5,-32.2) BG37(25.2,-32.2) BG38(25.9,-32.2) BG39(26.6,-32.2) BG40(27.3,-32.2) BG41(28,-32.2) BG42(28.7,-32.2) BG43(29.4,-32.2) BG44(30.1,-32.2) BG45(30.8,-32.2) BG46(31.5,-32.2) BG47(32.2,-32.2) BG48(32.9,-32.2) BG49(33.6,-32.2) BG50(34.3,-32.2) BG51(35,-32.2) BG52(35.7,-32.2) BH1(0,-32.9) BH2(0.7,-32.9) BH3(1.4,-32.9) BH4(2.1,-32.9) BH5(2.8,-32.9) BH6(3.5,-32.9) BH8(4.9,-32.9) BH9(5.6,-32.9) BH11(7,-32.9) BH12(7.7,-32.9) BH14(9.1,-32.9) BH15(9.8,-32.9) BH17(11.2,-32.9) BH18(11.9,-32.9) BH20(13.3,-32.9) BH21(14,-32.9) BH23(15.4,-32.9) BH24(16.1,-32.9) BH26(17.5,-32.9) BH27(18.2,-32.9) BH29(19.6,-32.9) BH30(20.3,-32.9) BH32(21.7,-32.9) BH33(22.4,-32.9) BH35(23.8,-32.9) BH36(24.5,-32.9) BH38(25.9,-32.9) BH39(26.6,-32.9) BH41(28,-32.9) BH42(28.7,-32.9) BH44(30.1,-32.9) BH45(30.8,-32.9) BH47(32.2,-32.9) BH48(32.9,-32.9) BH49(33.6,-32.9) BH50(34.3,-32.9) BH51(35,-32.9) BH52(35.7,-32.9) BJ2(0.7,-33.6) BJ3(1.4,-33.6) BJ4(2.1,-33.6) BJ5(2.8,-33.6) BJ6(3.5,-33.6) BJ7(4.2,-33.6) BJ8(4.9,-33.6) BJ9(5.6,-33.6) BJ10(6.3,-33.6) BJ11(7,-33.6) BJ12(7.7,-33.6) BJ13(8.4,-33.6) BJ14(9.1,-33.6) BJ15(9.8,-33.6) BJ16(10.5,-33.6) BJ17(11.2,-33.6) BJ18(11.9,-33.6) BJ19(12.6,-33.6) BJ20(13.3,-33.6) BJ21(14,-33.6) BJ22(14.7,-33.6) BJ23(15.4,-33.6) BJ24(16.1,-33.6) BJ25(16.8,-33.6) BJ26(17.5,-33.6) BJ27(18.2,-33.6) BJ28(18.9,-33.6) BJ29(19.6,-33.6) BJ30(20.3,-33.6) BJ31(21,-33.6) BJ32(21.7,-33.6) BJ33(22.4,-33.6) BJ34(23.1,-33.6) BJ35(23.8,-33.6) BJ36(24.5,-33.6) BJ37(25.2,-33.6) BJ38(25.9,-33.6) BJ39(26.6,-33.6) BJ40(27.3,-33.6) BJ41(28,-33.6) BJ42(28.7,-33.6) BJ43(29.4,-33.6) BJ44(30.1,-33.6) BJ45(30.8,-33.6) BJ46(31.5,-33.6) BJ47(32.2,-33.6) BJ48(32.9,-33.6) BJ49(33.6,-33.6) BJ50(34.3,-33.6) BJ51(35,-33.6) BK3(1.4,-34.3) BK4(2.1,-34.3) BK5(2.8,-34.3) BK6(3.5,-34.3) BK8(4.9,-34.3) BK9(5.6,-34.3) BK11(7,-34.3) BK12(7.7,-34.3) BK14(9.1,-34.3) BK15(9.8,-34.3) BK17(11.2,-34.3) BK18(11.9,-34.3) BK20(13.3,-34.3) BK21(14,-34.3) BK23(15.4,-34.3) BK24(16.1,-34.3) BK26(17.5,-34.3) BK27(18.2,-34.3) BK29(19.6,-34.3) BK30(20.3,-34.3) BK32(21.7,-34.3) BK33(22.4,-34.3) BK35(23.8,-34.3) BK36(24.5,-34.3) BK38(25.9,-34.3) BK39(26.6,-34.3) BK41(28,-34.3) BK42(28.7,-34.3) BK44(30.1,-34.3) BK45(30.8,-34.3) BK47(32.2,-34.3) BK48(32.9,-34.3) BK49(33.6,-34.3) BK50(34.3,-34.3) BL4(2.1,-35) BL5(2.8,-35) BL6(3.5,-35) BL7(4.2,-35) BL8(4.9,-35) BL9(5.6,-35) BL10(6.3,-35) BL11(7,-35) BL12(7.7,-35) BL13(8.4,-35) BL14(9.1,-35) BL15(9.8,-35) BL16(10.5,-35) BL17(11.2,-35) BL18(11.9,-35) BL19(12.6,-35) BL20(13.3,-35) BL21(14,-35) BL22(14.7,-35) BL23(15.4,-35) BL24(16.1,-35) BL25(16.8,-35) BL26(17.5,-35) BL27(18.2,-35) BL28(18.9,-35) BL29(19.6,-35) BL30(20.3,-35) BL31(21,-35) BL32(21.7,-35) BL33(22.4,-35) BL34(23.1,-35) BL35(23.8,-35) BL36(24.5,-35) BL37(25.2,-35) BL38(25.9,-35) BL39(26.6,-35) BL40(27.3,-35) BL41(28,-35) BL42(28.7,-35) BL43(29.4,-35) BL44(30.1,-35) BL45(30.8,-35) BL46(31.5,-35) BL47(32.2,-35) BL48(32.9,-35) BL49(33.6,-35) BM5(2.8,-35.7) BM6(3.5,-35.7) BM8(4.9,-35.7) BM9(5.6,-35.7) BM11(7,-35.7) BM12(7.7,-35.7) BM14(9.1,-35.7) BM15(9.8,-35.7) BM17(11.2,-35.7) BM18(11.9,-35.7) BM20(13.3,-35.7) BM21(14,-35.7) BM23(15.4,-35.7) BM24(16.1,-35.7) BM26(17.5,-35.7) BM27(18.2,-35.7) BM29(19.6,-35.7) BM30(20.3,-35.7) BM32(21.7,-35.7) BM33(22.4,-35.7) BM35(23.8,-35.7) BM36(24.5,-35.7) BM38(25.9,-35.7) BM39(26.6,-35.7) BM41(28,-35.7) BM42(28.7,-35.7) BM44(30.1,-35.7) BM45(30.8,-35.7) BM47(32.2,-35.7) BM48(32.9,-35.7) C3(1.4,-1.4) C4(2.1,-1.4) C5(2.8,-1.4) C6(3.5,-1.4) C8(4.9,-1.4) C9(5.6,-1.4) C11(7,-1.4) C12(7.7,-1.4) C14(9.1,-1.4) C15(9.8,-1.4) C17(11.2,-1.4) C18(11.9,-1.4) C20(13.3,-1.4) C21(14,-1.4) C23(15.4,-1.4) C24(16.1,-1.4) C26(17.5,-1.4) C27(18.2,-1.4) C29(19.6,-1.4) C30(20.3,-1.4) C32(21.7,-1.4) C33(22.4,-1.4) C35(23.8,-1.4) C36(24.5,-1.4) C38(25.9,-1.4) C39(26.6,-1.4) C41(28,-1.4) C42(28.7,-1.4) C44(30.1,-1.4) C45(30.8,-1.4) C47(32.2,-1.4) C48(32.9,-1.4) C49(33.6,-1.4) C50(34.3,-1.4) D2(0.7,-2.1) D3(1.4,-2.1) D4(2.1,-2.1) D5(2.8,-2.1) D6(3.5,-2.1) D7(4.2,-2.1) D8(4.9,-2.1) D9(5.6,-2.1) D10(6.3,-2.1) D11(7,-2.1) D12(7.7,-2.1) D13(8.4,-2.1) D14(9.1,-2.1) D15(9.8,-2.1) D16(10.5,-2.1) D17(11.2,-2.1) D18(11.9,-2.1) D19(12.6,-2.1) D20(13.3,-2.1) D21(14,-2.1) D22(14.7,-2.1) D23(15.4,-2.1) D24(16.1,-2.1) D25(16.8,-2.1) D26(17.5,-2.1) D27(18.2,-2.1) D28(18.9,-2.1) D29(19.6,-2.1) D30(20.3,-2.1) D31(21,-2.1) D32(21.7,-2.1) D33(22.4,-2.1) D34(23.1,-2.1) D35(23.8,-2.1) D36(24.5,-2.1) D37(25.2,-2.1) D38(25.9,-2.1) D39(26.6,-2.1) D40(27.3,-2.1) D41(28,-2.1) D42(28.7,-2.1) D43(29.4,-2.1) D44(30.1,-2.1) D45(30.8,-2.1) D46(31.5,-2.1) D47(32.2,-2.1) D48(32.9,-2.1) D49(33.6,-2.1) D50(34.3,-2.1) D51(35,-2.1) E1(0,-2.8) E2(0.7,-2.8) E3(1.4,-2.8) E4(2.1,-2.8) E5(2.8,-2.8) E6(3.5,-2.8) E8(4.9,-2.8) E9(5.6,-2.8) E11(7,-2.8) E12(7.7,-2.8) E14(9.1,-2.8) E15(9.8,-2.8) E17(11.2,-2.8) E18(11.9,-2.8) E20(13.3,-2.8) E21(14,-2.8) E23(15.4,-2.8) E24(16.1,-2.8) E26(17.5,-2.8) E27(18.2,-2.8) E29(19.6,-2.8) E30(20.3,-2.8) E32(21.7,-2.8) E33(22.4,-2.8) E35(23.8,-2.8) E36(24.5,-2.8) E38(25.9,-2.8) E39(26.6,-2.8) E41(28,-2.8) E42(28.7,-2.8) E44(30.1,-2.8) E45(30.8,-2.8) E47(32.2,-2.8) E48(32.9,-2.8) E49(33.6,-2.8) E50(34.3,-2.8) E51(35,-2.8) E52(35.7,-2.8) F1(0,-3.5) F2(0.7,-3.5) F3(1.4,-3.5) F4(2.1,-3.5) F5(2.8,-3.5) F6(3.5,-3.5) F7(4.2,-3.5) F8(4.9,-3.5) F9(5.6,-3.5) F10(6.3,-3.5) F11(7,-3.5) F12(7.7,-3.5) F13(8.4,-3.5) F14(9.1,-3.5) F15(9.8,-3.5) F16(10.5,-3.5) F17(11.2,-3.5) F18(11.9,-3.5) F19(12.6,-3.5) F20(13.3,-3.5) F21(14,-3.5) F22(14.7,-3.5) F23(15.4,-3.5) F24(16.1,-3.5) F25(16.8,-3.5) F26(17.5,-3.5) F27(18.2,-3.5) F28(18.9,-3.5) F29(19.6,-3.5) F30(20.3,-3.5) F31(21,-3.5) F32(21.7,-3.5) F33(22.4,-3.5) F34(23.1,-3.5) F35(23.8,-3.5) F36(24.5,-3.5) F37(25.2,-3.5) F38(25.9,-3.5) F39(26.6,-3.5) F40(27.3,-3.5) F41(28,-3.5) F42(28.7,-3.5) F43(29.4,-3.5) F44(30.1,-3.5) F45(30.8,-3.5) F46(31.5,-3.5) F47(32.2,-3.5) F48(32.9,-3.5) F49(33.6,-3.5) F50(34.3,-3.5) F51(35,-3.5) F52(35.7,-3.5) G2(0.7,-4.2) G4(2.1,-4.2) G6(3.5,-4.2) G8(4.9,-4.2) G9(5.6,-4.2) G11(7,-4.2) G12(7.7,-4.2) G14(9.1,-4.2) G15(9.8,-4.2) G17(11.2,-4.2) G18(11.9,-4.2) G20(13.3,-4.2) G21(14,-4.2) G23(15.4,-4.2) G24(16.1,-4.2) G26(17.5,-4.2) G27(18.2,-4.2) G29(19.6,-4.2) G30(20.3,-4.2) G32(21.7,-4.2) G33(22.4,-4.2) G35(23.8,-4.2) G36(24.5,-4.2) G38(25.9,-4.2) G39(26.6,-4.2) G41(28,-4.2) G42(28.7,-4.2) G44(30.1,-4.2) G45(30.8,-4.2) G47(32.2,-4.2) G49(33.6,-4.2) G51(35,-4.2) H1(0,-4.9) H2(0.7,-4.9) H3(1.4,-4.9) H4(2.1,-4.9) H5(2.8,-4.9) H6(3.5,-4.9) H7(4.2,-4.9) H10(6.3,-4.9) H11(7,-4.9) H12(7.7,-4.9) H13(8.4,-4.9) H14(9.1,-4.9) H15(9.8,-4.9) H16(10.5,-4.9) H17(11.2,-4.9) H18(11.9,-4.9) H19(12.6,-4.9) H20(13.3,-4.9) H21(14,-4.9) H22(14.7,-4.9) H23(15.4,-4.9) H24(16.1,-4.9) H25(16.8,-4.9) H26(17.5,-4.9) H27(18.2,-4.9) H28(18.9,-4.9) H29(19.6,-4.9) H30(20.3,-4.9) H31(21,-4.9) H32(21.7,-4.9) H33(22.4,-4.9) H34(23.1,-4.9) H35(23.8,-4.9) H36(24.5,-4.9) H37(25.2,-4.9) H38(25.9,-4.9) H39(26.6,-4.9) H40(27.3,-4.9) H41(28,-4.9) H42(28.7,-4.9) H43(29.4,-4.9) H46(31.5,-4.9) H47(32.2,-4.9) H48(32.9,-4.9) H49(33.6,-4.9) H50(34.3,-4.9) H51(35,-4.9) H52(35.7,-4.9) J1(0,-5.6) J2(0.7,-5.6) J3(1.4,-5.6) J4(2.1,-5.6) J5(2.8,-5.6) J6(3.5,-5.6) J7(4.2,-5.6) J12(7.7,-5.6) J14(9.1,-5.6) J15(9.8,-5.6) J17(11.2,-5.6) J18(11.9,-5.6) J20(13.3,-5.6) J21(14,-5.6) J23(15.4,-5.6) J24(16.1,-5.6) J26(17.5,-5.6) J27(18.2,-5.6) J29(19.6,-5.6) J30(20.3,-5.6) J32(21.7,-5.6) J33(22.4,-5.6) J35(23.8,-5.6) J36(24.5,-5.6) J38(25.9,-5.6) J39(26.6,-5.6) J41(28,-5.6) J46(31.5,-5.6) J47(32.2,-5.6) J48(32.9,-5.6) J49(33.6,-5.6) J50(34.3,-5.6) J51(35,-5.6) J52(35.7,-5.6) K2(0.7,-6.3) K4(2.1,-6.3) K6(3.5,-6.3) K8(4.9,-6.3) K12(7.7,-6.3) K13(8.4,-6.3) K14(9.1,-6.3) K15(9.8,-6.3) K16(10.5,-6.3) K17(11.2,-6.3) K18(11.9,-6.3) K19(12.6,-6.3) K20(13.3,-6.3) K21(14,-6.3) K22(14.7,-6.3) K23(15.4,-6.3) K24(16.1,-6.3) K25(16.8,-6.3) K26(17.5,-6.3) K27(18.2,-6.3) K28(18.9,-6.3) K29(19.6,-6.3) K30(20.3,-6.3) K31(21,-6.3) K32(21.7,-6.3) K33(22.4,-6.3) K34(23.1,-6.3) K35(23.8,-6.3) K36(24.5,-6.3) K37(25.2,-6.3) K38(25.9,-6.3) K39(26.6,-6.3) K40(27.3,-6.3) K41(28,-6.3) K45(30.8,-6.3) K47(32.2,-6.3) K49(33.6,-6.3) K51(35,-6.3) L1(0,-7) L2(0.7,-7) L3(1.4,-7) L4(2.1,-7) L5(2.8,-7) L6(3.5,-7) L7(4.2,-7) L8(4.9,-7) L14(9.1,-7) L15(9.8,-7) L17(11.2,-7) L18(11.9,-7) L20(13.3,-7) L21(14,-7) L23(15.4,-7) L24(16.1,-7) L26(17.5,-7) L27(18.2,-7) L29(19.6,-7) L30(20.3,-7) L32(21.7,-7) L33(22.4,-7) L35(23.8,-7) L36(24.5,-7) L38(25.9,-7) L39(26.6,-7) L45(30.8,-7) L46(31.5,-7) L47(32.2,-7) L48(32.9,-7) L49(33.6,-7) L50(34.3,-7) L51(35,-7) L52(35.7,-7) M1(0,-7.7) M2(0.7,-7.7) M3(1.4,-7.7) M4(2.1,-7.7) M5(2.8,-7.7) M6(3.5,-7.7) M7(4.2,-7.7) M8(4.9,-7.7) M9(5.6,-7.7) M10(6.3,-7.7) M43(29.4,-7.7) M44(30.1,-7.7) M45(30.8,-7.7) M46(31.5,-7.7) M47(32.2,-7.7) M48(32.9,-7.7) M49(33.6,-7.7) M50(34.3,-7.7) M51(35,-7.7) M52(35.7,-7.7) N2(0.7,-8.4) N4(2.1,-8.4) N6(3.5,-8.4) N8(4.9,-8.4) N10(6.3,-8.4) N14(9.1,-8.4) N18(11.9,-8.4) N22(14.7,-8.4) N26(17.5,-8.4) N27(18.2,-8.4) N31(21,-8.4) N35(23.8,-8.4) N39(26.6,-8.4) N43(29.4,-8.4) N45(30.8,-8.4) N47(32.2,-8.4) N49(33.6,-8.4) N51(35,-8.4) P1(0,-9.1) P2(0.7,-9.1) P3(1.4,-9.1) P4(2.1,-9.1) P5(2.8,-9.1) P6(3.5,-9.1) P7(4.2,-9.1) P8(4.9,-9.1) P9(5.6,-9.1) P10(6.3,-9.1) P11(7,-9.1) P13(8.4,-9.1) P14(9.1,-9.1) P15(9.8,-9.1) P16(10.5,-9.1) P17(11.2,-9.1) P18(11.9,-9.1) P19(12.6,-9.1) P20(13.3,-9.1) P21(14,-9.1) P22(14.7,-9.1) P23(15.4,-9.1) P24(16.1,-9.1) P25(16.8,-9.1) P26(17.5,-9.1) P27(18.2,-9.1) P28(18.9,-9.1) P29(19.6,-9.1) P30(20.3,-9.1) P31(21,-9.1) P32(21.7,-9.1) P33(22.4,-9.1) P34(23.1,-9.1) P35(23.8,-9.1) P36(24.5,-9.1) P37(25.2,-9.1) P38(25.9,-9.1) P39(26.6,-9.1) P40(27.3,-9.1) P42(28.7,-9.1) P43(29.4,-9.1) P44(30.1,-9.1) P45(30.8,-9.1) P46(31.5,-9.1) P47(32.2,-9.1) P48(32.9,-9.1) P49(33.6,-9.1) P50(34.3,-9.1) P51(35,-9.1) P52(35.7,-9.1) R1(0,-9.8) R2(0.7,-9.8) R3(1.4,-9.8) R4(2.1,-9.8) R5(2.8,-9.8) R6(3.5,-9.8) R7(4.2,-9.8) R8(4.9,-9.8) R9(5.6,-9.8) R10(6.3,-9.8) R11(7,-9.8) R14(9.1,-9.8) R15(9.8,-9.8) R16(10.5,-9.8) R17(11.2,-9.8) R18(11.9,-9.8) R19(12.6,-9.8) R20(13.3,-9.8) R21(14,-9.8) R22(14.7,-9.8) R23(15.4,-9.8) R24(16.1,-9.8) R25(16.8,-9.8) R26(17.5,-9.8) R27(18.2,-9.8) R28(18.9,-9.8) R29(19.6,-9.8) R30(20.3,-9.8) R31(21,-9.8) R32(21.7,-9.8) R33(22.4,-9.8) R34(23.1,-9.8) R35(23.8,-9.8) R36(24.5,-9.8) R37(25.2,-9.8) R38(25.9,-9.8) R39(26.6,-9.8) R42(28.7,-9.8) R43(29.4,-9.8) R44(30.1,-9.8) R45(30.8,-9.8) R46(31.5,-9.8) R47(32.2,-9.8) R48(32.9,-9.8) R49(33.6,-9.8) R50(34.3,-9.8) R51(35,-9.8) R52(35.7,-9.8) T2(0.7,-10.5) T4(2.1,-10.5) T6(3.5,-10.5) T8(4.9,-10.5) T10(6.3,-10.5) T14(9.1,-10.5) T15(9.8,-10.5) T16(10.5,-10.5) T17(11.2,-10.5) T18(11.9,-10.5) T19(12.6,-10.5) T20(13.3,-10.5) T21(14,-10.5) T22(14.7,-10.5) T23(15.4,-10.5) T24(16.1,-10.5) T25(16.8,-10.5) T26(17.5,-10.5) T27(18.2,-10.5) T28(18.9,-10.5) T29(19.6,-10.5) T30(20.3,-10.5) T31(21,-10.5) T32(21.7,-10.5) T33(22.4,-10.5) T34(23.1,-10.5) T35(23.8,-10.5) T36(24.5,-10.5) T37(25.2,-10.5) T38(25.9,-10.5) T39(26.6,-10.5) T43(29.4,-10.5) T45(30.8,-10.5) T47(32.2,-10.5) T49(33.6,-10.5) T51(35,-10.5) U1(0,-11.2) U2(0.7,-11.2) U3(1.4,-11.2) U4(2.1,-11.2) U5(2.8,-11.2) U6(3.5,-11.2) U7(4.2,-11.2) U8(4.9,-11.2) U9(5.6,-11.2) U10(6.3,-11.2) U11(7,-11.2) U14(9.1,-11.2) U15(9.8,-11.2) U16(10.5,-11.2) U17(11.2,-11.2) U18(11.9,-11.2) U19(12.6,-11.2) U20(13.3,-11.2) U21(14,-11.2) U22(14.7,-11.2) U23(15.4,-11.2) U24(16.1,-11.2) U25(16.8,-11.2) U26(17.5,-11.2) U27(18.2,-11.2) U28(18.9,-11.2) U29(19.6,-11.2) U30(20.3,-11.2) U31(21,-11.2) U32(21.7,-11.2) U33(22.4,-11.2) U34(23.1,-11.2) U35(23.8,-11.2) U36(24.5,-11.2) U37(25.2,-11.2) U38(25.9,-11.2) U39(26.6,-11.2) U42(28.7,-11.2) U43(29.4,-11.2) U44(30.1,-11.2) U45(30.8,-11.2) U46(31.5,-11.2) U47(32.2,-11.2) U48(32.9,-11.2) U49(33.6,-11.2) U50(34.3,-11.2) U51(35,-11.2) U52(35.7,-11.2) V1(0,-11.9) V2(0.7,-11.9) V3(1.4,-11.9) V4(2.1,-11.9) V5(2.8,-11.9) V6(3.5,-11.9) V7(4.2,-11.9) V8(4.9,-11.9) V9(5.6,-11.9) V10(6.3,-11.9) V11(7,-11.9) V13(8.4,-11.9) V14(9.1,-11.9) V15(9.8,-11.9) V16(10.5,-11.9) V17(11.2,-11.9) V18(11.9,-11.9) V19(12.6,-11.9) V20(13.3,-11.9) V21(14,-11.9) V22(14.7,-11.9) V23(15.4,-11.9) V24(16.1,-11.9) V25(16.8,-11.9) V26(17.5,-11.9) V27(18.2,-11.9) V28(18.9,-11.9) V29(19.6,-11.9) V30(20.3,-11.9) V31(21,-11.9) V32(21.7,-11.9) V33(22.4,-11.9) V34(23.1,-11.9) V35(23.8,-11.9) V36(24.5,-11.9) V37(25.2,-11.9) V38(25.9,-11.9) V39(26.6,-11.9) V40(27.3,-11.9) V42(28.7,-11.9) V43(29.4,-11.9) V44(30.1,-11.9) V45(30.8,-11.9) V46(31.5,-11.9) V47(32.2,-11.9) V48(32.9,-11.9) V49(33.6,-11.9) V50(34.3,-11.9) V51(35,-11.9) V52(35.7,-11.9) W2(0.7,-12.6) W4(2.1,-12.6) W6(3.5,-12.6) W8(4.9,-12.6) W10(6.3,-12.6) W14(9.1,-12.6) W15(9.8,-12.6) W16(10.5,-12.6) W17(11.2,-12.6) W18(11.9,-12.6) W19(12.6,-12.6) W20(13.3,-12.6) W21(14,-12.6) W22(14.7,-12.6) W23(15.4,-12.6) W24(16.1,-12.6) W25(16.8,-12.6) W26(17.5,-12.6) W27(18.2,-12.6) W28(18.9,-12.6) W29(19.6,-12.6) W30(20.3,-12.6) W31(21,-12.6) W32(21.7,-12.6) W33(22.4,-12.6) W34(23.1,-12.6) W35(23.8,-12.6) W36(24.5,-12.6) W37(25.2,-12.6) W38(25.9,-12.6) W39(26.6,-12.6) W43(29.4,-12.6) W45(30.8,-12.6) W47(32.2,-12.6) W49(33.6,-12.6) W51(35,-12.6) Y1(0,-13.3) Y2(0.7,-13.3) Y3(1.4,-13.3) Y4(2.1,-13.3) Y5(2.8,-13.3) Y6(3.5,-13.3) Y7(4.2,-13.3) Y8(4.9,-13.3) Y9(5.6,-13.3) Y10(6.3,-13.3) Y11(7,-13.3) Y14(9.1,-13.3) Y15(9.8,-13.3) Y16(10.5,-13.3) Y17(11.2,-13.3) Y18(11.9,-13.3) Y19(12.6,-13.3) Y20(13.3,-13.3) Y21(14,-13.3) Y22(14.7,-13.3) Y23(15.4,-13.3) Y24(16.1,-13.3) Y25(16.8,-13.3) Y26(17.5,-13.3) Y27(18.2,-13.3) Y28(18.9,-13.3) Y29(19.6,-13.3) Y30(20.3,-13.3) Y31(21,-13.3) Y32(21.7,-13.3) Y33(22.4,-13.3) Y34(23.1,-13.3) Y35(23.8,-13.3) Y36(24.5,-13.3) Y37(25.2,-13.3) Y38(25.9,-13.3) Y39(26.6,-13.3) Y42(28.7,-13.3) Y43(29.4,-13.3) Y44(30.1,-13.3) Y45(30.8,-13.3) Y46(31.5,-13.3) Y47(32.2,-13.3) Y48(32.9,-13.3) Y49(33.6,-13.3) Y50(34.3,-13.3) Y51(35,-13.3) Y52(35.7,-13.3)
NCP81278MNTXG_QFN20_3X3
  oval 0.787x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.2,-1.6) 12(3.2,-1.2) 13(3.2,-0.8) 14(3.2,-0.4) 15(3.2,0)
  oval 0.203x0.787 smd: 6(0.8,-2.4) 7(1.2,-2.4) 8(1.6,-2.4) 9(2,-2.4) 10(2.4,-2.4) 16(2.4,0.8) 17(2,0.8) 18(1.6,0.8) 19(1.2,0.8) 20(0.8,0.8)
  rect 1.803x1.803 smd: 21(1.6,-0.8)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI5A3158BZAEX_TDFN12_1X3
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(2.5,1.2) 8(2,1.2) 9(1.5,1.2) 10(1,1.2) 11(0.5,1.2) 12(0,1.2)
PI6CEQ20200LIEX_TSSOP20
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(5.85,5.8) 12(5.2,5.8) 13(4.55,5.8) 14(3.9,5.8) 15(3.25,5.8) 16(2.6,5.8) 17(1.95,5.8) 18(1.3,5.8) 19(0.65,5.8) 20(0,5.8)
PS8331BQFN60GTR-A0_QFN60_5X9-S
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PSOT24C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RL-3264-9W-R005-FNH_2512_2512
  rect 2.108x2.489 smd: 1(0,0) 4(1.35,-4.3)
  rect 1.041x2.489 smd: 2(1.875,0) 3(-0.525,-4.3)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8061AZQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT8207PGQW_WQFN20_3X3-S
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT8812AGQW_WQFN20_3X3-S
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GSP_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.157) 6(2.54,5.157) 7(1.27,5.157) 8(0,5.157)
  rect 2.311x2.311 smd: 9(1.905,2.579)
S-5711ACDL-M3T1S_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SDAN_601029-013231_13P
  round 1.194 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  round 1.397 hole 0.991: 9(-3.395,1.1) 10(-1.105,2.6) 11(8.245,2.6) 12(9.39,1.1) 13(10.535,2.6)
  oval 1.473x3.15 hole 0.711x2.388: 14(13.095,-6.42) 16(-5.955,-6.42)
  rect 0.889x1.803 smd: 15(12.32,-9.92) 17(-5.18,-9.92)
SDAN_608015-010232_10P
  round 1.168 hole 0.914: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-8,-1.5) 6(-5.75,-1.5) 7(-3.5,-1.5) 8(-1.25,-1.5) 9(1,-1.5)
  round 1.016 hole 0.762: 10(-8.2,-2.77)
  oval 1.372x3.15 hole 0.61x2.388: 11(-9.9,-1.59) 12(2.9,-1.59)
  oval 1.372x2.667 hole 0.61x1.905: 13(-11.4,-10.35) 14(4.4,-10.35)
SDM10U45-7_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2301CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SI3456DDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI3457CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SIC531CDT1GE3_POWERPAK22_4X3
  oval 0.889x0.279 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2)
  custom 0.322x0.322 smd: 6(1.25,-2.303)
  custom 0.439x0.439 smd: 7(3.018,-1)
  custom 0.225x0.225 smd: 8(4.425,-1)
  oval 0.279x0.889 smd: 9(2.25,0.75) 10(1.75,0.75) 11(1.25,0.75) 12(0.75,0.75)
  rect 1.168x1.194 smd: 13(1.31,-0.588)
SIC632CDT1GE3_POWERPAK31_5X5
  oval 0.889x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 11(5,-3.5) 12(5,-3) 13(5,-2.5) 14(5,-2) 15(5,-1.5) 16(5,-1) 17(5,-0.5) 18(5,0)
  custom 0.337x0.337 smd: 9(1.25,-3.185)
  custom 0.549x0.549 smd: 10(3.327,-2.275)
  oval 0.305x0.889 smd: 19(4.25,0.75) 20(3.75,0.75) 21(3.25,0.75) 22(2.75,0.75) 23(2.25,0.75) 24(1.75,0.75) 25(1.25,0.75) 26(0.75,0.75)
  rect 0.406x0.559 smd: 27(2.6,-0.275)
  rect 1.118x1.422 smd: 28(1.315,-0.71)
SKL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AB29(-20.725,15.203) AB30(-21.376,15.203) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AK29(-20.725,21.502) AK30(-21.376,21.502) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) B3(-1.382,0.699) B37(-25.909,0.703) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BE29(-20.725,33.313) BE30(-21.376,33.313) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) U29(-20.725,11.266) U30(-21.376,11.266) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) AA11(-6.512,14.548) AA12(-7.162,14.548) AC11(-6.512,15.463) AC12(-7.162,15.463) AD11(-6.512,16.377) AD12(-7.162,16.377) AE11(-6.512,17.291) AE12(-7.162,17.291) AF11(-6.512,18.206) AF12(-7.162,18.206) AG11(-6.512,19.12) AG12(-7.162,19.12) AH11(-6.512,20.035) AH12(-7.162,20.035) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AL11(-6.512,21.863) AL12(-7.162,21.863) AM11(-6.512,22.778) AM12(-7.162,22.778) AN11(-6.512,23.692) AN12(-7.162,23.692) AP11(-6.512,24.607) AP12(-7.162,24.607) AR11(-6.512,25.521) AR12(-7.162,25.521) AT11(-6.512,26.435) AT12(-7.162,26.435) AU11(-6.512,27.35) AU12(-7.162,27.35) AW11(-6.512,28.264) AW12(-7.162,28.264) AY11(-6.512,29.179) AY12(-7.162,29.179) B5(-2.743,0.65) B34(-24.443,0.67) BA11(-6.512,30.093) BA12(-7.162,30.093) BB11(-6.512,31.007) BB12(-7.162,31.007) BC11(-6.512,31.922) BC12(-7.162,31.922) BD11(-6.512,32.836) BD12(-7.162,32.836) BF11(-6.512,33.751) BF12(-7.162,33.751) BG11(-6.512,34.665) BG12(-7.162,34.665) BH11(-6.512,35.579) BH12(-7.162,35.579) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BK1(0,37.037) BK13(-7.899,36.727) BL38(-26.628,37.176) BN2(-0.65,38.642) BN37(-25.965,38.665) BR5(-2.166,39.984) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) D37(-25.603,1.985) E2(-0.65,2.474) G1(0,3.581) G38(-26.628,3.671) K11(-6.512,5.48) K12(-7.162,5.48) L11(-6.512,6.319) L12(-7.162,6.319) M11(-6.512,7.233) M12(-7.162,7.233) N11(-6.512,8.147) N12(-7.162,8.147) P11(-6.512,9.062) P12(-7.162,9.062) R11(-6.512,9.976) R12(-7.162,9.976) T11(-6.512,10.891) T12(-7.162,10.891) V11(-6.512,11.805) V12(-7.162,11.805) W11(-6.512,12.719) W12(-7.162,12.719) Y11(-6.512,13.634) Y12(-7.162,13.634)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BL2(-0.65,37.438) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM2(-0.963,38.053) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BM37(-25.978,37.986) BN3(-1.3,38.701) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BN36(-25.314,38.638) BP3(-1.483,39.334) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BP35(-24.561,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BR34(-23.774,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) C36(-25.145,1.388) D4(-1.894,1.655) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E3(-1.3,2.474) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) E37(-25.978,2.604) F2(-0.65,3.16) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
