# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_D53: length 30.9
  IN5 w0.145: v2(211.5,93.95) 211.9,93.55 213.13,93.55 213.25,93.43 220.9,93.43 221.85,92.48 224.99,92.48 226.33,91.15 236.89,91.15 237.85,92.1 237.85,93.55 v2(237.45,93.95)
  BOTTOM w0.089: v2(237.45,93.95) 237.84,94.35 UG6.N13
  BOTTOM w0.178: UG9.E21 v2(211.5,93.95)
FBC_D54: length 31.1
  IN5 w0.145: v2(237.45,95.55) 237.05,95.15 237.05,92.38 236.51,91.85 226.58,91.85 225.25,93.18 222.07,93.18 221.25,94 213.63,94 212.99,94.64 212.49,94.64 212.2,94.35 v2(212.2,93.95)
  BOTTOM w0.089: UG6.M11 v2(237.45,95.55)
  BOTTOM w0.178: UG9.D21 v2(212.2,93.95)
FBC_D55: length 28
  IN5 w0.145: v2(211.45,94.65) 211.82,95.02 213.25,95.02 213.69,94.58 221.62,94.58 222.35,93.85 225.59,93.85 226.9,92.54 234.07,92.54 235.02,93.5 236.19,93.5 v2(236.65,93.95)
  BOTTOM w0.089: UG6.M13 237.04,94.35 v2(236.65,93.95)
  BOTTOM w0.17: v2(211.45,94.65) 211.45,94.8 UG9.E23
FBC_D56: length 38.3
  IN1 w0.145: v2(209.5,96.05) 210.37,95.18 214.17,95.18 215.68,93.67 220.04,93.67 220.06,93.69 225.38,93.69 227.63,95.95 232.97,95.95 233.05,96.02 234.94,96.02 236.84,97.92 238.96,97.92 241.13,100.09 241.13,101.47 v2(240.65,101.95)
  BOTTOM w0.089: UG6.U4 241.05,101.55 v2(240.65,101.95)
  BOTTOM w0.178: UG9.G24 v2(209.5,96.05)
FBC_D57: length 39.2
  IN1 w0.129: 213.14,98.2 212.69,97.74
  IN1 w0.145: v2(240.65,103.55) 241.05,103.95 241.05,104.57 240.87,104.75 236.34,104.75 235.76,104.17 234.25,104.17 233.84,103.77 233.84,101.52 233.08,100.75 228.29,100.75 228.17,100.86 224.88,100.86 222.21,98.2 213.14,98.2 ; 212.69,97.74 209.69,97.74 v2(208.8,96.85)
  BOTTOM w0.089: UG6.U2 241.05,103.15 v2(240.65,103.55)
  BOTTOM w0.178: UG9.H26 v2(208.8,96.85)
FBC_D58: length 35.4
  IN1 w0.145: v2(210.2,96.05) 210.62,95.63 214.45,95.63 215.81,94.27 225.07,94.27 227.6,96.8 234.82,96.8 236.69,98.67 238.84,98.67 240.27,100.1 240.27,100.77 v2(240.65,101.15)
  BOTTOM w0.089: UG6.T4 240.65,101.15 v2(240.65,101.15)
  BOTTOM w0.17: UG9.F24 v2(210.2,96.05)
FBC_D59: length 34.9
  IN1 w0.145: v2(239.85,103.55) 239.45,103.95 236.4,103.95 235.68,103.23 234.93,103.23 234.68,102.97 234.68,102.94 234.66,102.92 234.66,101.29 234.13,100.76 233.79,100.76 233.16,100.13 225.08,100.13 222.52,97.56 218.33,97.56 218.26,97.62 213.06,97.62 212.89,97.45 210.7,97.45 v2(210.1,96.85)
  BOTTOM w0.089: v2(239.85,103.55) 240.25,103.15 UG6.T2
  BOTTOM w0.178: UG9.G26 v2(210.1,96.85)
FBC_D60: length 33.4
  IN1 w0.145: v2(210.8,96.85) 211.07,97.12 212.63,97.12 213.57,96.17 214.62,96.17 215.94,94.85 224.7,94.85 227.31,97.47 234.05,97.47 234.4,97.82 235.09,97.82 236.76,99.49 237.26,99.49 237.94,100.17 237.94,101.46 v2(237.45,101.95)
  BOTTOM w0.089: UG6.N4 237.85,101.55 v2(237.45,101.95)
  BOTTOM w0.17: UG9.F26 v2(210.8,96.85)
FBC_D61: length 31.4
  IN1 w0.145: v2(237.45,102.75) 237.05,102.35 237.05,100.82 236.9,100.68 236.48,100.68 236.24,100.44 236.24,100.02 234.65,98.43 234.12,98.43 233.7,98 225.95,98 223.42,95.48 218.55,95.48 218.54,95.49 216.65,95.49 215.05,97.09 v2(215.05,97.2)
  BOTTOM w0.142: UG9.D26 212.25,97.5 214.2,97.5 214.29,97.59 214.66,97.59 v2(215.05,97.2)
  BOTTOM w0.178: UG6.N2 237.45,102.75 v2(237.45,102.75)
FBC_D62: length 27.5
  IN1 w0.145: v2(215.8,97.2) 216.84,96.16 223.15,96.16 225.7,98.71 233.46,98.71 233.88,99.13 234.59,99.13 235.66,100.2 235.66,100.97 v2(236.65,101.95)
  BOTTOM w0.089: v2(236.65,101.95) 237.05,101.55 UG6.M4
  BOTTOM w0.142: v2(215.8,97.2) 215.41,96.81 213.86,96.81 213.52,97.15 UG9.B26
FBC_D63: length 29.7
  IN1 w0.145: v2(217,97.2) 217.46,96.73 218.01,96.73 218.14,96.86 222.77,96.86 225.27,99.36 233.18,99.36 233.89,100.07 234.51,100.07 235.12,100.68 235.12,101.08 235.45,101.41 235.45,102.24 236.37,103.16 237.05,103.16 v2(237.45,103.55)
  BOTTOM w0.142: UG9.C26 212.95,96.8 213.48,96.8 213.71,96.57 216.37,96.57 v2(217,97.2)
  BOTTOM w0.178: UG6.M2 237.05,103.15 v2(237.45,103.55)
FBC_DBI0: length 23.2
  IN2 w0.145: v2(230.25,75.11) 229.85,74.71 229.85,74.01 228.77,72.93 223.27,72.93 215.95,80.25 214.65,80.25 214.15,80.75 214.15,82 214.28,82.13 v2(214.34,82.13)
  BOTTOM w0.089: v2(230.25,75.11) 230.64,75.51 UG5.P2
  BOTTOM w0.178: UG9.A5 214.31,82.14 214.32,82.14 214.33,82.13 v2(214.34,82.13)
FBC_DBI1: length 22.1
  IN1 w0.089: 227.19,81.69 228.68,81.69 229.06,82.07 229.06,84.16 229.19,84.29 229.83,84.29 v2(230.25,84.71)
  IN1 w0.145: 227.19,81.69 224.61,81.69 224.04,82.26 219.02,82.26 216.93,84.35 214.68,84.35 214.55,84.22 212.89,84.22 v2(212.85,84.18)
  BOTTOM w0.089: UG5.P13 v2(230.25,84.71)
  BOTTOM w0.178: v2(212.85,84.18) 212.85,84.3 UG9.C8
FBC_DBI2: length 39.7
  IN2 w0.145: v2(208.1,91.85) 208.64,91.31 221.09,91.31 222.9,89.5 238.81,89.5 240.25,88.06 240.25,84.51 240.05,84.31 239.45,84.31 v2(239.05,83.91)
  BOTTOM w0.089: v2(239.05,83.91) 238.65,84.31 UG5.D13
  BOTTOM w0.178: UG9.J18 v2(208.1,91.85)
FBC_DBI3: length 40
  IN2 w0.145: v2(210.2,87.65) 210.59,87.26 213.81,87.26 214.39,87.84 220.74,87.84 221.18,87.4 235.79,87.4 236.25,86.94 236.25,81.48 238.66,79.07 238.66,76.32 v2(238.25,75.91)
  BOTTOM w0.089: UG5.D2 v2(238.25,75.91)
  BOTTOM w0.17: UG9.F12 v2(210.2,87.65)
FBC_DBI4: length 21.7
  IN2 w0.145: v2(230.25,103.55) 229.85,103.95 227.32,103.95 227.07,103.7 222.01,103.7 220.51,102.2 v2(220.49,102.2)
  BOTTOM w0.142: v2(220.49,102.2) 220.61,102.07 220.61,101.32 219.5,100.21 219,100.21 218.6,99.81 217.48,99.81 217.31,99.64 214.19,99.64 214.15,99.6 212.25,99.6 UG9.D29
  BOTTOM w0.178: UG6.D2 v2(230.25,103.55)
FBC_DBI5: length 23.6
  IN5 w0.089: v2(230.25,93.95) 229.88,94.32 229.25,94.32 229.06,94.51 229.06,96.67 228.04,97.69 227.19,97.69
  IN5 w0.145: 227.19,97.69 222.39,97.69 222.03,97.33 218.46,97.33 218.1,97.69 215.83,97.69 215.43,98.09 214.24,98.09 213.45,98.87 212.22,98.87 v2(211.5,98.15)
  BOTTOM w0.089: v2(230.25,93.95) 230.64,94.35 UG6.D13
  BOTTOM w0.17: v2(211.5,98.15) UG9.E27
FBC_DBI6: length 36
  IN2 w0.145: v2(239.05,94.75) 239.44,94.36 240.01,94.36 240.25,94.12 240.25,91.85 238.6,90.19 225.82,90.19 223.48,92.54 211.89,92.54 211.61,92.82 210.97,92.82 v2(210.8,92.65)
  BOTTOM w0.089: UG6.P13 238.65,94.35 v2(239.05,94.75)
  BOTTOM w0.178: UG9.F20 v2(210.8,92.65)
FBC_DBI7: length 37
  IN2 w0.114: 227.41,93.48 233.59,93.48 233.82,93.71 233.82,94.51 233.75,94.59 233.75,97.34 236.23,99.82 236.23,101.35 236.44,101.56 236.82,101.56 237.05,101.79 237.05,102.13 237.28,102.36 237.7,102.36 237.85,102.5 237.85,103.15 v2(238.25,103.55)
  IN2 w0.145: 227.41,93.48 224.19,96.69 v2(212.34,96.69)
  BOTTOM w0.089: UG6.P2 238.65,103.15 v2(238.25,103.55)
  BOTTOM w0.102: UG9.E26 211.43,97.15 211.78,96.8 212.23,96.8 v2(212.34,96.69)
FBC_EDC0: length 24.5
  IN2 w0.145: v2(229.44,75.9) 229.05,75.51 229.05,74.04 228.79,73.78 224.12,73.78 216.85,81.05 215.85,81.05 215.2,81.7 215.2,81.85 214.44,82.61 212.06,82.61 v2(211.6,82.15)
  BOTTOM w0.089: UG5.R2 229.84,75.51 v2(229.44,75.9)
  BOTTOM w0.17: UG9.D5 v2(211.6,82.15)
FBC_EDC1: length 32.2
  IN2 w0.145: v2(229.45,83.91) 229.05,83.51 229.05,81.95 230.8,80.2 230.8,77.07 230.65,76.92 230.65,76.49 230.47,76.31 228.25,76.31 227.58,76.98 222.37,76.98 216.8,82.55 215.63,82.55 215.14,83.04 212.16,83.04 211.9,83.3 211.9,83.96 211.63,84.22 211.63,84.22 v2(211.6,84.25)
  BOTTOM w0.089: UG5.R13 v2(229.45,83.91)
  BOTTOM w0.178: UG9.D8 v2(211.6,84.25)
FBC_EDC2: length 33.3
  IN2 w0.145: v2(211.5,90.55) 211.62,90.67 214.17,90.67 214.58,90.26 220.49,90.26 221.95,88.8 238.2,88.8 239.44,87.56 239.44,85.12 v2(239.85,84.71)
  BOTTOM w0.089: UG5.C13 239.45,84.31 v2(239.85,84.71)
  BOTTOM w0.1: v2(211.5,90.55) UG9.E17
FBC_EDC3: length 41.3
  IN2 w0.145: v2(211.5,87.65) 212.39,88.54 220.99,88.54 221.48,88.06 237.23,88.06 237.85,87.44 237.85,82.03 238.25,81.63 238.25,80.58 239.45,79.38 239.45,75.51 v2(239.05,75.11)
  BOTTOM w0.089: v2(239.05,75.11) 239.45,75.51 UG5.C2
  BOTTOM w0.17: UG9.E12 v2(211.5,87.65)
FBC_EDC4: length 20.6
  IN2 w0.145: v2(211.5,100.25) 211.89,99.86 212.81,99.86 213.73,100.78 219.87,100.78 222.24,103.15 229.05,103.15 v2(229.45,102.75)
  BOTTOM w0.178: UG9.E30 v2(211.5,100.25) ; UG6.C2 v2(229.45,102.75)
FBC_EDC5: length 20.5
  IN2 w0.145: v2(215.05,99.25) 215.71,98.59 228.41,98.59 229.04,97.96 229.04,95.16 v2(229.45,94.75)
  BOTTOM w0.089: UG6.C13 v2(229.45,94.75)
  BOTTOM w0.142: v2(215.05,99.25) 214.65,98.85 213.85,98.85 213.45,99.25 UG9.B29
FBC_EDC6: length 34.7
  IN2 w0.145: v2(239.85,93.95) 239.45,93.55 239.45,92.2 238.14,90.89 226.26,90.89 223.66,93.5 209.95,93.5 v2(209.5,93.95)
  BOTTOM w0.089: UG6.R13 v2(239.85,93.95)
  BOTTOM w0.178: UG9.G21 v2(209.5,93.95)
FBC_EDC7: length 37.2
  IN2 w0.114: 233.87,92.54 234.21,92.88 234.21,93.33 234.65,93.77 234.65,96.65 235.26,97.26 235.26,97.52 237.89,100.15 237.89,100.95 238.65,101.71 238.65,102.35 v2(239.05,102.75)
  IN2 w0.145: v2(211.5,96.1) 211.61,96.1 212,95.71 224.05,95.71 227.23,92.54 233.87,92.54
  BOTTOM w0.089: UG6.R2 239.05,102.75 v2(239.05,102.75)
  BOTTOM w0.178: UG9.E24 211.2,95.8 v2(211.5,96.1)
FBC_WCK01: length 26.2
  IN2 w0.119: v2(210.2,84.25) 210.03,84.42 210.03,84.83 210.15,84.95 213.68,84.95 214.22,84.42 216.8,84.42 221.44,79.78 228.63,79.78 229.86,78.55 229.86,77.11 v2(230.25,76.71)
  BOTTOM w0.089: UG5.P4 230.64,77.11 v2(230.25,76.71)
  BOTTOM w0.119: UG9.F8 v2(210.2,84.25)
FBC_WCK01#: length 26.2
  IN2 w0.119: v2(209.64,84.1) 209.82,84.28 209.82,84.91 210.07,85.16 213.77,85.16 214.31,84.62 216.89,84.62 221.53,79.99 228.72,79.99 230.07,78.64 230.07,77.69 v2(230.25,77.51)
  BOTTOM w0.089: UG5.P5 v2(230.25,77.51)
  BOTTOM w0.119: v2(209.64,84.1) 209.8,84.26 UG9.G8
FBC_WCK23: length 37.3
  IN2 w0.119: v2(208.8,87.65) 208.8,87 209.02,86.78 219.81,86.78 220.1,86.49 233.2,86.49 235.55,84.15 235.55,80.89 237.63,78.81 237.63,78.09 238.22,77.49 v2(238.26,77.49)
  BOTTOM w0.089: UG5.D4 v2(238.26,77.49)
  BOTTOM w0.119: UG9.H12 v2(208.8,87.65)
FBC_WCK23#: length 37.2
  IN2 w0.119: v2(209.5,87.65) 209.36,87.65 209.01,87.3 209.01,87.09 209.11,86.99 219.9,86.99 220.18,86.7 233.29,86.7 235.76,84.23 235.76,80.98 237.84,78.9 237.84,78.17 237.91,78.11 238.02,78.11 v2(238.25,78.33)
  BOTTOM w0.089: v2(238.25,78.33) 238.65,77.93 UG5.D5
  BOTTOM w0.119: UG9.G12 v2(209.5,87.65)
FBC_WCK45: length 28.9
  IN2 w0.119: v2(231.08,101.9) 231.16,101.9 231.58,101.48 231.58,100.47 230.9,99.78 214.24,99.78 213.91,99.45 213.91,98.24 212.94,97.28 208.39,97.28 208.1,97.56 v2(208.1,98.15)
  BOTTOM w0.089: v2(231.08,101.9) 231,101.9 UG6.D4
  BOTTOM w0.119: UG9.J27 v2(208.1,98.15)
FBC_WCK45#: length 28.7
  IN2 w0.119: v2(208.8,98.15) 208.63,98.15 208.31,97.82 208.31,97.65 208.47,97.48 212.85,97.48 213.7,98.33 213.7,99.53 214.15,99.99 230.81,99.99 231.38,100.56 231.38,101.4 231.25,101.53 231.07,101.53 230.94,101.4 v2(230.94,101.14)
  BOTTOM w0.089: v2(230.94,101.14) 230.77,101.14 230.65,101.02 UG6.D5
  BOTTOM w0.119: v2(208.8,98.15) 208.8,97.98 208.93,97.85 UG9.H27
FBC_WCK67: length 39.9
  IN2 w0.119: v2(239.05,101.15) 239.05,101.1 239.5,100.65 239.5,99.19 239.1,98.8 237.56,98.8 235.85,97.09 235.85,93.77 234.34,92.26 234.34,92.24 233.76,91.65 226.84,91.65 223.85,94.64 212.22,94.64 211.53,95.34 210.13,95.34 209.92,95.13 209.92,94.93 v2(210.1,94.75)
  BOTTOM w0.089: v2(239.05,101.15) 239.05,101.15 UG6.P4
  BOTTOM w0.119: UG9.G23 v2(210.1,94.75)
FBC_WCK67#: length 39.9
  IN2 w0.119: v2(238.9,100.33) 238.9,100.54 239.02,100.67 239.18,100.67 239.29,100.57 239.29,99.28 239.02,99.01 237.47,99.01 235.65,97.18 235.65,93.86 234.14,92.35 234.14,92.33 233.67,91.86 226.92,91.86 223.94,94.85 212.31,94.85 211.61,95.55 210.05,95.55 209.71,95.21 209.71,94.9 209.56,94.75 v2(209.4,94.75)
  BOTTOM w0.089: v2(238.9,100.33) 238.9,100.5 UG6.P5
  BOTTOM w0.119: UG9.H23 v2(209.4,94.75)
FBCAL_GND: length 1.2
  TOP w0.089: RG68.1 205.2,109.56 v2(205.2,109.45)
  BOTTOM w0.114: UG9.P44 v2(205.2,109.45)
FBCAL_TERM: length 2.4
  TOP w0.1: RG69.1 204.28,111.56 204.28,110.52 v2(203.9,110.15)
  BOTTOM w0.114: UG9.R45 v2(203.9,110.15)
FBCAL_VDDQ: length 1.2
  TOP w0.089: v2(203.9,109.45) 204.29,109.45 RG67.1
  BOTTOM w0.114: UG9.R44 v2(203.9,109.45)
FBVDD/Q_EN: length 296.6
  TOP w0.114: v2(119.93,16.25) 119.93,15.78 RG570.1 ; v2(188.41,71) 188.8,71.4 188.8,74.84 187.83,75.81 RG557.1 187.83,75.91 UG27.4
  TOP w0.254: v2(254.15,56.15) 254.15,55.88 254.65,55.38 PR8216.1
  IN1 w0.097: v2(237.07,42.67) 232.37,37.97 222.68,37.97 217.49,32.79 217.49,29.77 218.35,28.92 218.35,27.67 217.86,27.19 216.04,27.19 215.52,26.67 212.03,26.67 211.36,26 207.93,26 207.18,26.76 199.68,26.76 194.87,31.57 194.87,33.93 189.63,39.17 189.63,40.09 189.81,40.27 190.22,40.27 190.43,40.48 190.43,41.41 190.06,41.78 189.64,41.78 188.7,42.72 188.7,52.19 187.78,53.12 187.53,53.12 186.73,53.91 186.73,63.11 187.63,64.01 187.63,65.3 186.87,66.06 186.87,68.17 187.84,69.14 187.84,70.55 188.3,71 v2(188.41,71)
  IN4 w0.254: v2(237.07,42.67) 237.94,41.8 240.18,41.8 244.83,46.45 244.83,48.34 247.03,50.55 251.29,50.55 254.15,53.41 v2(254.15,56.15)
  IN5 w0.097: v2(237.07,42.67) 237.07,39.99 230.74,33.65 230.74,30.03 227.62,26.92 227.62,25.13 229.71,23.05 229.71,22.17 231.49,20.39 231.49,16.65 227.67,12.83 227.67,10.07 228.83,8.91 228.83,7.24 228.22,6.63 225.21,6.63 223.01,4.43 217.31,4.43 217.14,4.6 207.91,4.6 207.65,4.34 198.25,4.34 197.85,4.74 186.41,4.74 186.21,4.55 182.97,4.55 182.82,4.7 182.82,5.05 180.02,7.85 174.76,7.85 174.55,8.06 172.78,8.06 172.3,8.53 165.87,8.53 160.94,13.46 154.51,13.46 151,16.97 150.55,16.97 149.92,17.61 145.54,17.61 145.1,18.05 138.99,18.05 138.3,18.73 126.26,18.73 124.16,16.64 120.3,16.64 119.93,16.27 v2(119.93,16.25)
FBVDD/Q_ENP: length 6.6
  TOP w0.114: v1(253.87,56.7) 254.31,56.7 254.71,56.3 PR8216.2
  TOP w0.203: PC8211.1 254.93,58.14 254.24,58.14 253.74,58.65 253.74,59.77 253.82,59.85 PU8200.3
  TOP w0.254: PC8211.1 PR8220.2 PR8216.2
FCCM_GT: length 41.2
  IN1 w0.254: v2(121.61,138.6) 121.61,139.17 121.42,139.36 114.38,139.36 v2(113.71,138.69) 113.23,138.69 112.58,139.34 108.15,139.34 107.88,139.62 95.96,139.62 95.45,139.11 89.8,139.11 88.53,137.84 88.53,136.89 89.3,136.12 v2(89.3,135.79)
  BOTTOM w0.114: v2(113.71,138.69) 113.49,138.92 v1(113.21,138.92)
  BOTTOM w0.203: PU500.11 90.02,135.02 89.3,135.74 v2(89.3,135.79)
  BOTTOM w0.254: v2(113.71,138.69) PR585.1 ; PR594.1 122.04,138.17 v2(121.61,138.6)
FCCM_SA: length 67.8
  IN2 w0.254: v2(153.49,132.38) 153.49,133.05 154.38,133.95 154.38,134.92 149.61,139.69 109.37,139.69 101.1,131.43 v2(98.25,131.43)
  BOTTOM w0.114: v2(153.49,132.38) 153.75,132.63 153.75,132.68 v1(153.92,132.86)
  BOTTOM w0.203: v2(98.25,131.43) 97.93,131.43 97.54,131.82 PU500.34
  BOTTOM w0.254: PR5006.1 153.49,131.95 v2(153.49,132.38)
FCCM_VCORE: length 57.5
  IN5 w0.254: v2(146.21,138.54) 145.78,138.98 138.69,138.98 v2(138.25,138.54) 136.98,138.54 136.28,139.24 130.4,139.24 v2(129.73,138.57) 129.14,138.57 127.77,139.93 102.37,139.93 101.51,140.8 100.12,140.8 v2(99.64,140.32)
  BOTTOM w0.203: PU500.24 95.73,136.57 95.85,136.7 97.31,136.7 97.59,136.98 97.59,138.26 v1(98.4,139.07) v2(99.64,140.32)
  BOTTOM w0.254: v2(129.73,138.57) 130.17,138.13 PR556.1 ; v2(146.21,138.54) 146.21,138.49 146.66,138.05 PR576.1 ; PR566.1 138.38,138.21 138.38,138.41 v2(138.25,138.54)
FRAME_LOCK#: length 10.1
  BOTTOM w0.114: UG9.BG2 181.8,80.15 181.43,79.78 v1(181.43,77.48) 181.43,76.81 181.89,76.35 181.89,75.03 181.67,74.81 QG506.3 180.81,74.81 179.53,76.1 178.32,76.1 RG502.2
G-SYNC#: length 153.5
  TOP w0.114: v2(129.25,161.53) 129.25,161.35 128.6,160.7 JEDP.21 ; v2(157.02,70.29) v1(156.51,70.29)
  IN2 w0.097: v2(157.02,70.29) 155.41,71.9 155.41,77.52 153.18,79.75 153.18,110.61 158.12,115.55 158.12,118.53 160.67,121.08 160.67,130.2 153.87,136.99 153.87,137.35 150.81,140.42 131.33,140.42 130.25,141.5 130.25,145.82 130.95,146.52 130.95,147.98 132.62,149.64 132.62,154.16 131.04,155.74 131.04,157.16 130.34,157.86 130.34,158.4 128.94,159.79 128.94,161.05 129.25,161.35 v2(129.25,161.53)
  IN3 w0.124: v2(157.02,70.29) 158.51,68.79 163.52,68.79 167.32,72.59 171.14,72.59 171.92,73.37 179.15,73.37 v2(180.1,74.32)
  BOTTOM w0.114: QG506.1 180.1,74.58 v2(180.1,74.32) 180.1,74 180.35,73.75 RG517.2
GC6_EVENT#: length 56.3
  TOP w0.114: v2(176.37,41.66) 176.37,40.6 177.05,39.92 178.62,39.92 179.58,40.88 180.38,40.88 180.65,41.15 181.2,41.15 181.69,40.66 182.7,40.66 183.15,41.11 183.72,41.11 184.04,40.79 184.04,40.05 184.48,39.6 186.11,39.6 186.67,40.16 188,40.16 v3(189.04,41.2) 189.47,41.2 v2(190.02,40.65)
  IN1 w0.097: v2(190.02,40.65) 188.5,42.17 188.5,52.09 187.7,52.89 187.39,52.89 186.54,53.75 186.54,63.07 182.45,67.16 182.45,71.65 v2(182.45,71.66)
  BOTTOM w0.089: UH1.AR24 176.79,41.02 v2(176.37,41.66)
  BOTTOM w0.114: v2(182.45,71.66) 182.45,71.66 DG2.1
GC6_EVENT#_D: length 4.3
  BOTTOM w0.114: UG9.BD1 183.9,78.58 183.4,78.08 v1(183.4,77.52) 183.4,76.93 183.34,76.87 RG8.1 182.55,76.52 DG2.2
GC6_FB_EN: length 127.9
  TOP w0.089: 184.56,39.2 184.24,39.52 183.78,39.52 182.83,40.47 181.88,40.47 181.69,40.28 180.16,40.28 179.91,40.03 179.21,40.03 178.79,39.6 v2(178.79,39.4)
  TOP w0.114: v2(187.15,55.48) 186.93,55.7 RG561.2 186.34,54.47 QG511.1 ; v2(190.02,39.85) 189,39.85 188.55,39.39 186.45,39.39 186.26,39.2 184.56,39.2 ; UE10.9 123.16,11.39 v2(123.26,11.3) ; v2(189.75,69.31) 190.2,69.31 190.55,69.65 v1(190.55,70.57)
  IN1 w0.097: v2(187.15,55.48) 187,55.33 187,53.93 187.61,53.32 187.86,53.32 188.9,52.28 188.9,42.8 189.72,41.98 190.14,41.98 190.63,41.49 190.63,40.4 190.08,39.85 v2(190.02,39.85)
  IN2 w0.089: v2(178.79,39.4) 178.59,39.4 178.23,39.03 177.94,39.03 177.75,39.22 176.65,39.22 176.09,38.66 174.91,38.66 173.58,37.34 173.58,32.44 172.91,31.77 172.91,31.61 172.13,30.83 172.13,29.32 171.59,28.78 170.82,28.78 170.43,28.39 169.3,28.39 169.06,28.63 167.35,28.63 166.96,28.24
  IN2 w0.097: v2(123.5,19.01) 138.69,19.01 139.34,19.66 142.7,19.66 144.37,21.33 148.07,21.33 150.25,23.52 151.64,23.52 152.51,24.39 153.55,24.39 156.08,26.92 163.82,26.92 165.13,28.22 166.94,28.22 166.96,28.24
  IN5 w0.097: v2(187.15,55.48) 187.78,56.12 187.78,66.19 188.86,67.27 188.86,68.41 189.75,69.3 v2(189.75,69.31)
  BOTTOM w0.089: UH1.AW27 179.13,39.74 v2(178.79,39.4)
  BOTTOM w0.114: v2(123.5,19.01) 123.5,18.04 122.73,17.27 122.73,11.82 v2(123.26,11.3)
GPIO3_OC_WARN#: length 17.7
  TOP w0.089: v2(186.51,82.26) 186.48,82.29 v1(186.01,82.29) 185.84,82.29 185.62,82.08 RG522.1
  IN1 w0.089: v2(186.51,82.26) 186.7,82.07 186.7,81.93 187.31,81.32 187.31,78.19
  IN1 w0.097: v2(186.01,71.3) 186.01,71.4 186.84,72.24 186.84,73.06 187.4,73.62 187.4,78.1 187.31,78.19
  BOTTOM w0.114: UG9.BB4 185.3,81.8 185.62,82.13 186.38,82.13 v2(186.51,82.26) ; v2(186.01,71.3) 185.38,71.92 QG5.1
GPIO_1: length 6.9
  TOP w0.254: DA2.2 34.82,41.43 v1(33.8,41.43) 32.59,41.43 32.4,41.62 31.26,41.62 30.99,41.35 v2(30.99,40.65)
  BOTTOM w0.114: UA1.2 30.72,40.38 v2(30.99,40.65)
GPU_ALERT#: length 121.7
  TOP w0.114: UE10.10 v2(123.26,11.89) 123.33,11.89 123.59,12.15 123.59,14.17 RE644.1 ; QG501.3 185.34,76.9 185.05,76.61 v2(184.77,76.61)
  IN3 w0.124: v2(184.77,76.61) 184.1,76.61 184.04,76.54 182.51,76.54 181.5,75.53 181.5,75.16 179.48,73.14 172.01,73.14 171.24,72.36 167.41,72.36 161.61,66.56 160.05,66.56 v2(159.4,67.21)
  IN5 w0.097: v2(152.41,28.47) 152.54,28.6 152.54,35.08 152.22,35.39 152.22,56.96 157.14,61.88 157.52,61.88 157.94,62.29 157.94,65.94 159.21,67.21 v2(159.4,67.21)
  BOTTOM w0.114: v2(152.41,28.47) 152.41,28.35 150.51,26.44 136.35,26.44 v1(132.6,22.69) 132.6,17.36 133.87,16.09 133.87,13.36 132.86,12.34 123.71,12.34 v2(123.26,11.89)
GPU_AUXN/DDC: length 78.3
  IN5 w0.097: v2(176.73,124.99) 176.85,124.87 177.45,124.87 178.59,123.74 178.59,117.99 177.02,116.42 177.02,97.75 178.39,96.37 178.39,86.49 179.82,85.06 182.95,85.06 183.3,85.41 183.3,85.78 183.12,85.96 183.12,86.03 v2(182.8,86.35)
  BOTTOM w0.114: v2(176.73,124.99) 176.67,124.93 176.38,124.93 RV670.1 175.95,124.93 170.64,124.93 167.83,127.74 163.6,127.74 160.92,125.06 160.92,117.94 160.02,117.04 159.32,117.04 158.35,116.06 158.35,114.83 CV425.2 ; UG9.BF11 v2(182.8,86.35)
GPU_AUXN/DDC_C: length 2.4
  BOTTOM w0.114: CV425.1 158.38,113.91 158.38,113.69 158.7,113.37 v4(158.7,113.11) 158.7,112.42 158.67,112.39 UV21.27
GPU_AUXP/DDC: length 78.2
  IN5 w0.097: v2(176.73,124.36) 177.05,124.67 177.37,124.67 178.39,123.66 178.39,118.07 176.82,116.5 176.82,97.67 178.2,96.29 178.2,86.4 179.74,84.86 183.03,84.86 183.5,85.33 183.5,85.87 183.32,86.05 183.32,86.17 v2(183.5,86.35)
  BOTTOM w0.114: v2(176.73,124.36) 176.46,124.64 176.28,124.64 RV669.1 176.02,124.66 170.52,124.66 167.72,127.47 163.71,127.47 161.19,124.95 v4(161.19,118.77) 161.19,117.83 160.13,116.77 159.43,116.77 158.61,115.95 158.61,114.83 CV424.2 ; UG9.BE11 v2(183.5,86.35)
GPU_AUXP/DDC_C: length 2.4
  BOTTOM w0.114: UV21.28 159.07,112.37 158.97,112.47 158.97,113.48 158.65,113.8 158.65,113.98 CV424.1
GPU_B+:
  vias: v1(243.94,50.89)
GPU_BUFRST#: length 1
  TOP w0.114: T6.1 182.51,85.86 v2(182.2,85.55)
  BOTTOM w0.114: UG9.BF9 v2(182.2,85.55)
GPU_DPC_AUX: length 1.3
  BOTTOM w0.114: RV619.1 187.66,153.11 188.14,153.11 CV24.2
GPU_DPC_AUX#: length 1.2
  BOTTOM w0.114: RV618.1 187.54,153.38 188.19,153.38 CV25.2
GPU_FAN_FB: length 249.6
  TOP w0.114: UE5.29 99.87,9.09 v2(99.31,9.66) ; v2(173.18,9.74) 173.74,10.31 180.22,10.31 180.37,10.15 214.24,10.15 215.3,11.21 215.3,13.07 215.55,13.31 224.61,13.31 225.18,13.89 225.18,14.89 225.03,15.04 225.03,15.33 222.67,17.69 222.67,19.49 224.27,21.09 225.44,21.09 226.19,21.85 226.19,23.27 v3(224.61,24.85) 224.61,27.4 225.02,27.82 v2(225.03,27.82)
  IN1 w0.097: v2(173.18,9.74) 172.15,10.77 165.1,10.77 158.93,16.95 141.72,16.95 140.48,18.19 130.82,18.19 130.25,17.61 125.05,17.61 124.48,17.05 119.34,17.05 117.5,15.21 107.97,15.21 107.07,14.31 101.78,14.31 101.27,13.8 100.27,13.8 99.31,12.83 v2(99.31,9.66)
  IN4 w0.137: v2(247.33,82.68) 247.73,82.68 250.22,80.18 250.22,72.44 252.79,69.87 256.72,69.87 259.81,66.79 259.81,64.75 261.49,63.07 261.49,57.69 258.67,54.86 258.67,50.73 255.83,47.89 250.14,47.89 241.63,39.38 235.67,39.38 230.93,34.64 230.93,33.49 225.26,27.82 v2(225.03,27.82)
  BOTTOM w0.114: v2(247.33,82.68) 245.62,82.68 RF4.1 244.12,82.05 243.66,82.51 DF2.2
GPU_FAN_PWM: length 252.9
  TOP w0.114: UE5.27 99.07,7.9 98.38,8.59 v2(98.38,9.64) ; v2(174.02,9.74) 174.36,10.09 180.13,10.09 180.28,9.94 214.33,9.94 215.51,11.13 215.51,12.98 215.64,13.1 224.7,13.1 225.4,13.8 225.4,14.98 225.25,15.13 225.25,15.42 222.89,17.78 222.89,19.4 224.36,20.88 225.53,20.88 226.41,21.76 226.41,23.94 v3(226.29,24.05) 224.87,25.48 224.87,27.08 v2(225.02,27.23)
  IN1 w0.097: v2(174.02,9.74) 172.8,10.97 165.19,10.97 159.01,17.14 141.84,17.14 140.54,18.44 130.76,18.44 130.16,17.84 124.95,17.84 124.36,17.25 118.84,17.25 117,15.41 107.89,15.41 106.99,14.5 101.7,14.5 101.19,13.99 100.09,13.99 99.11,13.01 99.11,10.37 v2(98.38,9.64)
  IN4 w0.137: v2(225.02,27.23) 225.02,27.24 231.17,33.39 231.17,34.54 235.77,39.14 241.82,39.14 250.33,47.65 255.93,47.65 258.9,50.63 258.9,54.76 261.73,57.59 261.73,63.17 260.05,64.85 260.05,66.89 256.81,70.13 252.87,70.13 250.46,72.54 250.46,81.24 248.32,83.38 v2(247.33,83.38)
  BOTTOM w0.114: 246.23,86.81 245,86.12 RF5.1 245.96,84.75 v2(247.33,83.38)
GPU_GC6_FB_EN: length 45.6
  TOP w0.089: v2(184.84,82.19) 184.99,82.04 RG22.1
  TOP w0.114: v2(188.42,77.37) 188.42,77.62 188.76,77.96 188.76,77.96 188.98,78.18 189.13,78.34 UG27.1 ; QG511.3 187.31,53.24 187.58,53.5 187.58,54.51 187.73,54.66 187.73,56.45 RG553.1 188.1,56.44 188.1,55.45 v1(188.36,55.19) 188.36,54.72 RG563.2 188.76,54.32 v2(189.37,54.32)
  IN3 w0.089: v2(184.84,82.19) 184.85,82.18 184.85,79.29 185.95,78.19
  IN3 w0.124: v2(188.42,77.37) 186.77,77.37 185.95,78.19
  IN5 w0.097: v2(189.37,54.32) 189.05,54.32 188.29,55.08 188.29,55.53 187.98,55.84 187.98,66.11 189.24,67.37 189.24,67.91 190.51,69.18 190.51,70.5 189.71,71.3 189.71,72.52 189.12,73.11 189.12,76.67 v2(188.42,77.37)
  BOTTOM w0.114: v2(184.84,82.19) 185.1,82.45 UG9.BB5
GPU_GC6_FB_EN_R: length 27.5
  TOP w0.089: v2(182.18,36.27) v1(182.18,35.7)
  TOP w0.114: RG563.1 187.78,52.8 185.74,52.8 185.42,52.48 183.96,52.48 v2(183.83,52.6)
  IN1 w0.089: v2(182.18,36.27) 182.31,36.14 184.56,36.14 ; 184.56,51.83 184.56,51.88 v2(183.83,52.6)
  IN1 w0.097: 184.56,36.14 184.9,36.14 185.3,36.54 185.3,42.6 184.74,43.15 184.74,51.64 184.56,51.83
  BOTTOM w0.089: v2(182.18,36.27) 182.18,36.36 181.3,37.24 UH1.BD32
GPU_ID: length 4.6
  TOP w0.089: RH25.1 173.04,31.23 RH26.1 173.01,31.11 173.37,30.76 173.37,30.31 v1(173.43,30.25) 173.75,29.93 v2(173.75,29.81)
  BOTTOM w0.089: UH1.AJ43 173.83,31.73 173.56,31.46 173.56,30.95 173.5,30.89 173.5,30.19 173.69,30 173.69,29.87 v2(173.75,29.81)
GPU_INV_PWM: length 45.9
  TOP w0.089: v2(183.59,83.53) 183.64,83.48 RG150.1
  TOP w0.114: UG24.5 165.3,61.24 165.5,61.05 167.46,61.05 v1(167.84,61.43) 168.16,61.75 168.16,61.81 v2(168.29,61.94)
  IN3 w0.124: v2(183.39,69.95) 182.96,69.95 182.72,70.19 182.7,70.19 181.04,71.85 172.55,71.85 167.15,66.45 167.15,63.08 v2(168.29,61.94)
  IN5 w0.089: 183.41,83.53 v2(183.59,83.53) ; 182.2,82.32 182.2,82.13 181.88,81.81
  IN5 w0.097: 181.88,81.81 181.62,81.56 181.62,78.98 181.17,78.52 181.17,74.45 184,71.62 184,70.56 v2(183.39,69.95) ; 183.41,83.53 182.58,83.53 182.2,83.15 182.2,82.32
  BOTTOM w0.114: UG9.BD7 v2(183.59,83.53)
GPU_MDP_N0: length 109.9
  TOP w0.114: CV27.1 198.06,162.68 198.06,162.54 197.94,162.41 197.13,162.41 v2(196.85,162.68)
  IN1 w0.097: v2(196.85,162.68) 197.07,162.47 197.25,162.47 197.37,162.6 197.37,163.85 197.62,164.09 202.02,164.09 205.38,160.74 205.38,153.61 204.38,152.61 202.86,152.61 201.71,151.46 199.59,151.46 198.96,150.84 198.96,148.52 198.47,148.04 197.2,148.04 197,147.83 197,145.61 195.11,143.72 180.77,143.72 176.99,139.94 176.99,133.25 176.36,132.61 176.36,113.75 176.52,113.59 176.52,99.56 178.34,97.74 178.34,92.59 179.78,91.15 180.98,91.15 181.22,90.91 181.22,90.83 v2(181.5,90.55)
  BOTTOM w0.114: UG9.BG17 v2(181.5,90.55)
GPU_MDP_N1: length 106.4
  TOP w0.114: CV30.1 201.31,162.86 201.21,162.76 201.21,162.35 200.93,162.06 200.26,162.06 200.13,161.94 200.13,161.7 v2(200.23,161.61)
  IN1 w0.097: v2(182.2,89.75) 181.82,89.37 179.22,89.37 176.86,91.73 176.86,98 175.72,99.15 175.72,113.05 175.56,113.21 175.56,132.95 176.19,133.58 176.19,140.27 180.48,144.56 194.52,144.56 196.04,146.07 196.04,148.61 196.93,149.5 197.87,149.5 198,149.63 198,151.05 199.26,152.31 200.75,152.31 202.27,153.83 203.77,153.83 204.55,154.61 204.55,160.43 203.54,161.43 201.1,161.43 200.48,162.06 200.26,162.06 200.13,161.93 200.13,161.7 v2(200.23,161.61)
  BOTTOM w0.114: UG9.BF15 v2(182.2,89.75)
GPU_MDP_N2: length 101.9
  TOP w0.114: CV33.1 204.16,162.68 204.16,162.45 202.9,161.18 202.9,159.86 203.29,159.47 203.29,159.02 v2(203.1,158.83)
  IN1 w0.097: v2(203.1,158.83) 203.25,158.67 203.25,158.14 203,157.89 199.89,157.89 198.9,156.9 198.9,153.21 197.67,151.99 196.81,151.99 195.59,150.77 195.59,149.95 192.29,146.65 192.29,146.14 191.31,145.16 180.23,145.16 175.59,140.52 175.59,133.83 174.96,133.2 174.96,112.67 175.08,112.55 175.08,98.49 175.53,98.04 175.53,93.91 176.16,93.29 176.16,91.59 178.88,88.86 182.81,88.86 182.93,88.73 182.93,88.58 v2(182.8,88.45)
  BOTTOM w0.114: UG9.BF14 v2(182.8,88.45)
GPU_MDP_N3: length 97.8
  IN1 w0.097: v2(201.28,159.1) 200.24,159.1 198.25,157.12 198.25,154.32 197.76,153.83 196.05,153.83 195.28,153.06 195.28,151.47 191.73,147.93 190.75,147.93 188.65,145.83 179.22,145.83 174.95,141.56 174.95,134.22 174.36,133.63 174.36,112.06 174.44,111.98 174.44,96.53 174.89,96.08 174.89,93.54 175.52,92.91 175.52,90.94 179.19,87.27 180.88,87.27 181.5,87.88 v2(181.5,88.45)
  BOTTOM w0.114: CV31.1 200.81,159.8 200.81,159.09 200.94,158.96 201.15,158.96 v2(201.28,159.1) ; UG9.BG14 v2(181.5,88.45)
GPU_MDP_P0: length 110
  TOP w0.114: CV26.1 198.33,162.68 198.33,162.43 198.05,162.14 196.9,162.14 v2(196.85,162.1)
  IN1 w0.097: v2(180.85,90.47) 181.03,90.65 181.03,90.83 180.9,90.96 179.69,90.96 178.14,92.51 178.14,97.66 176.32,99.47 176.32,113.51 176.16,113.67 176.16,132.7 176.79,133.33 176.79,140.02 180.69,143.92 195.03,143.92 196.8,145.69 196.8,147.92 197.12,148.23 198.39,148.23 198.76,148.61 198.76,150.92 199.51,151.66 201.63,151.66 202.78,152.81 204.3,152.81 205.18,153.69 205.18,160.65 201.94,163.9 197.7,163.9 197.57,163.77 197.57,162.52 197.33,162.28 197.08,162.28 197.07,162.27 197.02,162.27 v2(196.85,162.1)
  BOTTOM w0.114: v2(180.85,90.47) 181.1,90.72 UG9.BH17
GPU_MDP_P1: length 106.3
  TOP w0.114: v2(199.64,161.61) 199.87,161.83 199.87,162.05 200.15,162.33 200.82,162.33 200.95,162.46 200.95,162.59 200.67,162.86 CV28.1
  IN1 w0.097: v2(181.5,89.75) 181.31,89.94 181.18,89.94 181.05,89.81 181.05,89.69 180.93,89.57 179.3,89.57 177.06,91.81 177.06,98.09 175.92,99.23 175.92,113.14 175.76,113.3 175.76,132.86 176.39,133.5 176.39,140.19 180.56,144.36 194.6,144.36 196.24,145.99 196.24,148.53 197.01,149.31 197.96,149.31 198.2,149.55 198.2,150.96 199.34,152.11 200.83,152.11 202.35,153.63 203.85,153.63 204.75,154.53 204.75,160.51 203.62,161.63 201.18,161.63 200.56,162.26 200.18,162.26 199.93,162.01 199.93,161.9 v2(199.64,161.61)
  BOTTOM w0.114: UG9.BG15 v2(181.5,89.75)
GPU_MDP_P2: length 102
  TOP w0.114: CV32.1 204.43,162.68 204.43,162.34 203.16,161.07 203.16,159.97 203.55,159.58 203.55,158.96 v2(203.68,158.83)
  IN1 w0.097: v2(203.68,158.83) 203.45,158.6 203.45,158.06 203.08,157.69 199.97,157.69 199.09,156.81 199.09,153.13 197.75,151.79 196.89,151.79 195.79,150.69 195.79,149.87 192.49,146.56 192.49,146.06 191.39,144.96 180.31,144.96 175.79,140.44 175.79,133.75 175.16,133.11 175.16,112.75 175.27,112.64 175.27,98.58 175.73,98.12 175.73,94 176.35,93.37 176.35,91.67 178.96,89.06 182.89,89.06 v2(183.5,88.45)
  BOTTOM w0.114: UG9.BE14 v2(183.5,88.45)
GPU_MDP_P3: length 97.7
  IN1 w0.097: v2(180.85,88.37) 181.04,88.37 181.3,88.11 181.3,87.97 180.8,87.47 179.27,87.47 175.72,91.02 175.72,92.99 175.08,93.62 175.08,96.16 174.64,96.61 174.64,112.06 174.56,112.15 174.56,133.55 175.15,134.14 175.15,141.48 179.3,145.63 188.74,145.63 190.83,147.73 191.81,147.73 195.48,151.39 195.48,152.98 196.13,153.63 197.84,153.63 198.45,154.24 198.45,157.03 200.32,158.9 200.95,158.9 201.28,158.56 v2(201.28,158.52)
  BOTTOM w0.114: v2(180.85,88.37) 180.85,88.5 UG9.BH14 ; CV29.1 200.55,159.79 200.55,158.98 200.83,158.7 201.1,158.7 v2(201.28,158.52)
GPU_OVERT#: length 217.9
  TOP w0.089: UG23.6 187.96,82.11 187.08,81.23 v2(186.86,81.23)
  TOP w0.114: QG502.3 v2(187.23,62.33) 187.02,62.12 187.02,60.6 186.6,60.18 186.6,59.61 186.45,59.46 185.82,59.46 DG3.1 185.44,59.01 185.75,58.7 187.38,58.7 RG505.2 ; v2(71.96,7.05) v1(71.43,6.52) 70.95,6.52 70.79,6.68 UE6.21
  IN1 w0.097: v2(187.23,62.33) 187.93,63.03 187.93,67.68 189.05,68.81 189.05,71.11 v2(188.37,71.79)
  IN2 w0.089: 190.9,78.19 190.9,78.83 189.14,80.59 188.86,80.59 188.23,81.23 v2(186.86,81.23)
  IN2 w0.097: v2(188.37,71.79) 188.37,71.74 189.17,70.94 190.38,70.94 190.9,71.46 190.9,78.19
  IN3 w0.124: v2(146.51,66.89) 147.78,66.89 147.97,67.08 157.97,67.08 159.56,65.49 165.55,65.49 172.36,72.31 180.18,72.31 183.47,75.59 184.93,75.59 185.82,74.7 185.82,72.35 186.37,71.79 v2(188.37,71.79)
  IN4 w0.137: v2(146.51,66.89) 143.31,63.69 138.61,63.69 130.87,55.95 130.87,42.55 129.45,41.13 129.45,32.5 128.54,31.58 128.54,28.79 128.17,28.42 128.17,27.09 126.06,24.98 122.67,24.98 117.22,19.54 114.17,19.54 109.29,24.41 102.31,24.41 101.98,24.74 99.44,24.74 98.12,26.06 93.55,26.06 93.04,26.57 91.77,26.57 89.66,24.45 89.66,24.07 90.57,23.16 90.57,21.66 89.41,20.5 89.41,19.83 87.83,18.26 87.83,16.79 89.61,15.02 89.61,14.29 88.97,13.65 88.97,11.3 86.62,8.95 81.39,8.95 79.49,7.05 v2(71.96,7.05)
GPU_PEX_RST_HOLD#: length 32.7
  IN2 w0.089: 176.8,78.19 181.81,78.19 182.58,78.95 182.58,80.33 v2(182.17,80.74)
  IN2 w0.097: v2(179.72,61.11) 179.53,61.11 178.64,62 178.64,63.26 175.16,66.75 175.16,77.73 175.62,78.19 176.8,78.19
  BOTTOM w0.109: UG9.BG3 181.86,81.05 v2(182.17,80.74)
  BOTTOM w0.114: RG14.1 178.49,61.71 v1(178.49,60.93) 178.49,60.91 178.61,60.78 179.45,60.78 179.72,61.05 v2(179.72,61.11) 179.78,61.11 180.02,60.87 DG1.3
GPU_PWR_EN: length 9.8
  TOP w0.254: 93.61,64.67 v1(94.31,63.97) 94.95,63.97 95.5,64.53 UG26.1 ; 93.61,64.67 UG25.2 ; 93.61,64.67 92.98,64.03 92.85,64.03 ; UG28.1 89.92,64.87 90.14,65.1 91.42,65.1 92.49,64.03 92.85,64.03 ; 92.85,64.03 92.62,63.8 92.62,63.59 RG552.2 RG551.2
GPU_TX0N: length 35.5
  BOTTOM w0.114: UG9.BM17 177.73,90.85 177.61,90.97 174.8,90.97 173.96,90.13 173.74,90.13 173.74,90.13 v4(166.8,90.13) 165.75,90.13 162.02,93.86 157.32,93.86 151.64,99.55 151.64,102.69 152.1,103.15 152.6,103.15 152.73,103.28 CV417.2
GPU_TX0N_C: length 2.6
  BOTTOM w0.114: UV21.2 155.03,104.04 154.92,103.93 154.66,103.93 153.81,103.08 153.6,103.08 CV417.1
GPU_TX0P: length 35.5
  BOTTOM w0.114: UG9.BM18 178.5,91.55 178.56,91.5 178.56,91.32 178.41,91.17 178.17,91.17 178.11,91.12 177.84,91.12 177.72,91.24 174.69,91.24 173.85,90.4 v4(168.31,90.4) 165.86,90.4 162.13,94.13 157.43,94.13 151.91,99.66 151.91,102.58 152.21,102.88 152.64,102.88 CV416.2
GPU_TX0P_C: length 2.6
  BOTTOM w0.114: CV416.1 153.52,102.82 153.92,102.82 v4(154.38,103.28) 154.77,103.66 155.04,103.66 155.07,103.64 UV21.1
GPU_TX1N: length 40.5
  BOTTOM w0.114: CV419.2 152.03,104.61 150.78,103.35 150.78,99.19 156.96,93 161.61,93 165.43,89.18 v4(171.19,89.18) 174.23,89.18 175.16,90.11 176.46,90.11 176.61,90.26 178.63,90.26 178.89,90.48 179.33,90.48 UG9.BK17
GPU_TX1N_C: length 2.6
  BOTTOM w0.114: CV419.1 153.58,104.43 153.76,104.43 v4(154.25,104.92) 154.51,105.18 154.95,105.18 155.01,105.24 UV21.5
GPU_TX1P: length 40.4
  BOTTOM w0.114: UG9.BL17 179.03,90.82 179.24,90.82 179.37,90.94 179.37,91.11 179.26,91.23 178.77,91.23 178.64,91.1 178.64,90.65 178.51,90.52 176.5,90.52 176.35,90.37 175.04,90.37 174.12,89.45 v4(169.79,89.45) 165.54,89.45 161.72,93.27 157.07,93.27 151.04,99.3 151.04,103.24 152.14,104.34 152.45,104.34 CV418.2
GPU_TX1P_C: length 2.6
  BOTTOM w0.114: CV418.1 153.6,104.17 153.87,104.17 154.62,104.91 154.97,104.91 155.04,104.84 UV21.4
GPU_TX2N: length 43.3
  BOTTOM w0.114: CV421.2 152.69,105.82 151.4,105.82 149.91,104.33 149.91,98.83 156.6,92.14 159.87,92.14 163.72,88.29 v4(166.56,88.29) 174.56,88.29 175.51,89.24 176.93,89.24 177.47,89.78 178.43,89.78 178.44,89.77 178.45,89.77 178.77,89.45 UG9.BL15
GPU_TX2N_C: length 2.4
  BOTTOM w0.114: CV421.1 153.58,105.76 153.89,105.76 154.03,105.91 154.92,105.91 155.05,106.04 UV21.7
GPU_TX2P: length 43.3
  BOTTOM w0.114: UG9.BK15 179.51,89.45 179.18,89.78 178.83,89.78 178.56,90.05 178.55,90.05 178.55,90.05 177.36,90.05 176.82,89.51 175.4,89.51 174.45,88.56 v4(168.29,88.56) 163.83,88.56 159.98,92.4 156.72,92.4 150.18,98.94 150.18,104.22 151.51,105.55 152.58,105.55 CV420.2
GPU_TX2P_C: length 2.3
  BOTTOM w0.114: UV21.6 154.14,105.64 154,105.5 153.6,105.5 CV420.1
GPU_TX3N: length 45.6
  BOTTOM w0.114: CV423.2 152.09,107.28 151.85,107.03 151.22,107.03 149.05,104.86 149.05,98.47 156.45,91.07 159.61,91.07 163.35,87.32 v4(171.43,87.32) 174.82,87.32 175.87,88.38 177.46,88.38 177.83,88.75 UG9.BM14
GPU_TX3N_C: length 2.4
  BOTTOM w0.114: CV423.1 153.65,107.03 154.45,107.03 154.57,107.16 154.85,107.16 154.93,107.24 UV21.10
GPU_TX3P: length 45.6
  BOTTOM w0.114: UG9.BM15 178.36,89.45 178.51,89.3 178.51,89.16 178.42,89.07 178.17,89.07 178.11,89.02 177.72,89.02 177.34,88.65 175.76,88.65 174.71,87.59 v4(169.94,87.59) 163.46,87.59 159.72,91.34 156.56,91.34 149.32,98.58 149.32,104.75 151.33,106.77 151.96,106.77 152.2,107.01 152.45,107.01 CV422.2
GPU_TX3P_C: length 2.3
  BOTTOM w0.114: UV21.9 154.93,106.84 154.87,106.89 154.68,106.89 154.56,106.77 v4(154.32,106.77) 153.53,106.77 CV422.1
H_CPUPWRGD: length 155.8
  TOP w0.089: CH194.1 101.98,105.83 101.68,106.13 v2(101.68,107.3) ; v2(175.12,55.02) 175.12,55.17
  TOP w0.114: 175.12,55.17 v3(175.12,55.62)
  IN2 w0.097: v2(86.25,56.89) 86.27,56.86 152.05,56.86 154.79,54.13 163.46,54.13 164.56,55.24 174.9,55.24 v2(175.12,55.02)
  IN4 w0.137: v2(86.25,56.89) 86.33,56.89 92.41,62.97 92.41,68.8 99.33,75.73 99.33,85.49 98.68,86.14 98.68,88.63 100.05,89.99 100.05,91.38 100.53,91.86 100.53,101.38 100.63,101.48 100.63,105.16 101.68,106.21 v2(101.68,107.3)
  BOTTOM w0.076: UH1.AM3 175.4,51.54 175.14,51.8 175.14,53.61
  BOTTOM w0.089: 175.14,53.61 175.12,53.63 v2(175.12,55.02)
  BOTTOM w0.114: CPU1.BT31 101.72,107.26 v2(101.68,107.3)
H_DRAMRST#: length 143.9
  TOP w0.114: v2(108.38,30.36) 108.01,29.98 CD92.1 ; v2(104.4,43.51) 105.7,43.51 RD35.2 CD69.1 108.68,42.84 108.79,42.72 108.79,41.1 CD91.1 108.74,40.52 108,39.78 v2(107.74,39.78)
  IN2 w0.089: 160.1,33.93 160.55,33.48 160.55,31.78 160.17,31.4 158.75,31.4
  IN2 w0.097: 158.75,31.4 158.65,31.5 156.01,31.5 152.51,27.99 151.94,27.99 150.26,26.31 147.14,26.31 144.79,23.96 143.27,23.96 142.32,23.01 138.44,23.01 137.73,22.3 118.26,22.3 115.99,20.03 v2(115.61,20.03) ; 160.1,33.93 160.1,36.28 161.43,37.62 166.57,37.62 167.15,37.04 167.84,37.04 168.1,37.3 169.65,37.3 170.42,38.07 171.47,38.07 173.24,39.83 173.24,39.84 173.54,40.14 174.04,40.14 175.01,41.11 175.32,41.11 175.51,41.3 176.52,41.3 177.04,41.81 177.04,42.94 177.26,43.15 177.63,43.15 178.13,43.65 178.64,43.65 179.08,44.09 179.08,45 179.89,45.8 180.6,45.8 181.49,46.69 182.77,46.69 v2(183.52,45.94)
  IN4 w0.137: v2(108.38,30.36) 108.03,30.72 108.03,36.09 108.15,36.21 108.15,39.08 107.74,39.49 v2(107.74,39.78) ; v2(115.61,20.03) 115.48,20.03 115.18,20.33 113.99,20.33 111.69,22.64 111.69,23.82 110.22,25.3 104.03,25.3 103.58,25.74 103.58,42.89 104.21,43.51 v2(104.4,43.51)
  BOTTOM w0.089: v2(183.52,45.94) 183.14,45.56 182.25,45.56 182.03,45.78 181.83,45.78 181.51,46.1 181.04,46.1 180.8,46.33 UH1.BC14
  BOTTOM w0.114: JDIMM1.108 108.77,40.62 107.94,39.78 v2(107.74,39.78) ; JDIMM2.108 108.78,29.78 108.38,30.17 v2(108.38,30.36)
H_PECI: length 206.2
  TOP w0.114: RE76.2 80.81,10.81 77.75,13.88 77.75,15.74 v3(76.94,16.54) 76.78,16.7 76.78,24.22 78.34,25.78 v2(78.34,26.5)
  IN2 w0.097: v2(87.67,61.77) 88,61.44 149.09,61.44 149.55,60.99 155.91,60.99 156.84,61.92 165.12,61.92 166.79,60.25 169.91,60.25 170.9,59.27 173.7,59.27 173.83,59.14 v2(173.83,58.57)
  IN4 w0.137: v2(78.34,26.5) 78.25,26.59 78.25,33.45 80.98,36.18 80.98,41.18 82.37,42.58 82.37,56.47 v2(87.67,61.77) 90.95,65.04 90.95,69.22 97.36,75.63 97.36,90.73 99.7,93.07 99.7,102.02 99.95,102.26 99.95,105.44 100.23,105.72 100.23,108.54 v2(101.1,109.42)
  BOTTOM w0.089: v2(101.1,109.42) 101.74,108.78 CPU1.BT34
  BOTTOM w0.114: v2(173.83,58.57) 174.45,57.95 174.45,57.38 RH73.2
H_PECI_R: length 5
  BOTTOM w0.089: 174.44,54.91 174.72,54.64 174.72,52.32 174.65,52.25 174.65,51.94 174.89,51.7 UH1.AL3
  BOTTOM w0.114: 174.44,54.91 v1(174.44,55.31) 174.44,55.96 RH73.1
H_PM_DOWN: length 155.3
  IN2 w0.097: v2(168.42,58.64) 166.12,58.64 164.45,60.31 157.51,60.31 155.9,58.7 153.63,58.7 153.08,59.25 88.6,59.25 87.31,60.54 81.52,60.54 v2(80.95,61.11)
  IN4 w0.137: v2(96.53,108.31) 95.9,107.68 95.9,94.77 93.68,92.54 93.68,82.9 87.58,76.8 87.58,66.45 82.24,61.11 v2(80.95,61.11)
  BOTTOM w0.089: 173.3,55.17 173.3,54.72 173.85,54.18 173.85,52.35 UH1.AH2
  BOTTOM w0.114: 173.3,55.17 173.3,56.37 172.32,57.36 171.3,57.36 171,57.66 169.4,57.66 v2(168.42,58.64) ; v2(96.53,108.31) 96.56,108.28 RH155.1
H_PM_SYNC_R: length 153.1
  IN2 w0.097: v2(169.18,58.64) 168.78,59.05 166.29,59.05 164.62,60.71 157.34,60.71 156.28,59.65 88.9,59.65 87.76,60.79 v2(87.59,60.79)
  IN4 w0.137: v2(101.68,109.45) 101.68,108.8 100.45,107.57 100.45,105.63 100.17,105.35 100.17,101.67 99.96,101.46 99.96,92.71 97.8,90.55 97.8,75.45 91.4,69.05 91.4,64.87 87.59,61.07 v2(87.59,60.79)
  BOTTOM w0.076: v2(101.68,109.45) 102.06,109.07 102.56,109.07 102.58,109.09 103.02,109.09 103.1,109.16 103.68,109.16 103.76,109.25 105.04,109.25 CPU1.BM34 ; UH1.AJ4 173.97,51.34 173.97,52.23 174.02,52.28 174.02,54.32 173.83,54.51
  BOTTOM w0.089: 173.83,54.51 173.56,54.78
  BOTTOM w0.114: v2(169.18,58.64) 169.75,58.08 171.17,58.08 171.47,57.77 172.5,57.77 173.56,56.71 173.56,54.78
H_PROCHOT#: length 186.1
  TOP w0.114: v2(59.33,40.11) 59.33,39.71 PR724.1 ; QE2.1 80.76,23.89 80.17,23.31 RE78.2 79.24,23.31 79.07,23.14 v1(78.83,23.14) v2(78.18,23.14) ; v2(56.53,4.34) 56.28,4.34 55.89,4.73 PQ8.1
  IN1 w0.097: v2(59.33,40.11) 59.34,40.11 59.77,40.54 64.27,40.54 70,34.8 70,26.34 70.5,25.84 70.5,12.09 69.23,10.82 67.13,10.82 60.4,4.09 56.66,4.09 56.53,4.22 v2(56.53,4.34)
  IN2 w0.097: v2(78.18,23.14) 78.18,23.76 74.42,27.52 74.42,35.85 71.49,38.78 60.27,38.78 59.44,39.61 59.44,39.99 59.32,40.11 v2(59.33,40.11)
  IN4 w0.137: v2(78.18,23.14) 78.18,23.76 76.74,25.21 76.74,34.16 78.43,35.85 78.69,36.11 78.69,46.58 79.65,47.54 79.65,47.54 80.28,48.18 80.28,49.74 80.28,57.91 88.46,66.09 88.46,69.1 88.9,69.55 88.9,76.02 95.45,82.57 95.45,92.42 96.85,93.81 96.85,104.25 97.68,105.07 97.68,106.26 v2(98.75,107.33)
  BOTTOM w0.114: RH158.1 99.01,107.59 v2(98.75,107.33) RH165.2
H_THERMTRIP#: length 73.7
  TOP w0.089: RH163.2 137.76,107.17 v2(138.08,107.5)
  IN5 w0.097: v2(138.08,107.5) 138.19,107.39 138.19,96.18 139.46,94.91 142.76,94.91 142.89,94.79 142.89,86.93 146.34,83.48 146.34,76.65 150,72.99 150,68.36 v2(152.22,66.13)
  BOTTOM w0.076: v2(138.08,107.5) 138.41,107.16 CPU1.J31
  BOTTOM w0.114: RH79.2 170.29,56.41 168.61,56.41 167.46,57.56 v1(167.46,58.32) 167.46,58.61 162.04,64.03 160.06,64.03 159.23,64.87 155.09,64.87 153.82,66.13 v2(152.22,66.13)
H_THERMTRIP#_R: length 6.8
  BOTTOM w0.089: 173.05,55.15 173.05,54.55 v1(173.37,54.23) 173.67,53.93 173.67,52.56 173.38,52.26 173.38,51.74 173.5,51.62 UH1.AJ3
  BOTTOM w0.114: 173.05,55.15 173.05,56.11 172.33,56.83 RH79.1
H_VCCST_PWRGD: length 173.6
  TOP w0.089: 143.02,81.15 143.02,87.17 145.17,89.32 145.17,90.93 RH164.2 RH154.1 145.23,92.23 CH193.1
  TOP w0.114: v2(146.51,55.43) 146.42,55.43 144.12,57.73 144.12,77.43 143.02,78.52 143.02,81.15 ; v2(109.83,11.14) 109.83,8.82 111.39,7.26 v3(112.33,7.26) 114.06,7.26 115.46,8.66 115.98,8.66 116.41,8.23 116.41,7.91 116.54,7.79 Q7.3 ; v2(89.42,9.1) 88.41,9.1 88.17,9.34 UE5.123
  IN1 w0.097: v2(145.56,11.84) 140.94,16.45 128.92,16.45 126.59,14.12 114.77,14.12 112.56,11.91 110.61,11.91 v2(109.83,11.14) 109.77,11.07 105.74,11.07 105.64,10.97 102.65,10.97 100.55,8.86 96.63,8.86 95.5,9.99 95.5,11.1 94.72,11.88 92.95,11.88 92.34,11.27 92.34,10.31 91.14,9.1 v2(89.42,9.1)
  IN4 w0.137: v2(146.51,55.43) 151.07,55.43 152.54,53.95 152.54,50.7 150.7,48.86 150.7,43.33 150.38,43.01 150.38,33.88 150.64,33.62 151.14,33.11 151.14,14.69 150.7,14.25 146.95,14.25 145.56,12.85 v2(145.56,11.84)
HDA_SPKR: length 198.4
  TOP w0.114: DA1.3 34.83,33.53 v2(34.49,33.2)
  IN2 w0.104: v2(34.49,33.2) 34.49,32.61 31.98,30.1 31.98,26.94 32.2,26.72 32.2,25.56 32.2,25.56 32.2,24.7 32.2,24.7 32.2,20.2 35.68,16.73 35.68,14.68 36.18,14.17 42.17,14.17 44.99,11.35 61.36,11.35 61.84,11.84 66.59,11.84 66.94,11.49 66.94,11.35 67.98,10.31 83.05,10.31 85.48,7.88 87.14,7.88 87.53,7.49 93.4,7.49 94.23,8.32 96.64,8.32 96.86,8.1 103.24,8.1 103.94,7.41 113.69,7.41 116.26,9.99 117.65,9.99 120.89,13.22 124.7,13.22 125.43,12.49 129.52,12.49 130.29,13.26 138.62,13.26 139.42,14.06 143.63,14.06 145.85,16.28 150.24,16.28 151.3,17.33 151.91,17.95 157.98,17.95 160.24,20.22 168.18,20.22 168.86,20.9 177.2,20.9 179.15,22.84 v2(179.88,22.84)
  IN5 w0.089: v2(182.82,39.4) 182.82,39.38 181.82,38.38 181.82,30.02 180.04,28.24
  IN5 w0.097: v2(179.88,22.84) 179.88,23.57 178.78,24.67 178.78,26.07 179.74,27.03 179.74,27.94 180.04,28.24
  BOTTOM w0.089: UH1.BD26 181.55,40.23 181.96,40.23 182.02,40.28 182.39,40.28 182.82,39.85 v2(182.82,39.4)
HDD_DET#: length 7.9
  TOP w0.102: RH513.1 172.6,29.5 172.53,29.57 172.53,32.07 172.79,32.32 v3(172.79,33.96) 172.79,35.76 v2(173.18,36.15)
  BOTTOM w0.089: v2(173.18,36.15) 172.82,35.8 UH1.AG35
HDMI_CTRLCLK: length 85.8
  IN5 w0.104: v2(175.6,86.3) 175.43,86.13 175.09,86.13 174.39,86.84 174.39,93.69 173.28,94.79 173.28,105.1 175.32,107.14 175.32,134.15 175.78,134.61 175.78,139.05 177.35,140.62 177.35,144.21 176.93,144.63 176.93,147.83 173.13,151.63 173.13,156.29 172.35,157.07 172.35,159.24 173.11,160 v2(173.12,160)
  BOTTOM w0.114: v2(175.6,86.3) 175.76,86.15 178.26,86.15 178.81,85.6 179.35,85.6 UG9.BK9 ; QV96.4 171.84,160.18 171.9,160.24 RV648.2 172.88,160.24 173.11,160 v2(173.12,160)
HDMI_CTRLDAT: length 85.7
  IN5 w0.104: v2(168.63,158.88) 170.32,157.19 171.91,157.19 172.9,156.2 172.9,151.53 176.69,147.73 176.69,144.54 177.12,144.11 177.12,140.71 175.55,139.15 175.55,134.71 175.09,134.25 175.09,107.23 173.05,105.19 173.05,94.69 174.15,93.59 174.15,86.74 175,85.9 175.42,85.9 v2(175.6,85.72)
  BOTTOM w0.114: UG9.BL9 178.89,85.36 178.71,85.36 178.16,85.91 175.79,85.91 v2(175.6,85.72) ; QV96.1 v2(168.63,158.88) 168.07,158.88 RV652.2
HDMI_DOWN: length 13.9
  TOP w0.508: LX1.2 LX2.2 LX3.2 LX4.2 LX5.2 LX6.2 LX7.2 LX8.2 178.13,160.8 177.77,160.44 177.77,159.4 v2(178.13,159.03)
  BOTTOM w0.114: v1(178.58,159.98) 178.13,159.54 v2(178.13,159.03)
  BOTTOM w0.508: QX1.1 177.59,158.48 v2(178.13,159.03)
HDMI_HPD_GPU#: length 98.1
  TOP w0.114: v1(193.94,149.01) 193.83,149.12 RX7.2 194,149.95 v2(194.45,149.5) 195.37,150.41 195.37,152.2 195.61,152.44 QV97.3
  IN2 w0.089: 176.8,100.16 179.53,97.43 185.69,97.43 186.7,96.42 186.7,95.38 186.77,95.31 186.77,88.36 185.09,86.68 185.09,84.91 186.01,84 186.01,81.74 v2(186.3,81.45)
  IN2 w0.097: v2(194.45,149.5) 193.69,149.5 192.8,148.61 192.8,146.9 189.69,143.79 180.04,143.79 179.27,143.03 179.27,136.42 175.21,132.36 175.21,113.31 176.16,112.36 176.16,100.8 176.8,100.16
  BOTTOM w0.114: UG9.BA4 v2(186.3,81.45)
HDMI_HPD_PCH: length 151.5
  IN1 w0.089: v2(177.56,32.92) 177.88,32.92 178.07,33.11 178.07,34.89 181.62,38.44 181.62,40.22 181.94,40.54 182.51,40.54 182.7,40.73 182.7,41.3 182.51,41.49 182.15,41.49 181.43,42.22 181.43,43.33 181.69,43.59 181.69,43.97 181.94,44.22 181.94,53.81 181.37,54.38 181.37,55.17
  IN1 w0.097: v2(167.13,155.36) 166.97,155.36 165.43,153.82 165.43,147.83 166.8,146.47 166.8,144.96 172.1,139.66 172.1,130.35 172.81,129.64 172.81,112.98 171.9,112.07 171.9,93.49 167.31,88.9 167.31,78.76 168.55,77.53 168.55,74.22 169.25,73.51 169.25,68.28 178.35,59.17 178.35,58.35 179.15,57.56 179.3,57.56 181.37,55.49 181.37,55.17
  BOTTOM w0.089: UH1.AU41 177.83,32.65 v2(177.56,32.92)
  BOTTOM w0.114: QX3.3 167.58,164.24 UX2.1 167.97,164.05 168.23,163.79 168.23,162.6 167.95,162.32 167.95,161.86 RX8.1 v1(167.12,160.58) 167.12,159.69 167.34,159.47 167.34,158.41 168.61,157.14 168.61,156.04 168.42,155.85 167.91,155.85 167.41,155.36 v2(167.13,155.36)
HDMI_HPLUG: length 20.9
  TOP w0.114: JHDMI.19 187.1,167.42 186.64,166.97 178.24,166.97 175.87,164.6 174.87,164.6 v2(172.95,166.52)
  BOTTOM w0.114: RX6.2 CX2.1 170.44,167.09 v1(172.12,167.09) 172.38,167.09 v2(172.95,166.52)
HP2_D_L1_JK: length 20.1
  TOP w0.114: v3(20.01,32.41) v2(20.01,33)
  TOP w0.254: v2(20.01,33) 18.67,34.35 DA6.3 17.02,34.35 16.4,34.97 16.4,35.4 16.65,35.65 LA12.1 CA50.1
  IN2 w0.254: v2(20.01,33) 16.08,29.06 16.08,27.46 13.62,25 11.95,25 JACK2.1
HP2_D_L_C: length 5.6
  TOP w0.254: v2(18.57,40.05) v3(18.57,38.98) 19.59,37.96 19.59,37.13 19.2,36.75 RA43.1
  BOTTOM w0.254: CA49.2 18.57,41.39 v2(18.57,40.05)
HP2_D_L_R: length 20.2
  TOP w0.114: v2(17.4,37.3) v1(16.82,37.3)
  TOP w0.254: v2(17.4,37.3) LA12.2 17.58,35.84 RA41.2 18.45,36.58 RA43.2 18.29,36.78 19.04,37.53 RA44.1
  IN1 w0.254: v2(16.59,24.09) 16.38,24.3 16.38,26.93 18.24,28.79 18.24,36.46 v2(17.4,37.3)
  BOTTOM w0.254: v2(16.59,24.09) 16.52,24.15 16.52,24.62 RA46.1
HP2_D_R1_JK: length 19.8
  TOP w0.114: v2(14.83,33.07) v3(14.17,33.07)
  TOP w0.254: v2(14.83,33.07) 15.53,32.37 16.49,32.37 16.84,32.73 17.89,32.73 DA6.2 17.87,32.09 17.1,32.09 16.84,31.84 16.84,30.82 LA11.1 16.28,30.75 16.14,30.89 CA48.1
  IN1 w0.254: JACK2.2 6.01,35.35 6.49,35.84 13.49,35.84 14.83,34.5 v2(14.83,33.07)
HP2_D_R_C: length 3.4
  TOP w0.102: v2(20.23,30.02) 20.58,30.02 v1(20.79,29.81)
  TOP w0.254: RA42.1 v2(20.23,30.02)
  BOTTOM w0.254: v2(20.23,30.02) 20.77,30.02 CA47.2
HP2_D_R_R: length 7.7
  TOP w0.114: RA42.2 18.63,29.55 v1(19.45,28.73)
  TOP w0.254: v2(17.73,29.17) 17.73,29.54 RA45.1 17.54,30.25 17.52,30.27 LA11.2 17.69,30.91 RA40.2 18.63,30.89 RA42.2
  BOTTOM w0.254: v2(17.73,29.17) 17.67,29.11 17.67,28.79 16.75,27.88 16.75,27.27 RA47.1
HP_LINE1_JD: length 5.5
  TOP w0.114: v1(30.48,37.73) 30.55,37.67 v2(31.17,37.67) 31.17,37.95 31.47,38.24 RA36.1 RA34.1
  BOTTOM w0.114: RA32.2 RA34.1 31.56,37.66 31.18,37.66 v2(31.17,37.67) 31.08,37.58 UA1.9
HP_MUTE#: length 54.1
  TOP w0.254: UA3.B1 16.02,28.23 15.46,28.79 v2(13.73,28.79) ; v2(34.37,43.9) v1(36.48,43.9) 37.33,43.05 DA2.1 37.28,41.68 36.78,41.19 RA13.2
  IN1 w0.254: v2(13.73,28.79) 15.19,28.79 15.63,29.23 15.63,42.61 17.11,44.09 19.57,44.09 22.11,46.63 25.22,46.63 26.05,45.81 28.46,45.81 30.37,43.9 v2(34.37,43.9)
  BOTTOM w0.254: UA2.B1 15.99,24.7 15.51,24.22 14.69,24.22 13.73,25.18 v2(13.73,28.79)
HPOUT-L: length 24.7
  TOP w0.254: RA35.1 v2(18.27,15.94)
  IN1 w0.254: v2(19.57,29.38) 19.57,29.37 19.02,28.82 19.02,19.54 18.27,18.79 v2(18.27,15.94)
  IN4 w0.254: v2(21.91,36.44) 22.81,35.54 22.81,34.21 22,33.41 22,32.96 19.57,30.52 v2(19.57,29.38)
  BOTTOM w0.203: UA1.32 22.46,36.78 22.44,36.77 22.24,36.77 v2(21.91,36.44)
HPOUT-R: length 22.4
  TOP w0.254: v2(17.77,23.47) 18.07,23.77 v1(18.32,23.77) 18.71,23.38 RA37.1
  IN4 w0.254: v2(17.77,23.47) 19,24.7 19,28.04 19.96,29 21.16,29 22.05,29.89 22.05,31.08 23.59,32.63 23.59,34.91 23.4,35.1 23.4,35.93 22.39,36.94 21.6,36.94 21.28,36.62 v2(21.28,36.49)
  BOTTOM w0.203: UA1.33 22.67,37.18 22.62,37.13 22.17,37.13 21.99,36.95 21.74,36.95 v2(21.28,36.49)
HPOUT_JD: length 35.4
  TOP w0.114: RA34.2 32.81,37.35 33.52,36.64 33.69,36.64 33.87,36.46 v2(34.26,36.46)
  IN2 w0.254: JACK1.6 8.74,23.23 9.31,23.79 13.17,23.79 16.96,27.59 17.48,27.59 17.6,27.71 17.6,27.84 18.01,28.24 19.2,28.24 19.95,29 20.97,29 21.54,29.57 21.54,30.7 25.63,34.79 28.65,34.79 29.64,35.78 30.76,35.78 31.09,35.45 31.55,35.45 32.57,36.46 v2(34.26,36.46)
  BOTTOM w0.114: v2(34.26,36.46) v3(34.88,36.46)
I2C0_SCL_EC: length 92
  TOP w0.114: v2(93.83,22.71) 93.87,22.67 UE5.83 ; v2(33.39,20.42) 33.33,20.42 RA56.1 33.36,21.8 33.37,21.8 33.9,22.33 v2(34.27,22.33)
  IN2 w0.097: v2(34.27,22.33) 34.27,22.1 37.7,18.67 43.43,18.67 44.46,17.64 45.57,17.64 49.28,13.93 62.97,13.93 64.71,15.66 70.52,15.66 74.66,19.81 84.7,19.81 86.59,21.7 92.82,21.7 v2(93.83,22.71)
  IN4 w0.137: v2(33.39,20.42) 31.74,22.07 30.39,22.07 29.68,22.78 29.68,24.32 31.59,26.23 31.59,28.08 31.39,28.27 31.39,35.89 v2(31.35,35.93)
  BOTTOM w0.114: UA1.12 30.61,36.38 30.94,36.05 31.24,36.05 v2(31.35,35.93) ; v2(93.83,22.71) v1(93.19,22.71)
