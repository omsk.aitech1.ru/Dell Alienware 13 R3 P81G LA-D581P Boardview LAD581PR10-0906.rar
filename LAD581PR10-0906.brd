# Allegro board LAD581PR10-0906.brd (continued)
## Nets (continued)
TMDS_CTRLCLK_R: JHDMI.15 RV651.1
TMDS_CTRLDAT_R: JHDMI.16 RV650.1
TMDS_L_TX0N: LV4.2 RV27.1 RV501.2 RV643.2
TMDS_L_TX0P: LV4.3 RV28.1 RV501.1 RV646.2
TMDS_L_TX1N: LV5.2 RV29.1 RV502.2 RV642.2
TMDS_L_TX1P: LV5.3 RV30.1 RV502.1 RV639.2
TMDS_L_TX2N: LV6.2 RV33.1 RV503.2 RV645.2
TMDS_L_TX2P: LV6.3 RV34.1 RV503.1 RV638.2
TMDS_L_TXCN: LV3.2 RV500.2 RV641.2 RV673.1
TMDS_L_TXCP: LV3.3 RV500.1 RV640.2 RV674.1
TMDS_R_TX0N: JHDMI.9 RV27.2
TMDS_R_TX0P: JHDMI.7 RV28.2
TMDS_R_TX1N: JHDMI.6 RV29.2
TMDS_R_TX1P: JHDMI.4 RV30.2
TMDS_R_TX2N: JHDMI.3 RV33.2
TMDS_R_TX2P: JHDMI.1 RV34.2
TMDS_R_TXCN: JHDMI.12 RV673.2
TMDS_R_TXCP: JHDMI.10 RV674.2
TMDS_SCLF: QV96.3 RV649.1 RV651.2
TMDS_SDAF: QV96.6 RV650.2 RV653.1
TMDS_TX0N: CV1060.2 UG9.BF18
TMDS_TX0P: CV1059.2 UG9.BG18
TMDS_TX1N: CV1062.2 UG9.BG20
TMDS_TX1P: CV1061.2 UG9.BH20
TMDS_TX2N: CV1064.2 UG9.BF20
TMDS_TX2P: CV1063.2 UG9.BE20
TMDS_TXCN: CV1057.2 UG9.BF17
TMDS_TXCP: CV1058.2 UG9.BE17
TON_1.2V: PR206.2 PU201.9
TP_CLK: JTP.12 RE100.2 UE5.87
TP_DATA: JTP.13 RE101.2 UE5.88
TP_LED_B#: Q28.5 R146.2 UE3.14
TP_LED_B#_DRV: Q28.2 Q28.3 R144.2
TP_LED_B#_DRV#: JTP.3 Q28.6
TP_LED_EN: Q2410.2 UE5.25
TP_LED_G#: Q29.5 R154.2 UE3.11
TP_LED_G#_DRV: Q29.2 Q29.3 R150.2
TP_LED_G#_DRV#: JTP.4 Q29.6
TP_LED_R#: Q34.5 R147.2 UE3.10
TP_LED_R#_DRV: Q34.2 Q34.3 R145.2
TP_LED_R#_DRV#: JTP.5 Q34.6
TRIP_+1VALWP: PR303.2 PU300.2
TS_EN: JEDP.34 UE6.14
TYPEC_DET#: QU1.1 RU26.2 UE10.18
UART_2_CCTS_DRTS: RC65.1 UH1.AN44
UART_2_CRXD_DTXD: JWDB.3 RC62.1 UH1.AR45
UART_2_CTXD_DRXD: JWDB.2 RC63.1 UH1.AR39
UG_3V: PQ100.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1VALWP: PQ300.4 PU300.9
USB2_COMP: RH109.1 UH1.AG3
USB3_A_TRX_DTX_N0: DT5.1 JUSBC1.B10 UT1.A21
USB3_A_TRX_DTX_N1: DT9.1 JUSBC1.A10 UT1.B15
USB3_A_TRX_DTX_P0: DT4.1 JUSBC1.B11 UT1.B21
USB3_A_TRX_DTX_P1: DT8.1 JUSBC1.A11 UT1.A15
USB3_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC1.A3
USB3_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC1.B3
USB3_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC1.A2
USB3_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC1.B2
USB3_A_TTX_DRX_N0: CT42.2 UT1.B19
USB3_A_TTX_DRX_N1: CT40.2 UT1.B17
USB3_A_TTX_DRX_P0: CT41.2 UT1.A19
USB3_A_TTX_DRX_P1: CT39.2 UT1.A17
USB3_CC1: DU20.2 JUSBC2.A5 UU7.11
USB3_CC2: DU20.3 JUSBC2.B5 UU7.13
USB3_CRX_L_DTX_N1: DU2.1 DU2.9 JUSB1.5 LU5.2
USB3_CRX_L_DTX_N2: DU12.4 DU12.7 JUSBC2.B10 LU8.2
USB3_CRX_L_DTX_N4: DU5.1 DU5.9 JUSB2.5 LU2.2
USB3_CRX_L_DTX_N5: DU13.1 DU13.9 JUSBC2.A10 LU11.3
USB3_CRX_L_DTX_P1: DU2.2 DU2.8 JUSB1.6 LU5.3
USB3_CRX_L_DTX_P2: DU12.5 DU12.6 JUSBC2.B11 LU8.3
USB3_CRX_L_DTX_P4: DU5.2 DU5.8 JUSB2.6 LU2.3
USB3_CRX_L_DTX_P5: DU13.2 DU13.8 JUSBC2.A11 LU11.2
USB3_CTX_C_DRX_N1: CU13.1 LU4.1
USB3_CTX_C_DRX_N2: CU30.1 LU7.1
USB3_CTX_C_DRX_N4: CU5.1 LU1.1
USB3_CTX_C_DRX_N5: CU38.1 LU10.4
USB3_CTX_C_DRX_P1: CU12.1 LU4.4
USB3_CTX_C_DRX_P2: CU31.1 LU7.4
USB3_CTX_C_DRX_P4: CU4.1 LU1.4
USB3_CTX_C_DRX_P5: CU39.1 LU10.1
USB3_CTX_C_L_DRX_N1: DU2.4 DU2.7 JUSB1.8 LU4.2
USB3_CTX_C_L_DRX_N2: DU12.1 DU12.9 JUSBC2.A3 LU7.2
USB3_CTX_C_L_DRX_N4: DU5.4 DU5.7 JUSB2.8 LU1.2
USB3_CTX_C_L_DRX_N5: DU13.4 DU13.7 JUSBC2.B3 LU10.3
USB3_CTX_C_L_DRX_P1: DU2.5 DU2.6 JUSB1.9 LU4.3
USB3_CTX_C_L_DRX_P2: DU12.2 DU12.8 JUSBC2.A2 LU7.3
USB3_CTX_C_L_DRX_P4: DU5.5 DU5.6 JUSB2.9 LU1.3
USB3_CTX_C_L_DRX_P5: DU13.5 DU13.6 JUSBC2.B2 LU10.2
USB3_RUF1: DU21.2 JUSBC2.A8
USB3_RUF2: DU21.3 JUSBC2.B8
USB3RN1: LU5.1 UH1.B7
USB3RN2: LU8.1 UH1.C8
USB3RN3: CI38.1 UH1.B10
USB3RN3_C: CI38.2 JCDRA.36
USB3RN4: LU2.1 UH1.E11
USB3RN5: LU11.4 UH1.G13
USB3RP1: LU5.4 UH1.A7
USB3RP2: LU8.4 UH1.B8
USB3RP3: CI39.1 UH1.A9
USB3RP3_C: CI39.2 JCDRA.37
USB3RP4: LU2.4 UH1.G11
USB3RP5: LU11.1 UH1.H13
USB3TN1: CU13.2 UH1.C11
USB3TN2: CU30.2 UH1.B12
USB3TN3: JCDRA.42 UH1.C13
USB3TN4: CU5.2 UH1.A14
USB3TN5: CU38.2 UH1.B14
USB3TP1: CU12.2 UH1.B11
USB3TP2: CU31.2 UH1.A12
USB3TP3: JCDRA.43 UH1.D13
USB3TP4: CU4.2 UH1.B13
USB3TP5: CU39.2 UH1.C14
USB20_CAM_N7_R: DV4.3 JEDP.19 LV2.3
USB20_CAM_P7_R: DV4.2 JEDP.20 LV2.2
USB20_N1: UH1.AF5 UU1.2
USB20_N1_CONN: DU1.3 JUSB1.2 LU3.2
USB20_N2: LU6.4 UH1.AD5
USB20_N2_CONN: DU4.3 JUSB2.2 LU6.3
USB20_N3: LM1.1 UH1.AG8
USB20_N3_CONN: JCDRA.40 LM1.2
USB20_N4: UE1.5 UH1.AE1
USB20_N5: JWLAN.5 UH1.AC2
USB20_N6: DV2.3 JEDP.17 UH1.AF2
USB20_N7: LV2.4 UH1.AB3
USB20_N8: LU9.4 UH1.AL8
USB20_N8_CONN: DU11.3 JUSBC2.A7 JUSBC2.B7 LU9.3
USB20_P1: UH1.AG7 UU1.3
USB20_P1_CONN: DU1.2 JUSB1.3 LU3.3
USB20_P2: LU6.1 UH1.AD7
USB20_P2_CONN: DU4.2 JUSB2.3 LU6.2
USB20_P3: LM1.4 UH1.AG10
USB20_P3_CONN: JCDRA.39 LM1.3
USB20_P4: UE1.4 UH1.AE2
USB20_P5: JWLAN.3 UH1.AC3
USB20_P6: DV2.2 JEDP.18 UH1.AF3
USB20_P7: LV2.1 UH1.AB2
USB20_P8: LU9.1 UH1.AL7
USB20_P8_CONN: DU11.2 JUSBC2.A6 JUSBC2.B6 LU9.2
USB_OC0#: RPH6.4 UH1.AD43 UU1.13
USB_OC1#: CU17.1 RPH6.3 UH1.AD42 UU3.3
USB_OC2#: RPH6.1 UH1.AD39
USB_OC3#: RPH6.2 UH1.AC44
USB_PWR_EN: CU16.1 RE645.2 UE5.117 UU3.4
USBC_PWR_EN: CU35.1 RE647.2 UE10.5 UU7.6
USBCHG_DET#: CU27.2 CU28.1 DU9.2 JUSB1.10 RU4.2
USBCHG_DET_D: PD100.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU9.1 RU6.2 UE5.75
VCIN0_PH1: PH1.1 PR24.1 PR25.1 UE5.109
VCIN1_AC_IN: CE40.2 DH1.1 PR714.2 PR715.1 PR731.1 PU700.5 QE3.5 UE5.110
VCIN1_AC_IN#: QE3.3 RE17.2 UE1.24
VCIN1_ADP_PROCHOT: PC13.2 PR23.1 PR26.2 UE5.102
VCIN_ BATT_TEMP: CE35.2 PC14.1 PD3.2 PR16.1 PR22.2 PR727.2 UE5.63
VCOUT0_MAIN_PWR_ON#: PR114.1 UE5.104
VCOUT1_PROCHOT#: RE84.2 RE85.2 UE5.103
VD33STB: RA25.1 UA1.10
VGA_EN: RM14.2 RM87.1 UM8.26
VGA_SMB_CK2: QG6.4 RG17.1 UG9.BJ8
VGA_SMB_DA2: QG6.1 RG18.1 UG9.BH8
VL: PC111.1 PU100.13
VR_HOT#: PC501.1 PR504.1 RE78.1
VR_PWRGD: PR520.2 UE5.101
VR_SVID_ALERT#: PR509.2 RH152.2 RH153.1
VR_SVID_CLK: CPU1.BH32 PR507.2
VR_SVID_DATA: CPU1.BH29 PR511.2 RH151.2
VROM_SEL: UG16.7 UG16.10 UH1.BC27
VSB_N_001: PC10.2 PQ3.3 PR12.2 PR13.2
VSB_N_002: PC12.1 PQ4.2 PR17.1
VSB_N_003: PQ4.1 PR13.1
VSENSEN_L: RA61.2 RA79.2 UA4.27
VSENSEN_R: RA65.2 RA82.2 UA4.30
VTTREF_1.2V: PC210.1 PU201.4
WAKE#: RH4.2 RH453.1 UH1.BC13
WAKE_PCH#: RH545.1 UH1.BD11
WL_OFF#: RN15.2 UH1.AU44
WL_OFF#_R: CN9.1 JWLAN.48 RN5.2 RN15.1
XDP_BPM#0: CPU1.BR27 T112.1(TP-1)
XDP_BPM#1: CPU1.BT27 T113.1(TP-1)
XDP_HOOK0: JPCMC.27 RC355.1
XDP_ITP_PMODE: JPCMC.26 RC353.2 UH1.AT2
XDP_PRDY#: CPU1.BP27 JPCMC.34 UH1.AT4
XDP_PREQ#: CPU1.BL30 JPCMC.33 RH156.2 UH1.AT3
XDP_SPI_IO2: JPCMC.24 RC354.1
XDP_SPI_SI: JPCMC.25 RC9.2 RH1.1
XDP_TCK: JPCMC.31 RC348.1 UH1.AN3
XDP_TDI: CPU1.BL32 JPCMC.29 RH495.2 UH1.AP2
XDP_TDO: CPU1.BT28 JPCMC.35 RH496.2 UH1.AP1
XDP_TMS: CPU1.BP28 JPCMC.30 RH494.2 UH1.AR2
XMP1: PR212.1 UH1.BD22
XMP2: PR214.1 UH1.BE21
XTAL24_IN: CH47.1 RH72.1 UH1.A6 YH2.1
XTAL24_OUT: CH48.1 RH72.2 UH1.A5 YH2.3
XTALIN: CG75.2 RG99.1 UG9.BL6 YG1.1
XTALOUT: CG76.2 RG99.2 UG9.BM6 YG1.3
XTALOUTBUFF_R: RG98.1 UG9.BK6
XTLI: CL8.2 UL1.8 YL1.1
XTLO: CL9.2 UL1.7 YL1.3
N150549: CA258.1 RA84.1 RA85.1 UA2.B2
N150553: CA51.1 UA2.B3
N150559: RA46.2 UA2.A1
N150561: RA47.2 UA2.A3
N150671: RA39.2 UA3.A3
N150673: RA38.2 UA3.A1
N150681: CA44.1 UA3.B3
N150741: CA18.1 RA10.2
N150745: CA11.1 RA2.2
N150841: CA21.1 UA1.27
N150843: CA21.2 UA1.28
N150847: CA20.1 UA1.25
N150849: CA20.2 UA1.26
N150875: CA23.1 CA85.1 UA1.18
N150935: RA18.2 UA1.16
N150987: CA3.1 CA4.1 RA68.1 UA1.46
N151025: CA7.1 CA8.1 RA69.1 UA1.51
N151065: CA26.1 CA27.1 UA1.43
N151071: CA33.1 UA1.41
N151073: CA30.1 CA31.1 UA1.21
N151093: CA32.1 UA1.44
N151121: CA25.1 UA1.29
N151137: CA24.1 UA1.31
N151149: CA19.2 UA1.23
N151153: CA19.1 RA15.2 RA16.1
N155467: CA74.1 UA4.23
N155515: CA66.2 UA4.40
N155527: CA71.2 RA51.2 UA4.3
N155529: RA51.1 RA52.2 UA4.6
N155531: CA67.2 UA4.2
N155533: CA68.2 UA4.50
N155535: CA69.2 UA4.49
N155537: CA70.2 UA4.41
N155541: RA62.2 UA4.5
N155763: CA87.2 RA73.1
N155773: CA88.2 RA74.1
N155779: CA89.2 RA75.1
N155789: CA90.2 RA76.1
N3691692: PC305.1 PR302.2
N3691782: PC309.1 PR305.2
N4123408: PC105.2 PR108.1
N4123550: PC109.1 PR110.2
N4123582: PC110.1 PR111.2
N4124695: PC106.1 PR109.2
N16760382: PC6209.1 PC6210.1 PR6211.2 PR6214.2 PU6200.11
N16761462: PC6212.1 PR6215.1 PR6217.1 PU6200.7
N16767833: PC112.1 PR100.2 PR112.2 PR113.2 PR114.2 PR115.2 PR116.1
N16767857: PD101.1 PR115.1
N16768121: PD100.1 PR113.1
N16788038: PC701.2 PC722.2 PC723.2 PQ700.1 PQ702.4 PR705.1 PR725.2 PR726.2
N16788064: PQ700.2 PR700.2 PR701.1
N16910514: PC6215.1 PR6215.2 PR6216.2 PR6224.2
N16952535: RU14.2 UU7.10
N17186119: PC6213.2 PR6219.2 PU6200.10
N17186139: PR6213.1 PU6200.9
N17228387: PC6211.1 PC6213.1 PR6214.1 PR6220.2
N17230071: PC6207.2 PR6203.2
N17235867: PR6208.2 PU6200.5
N17244731: PD1.2 PL2.1 PQ7.1 PR6.2
N17244796: PR6217.2 PR6222.2
N17249236: PC6211.2 PR6211.1
N17320532: QV97.5 UX2.4
N17320539: QX3.2 RX6.1
N17377398: RM21.2 RM96.2 UM4.1
N17431129: CE36.1 RE89.1
N17434554: RE74.2 UE5.107
N17695382: JHDMI.13 RV655.2
N17847188: PC800.2 PJ800.2 PU800.2 PU800.3 PU800.4 PU800.5
N17847698: PC803.1 PU800.16 PU800.17
N17848365: PR812.1 PR813.2 PU800.13
N17848703: PC808.1 PR806.2
N17848716: PR806.1 PU800.1
N18016661: RE25.2 UE3.24
N18017204: RE31.1 UE3.30
N18168284: PC207.2 PR204.2 PU201.12
N18232316: RH580.1 UH1.AD10
N18232318: RH581.1 UH1.AG2
N18236403: RH89.2 UH1.BC17
N18241196: RH531.1 UH1.BE11
N18242976: RH71.2 UH1.E1
N18246388: CH70.1 UH1.BA26
N18249914: CH4.1 RH6.2 UH1.V28
N18250394: CH3.1 RH7.2 UH1.BA15
N18401963: CV438.1 UV21.47
N18401967: RV24.1 UV21.34
N18456729: PR722.1 PU700.20
N18456733: PR723.1 PU700.19
N18456739: PQ705.3 PR709.1 PR711.1 PU700.21
N18456772: PC711.2 PR707.2 PU700.28
N18456789: PD700.1 PR707.1
N18456799: PR724.2 PU700.10
N18456859: PC702.2 PR708.1
N18456884: PC718.2 PR717.1 PU700.7
N18456888: PC720.2 PU700.8
N18456944: PQ705.1 PR710.2
N18456952: PR720.1 PU700.11
N18456954: PR721.1 PU700.12
N18498179: RU15.1 UU7.1
N18498181: RU16.1 UU7.20
N18498183: RU17.1 UU7.16
N18498185: RU20.1 UU7.19
N18498187: RU19.1 UU7.18
N18498189: RU18.1 UU7.17
N18650921: RV634.2 UV21.59
N18651247: RV635.2 UV21.58
N18781336: CV374.1 RV13.2
N18809163: CPU1.BT2 T44.1(TP-1)
N18809164: CPU1.BR1 T43.1(TP-1)
N18809165: CPU1.E3 T41.1(TP-1)
N18809166: CPU1.BJ33 T82.1(TP-1)
N18809168: CPU1.B2 T85.1(TP-1)
N18809169: CPU1.BR2 T88.1(TP-1)
N18809170: CPU1.BJ34 T81.1(TP-1)
N18809172: CPU1.C1 T89.1(TP-1)
N18809173: CPU1.BJ16 T73.1(TP-1)
N18809174: CPU1.BK16 T74.1(TP-1)
N18809175: CPU1.BK24 T75.1(TP-1)
N18809176: CPU1.BJ24 T76.1(TP-1)
N18809177: CPU1.BM33 T66.1(TP-1)
N18809178: CPU1.BJ14 T68.1(TP-1)
N18809179: CPU1.BJ13 T69.1(TP-1)
N18809180: CPU1.BL33 T67.1(TP-1)
N18809182: CPU1.J23 RH192.2
N18809184: CPU1.H23 RH167.2
N19473413: PC1305.2 PR1304.2 PR1305.1 PU1300.7
N19473595: PR1300.2 PU1300.1
N19477426: RU14.1 UU7.9
N19477490: RU21.2 UU7.7
N19496810: PC810.2 PC814.2 PJP802.2 PU802.8 PU802.9 PU802.10
N19497031: PC806.1 PR809.2
N19534507: PC6119.2 PR6122.2 PU6100.10
N19534529: PC6107.2 PR6104.2
N19534538: PC6108.2 PR6105.2
N19534760: PR6120.2 PR6125.2
N19535281: PC6118.1 PR6118.1 PR6120.1 PU6100.7
N19535283: PC6121.1 PR6118.2 PR6119.2 PR6127.2
N19535308: PR6110.2 PU6100.5
N19535327: PC6109.1 PC6110.1 PR6113.2 PR6115.2 PU6100.11
N19535343: PC6117.1 PC6119.1 PR6115.1 PR6123.2
N19535360: PC6117.2 PR6113.1
N19535469: PR6117.1 PU6100.9
N19535500: PC6110.2 PR6112.1
N19616464: CG230.1 CG231.1 CG232.1 LG4.2 UG9.BC12
N19616930: CG233.1 CG234.1 CG235.1 CG236.1 CG237.1 CG238.1 CG239.1 LG3.2 UG9.AF11 UG9.BB24 UG9.BD12 UG9.U42
N19618056: RG101.1 UG9.BJ6
N19795707: RG7.1 RG537.1 RG562.1 UG10.4
N19799736: RG19.1 UG9.BG8
N19799738: RG20.1 UG9.BF8
N19842722: RG130.1 UG5.J13
N19842724: RG126.1 UG5.J1
N19842731: RG128.1 UG5.J10
N19847413: RG120.1 UG4.J13
N19847417: RG116.1 UG4.J1
N19847426: RG118.1 UG4.J10
N19848462: QG3.1 RG122.1
N19849394: RG119.1 UG3.J13
N19849396: RG115.1 UG3.J1
N19849403: RG117.1 UG3.J10
N19854250: RG109.1 UG2.J13
N19854254: RG105.1 UG2.J1
N19854263: RG107.1 UG2.J10
N19855299: QG2.1 RG111.1
N19856231: RG108.1 UG1.J13
N19856233: RG104.1 UG1.J1
N19856240: RG106.1 UG1.J10
N20118187: RU23.2 UU7.8
N20539566: RG26.1 UG9.BK23
N20881316: PR5033.1 PR5034.2 PU509.13
N20881504: PR5012.1 PR5014.2 PR5017.1
N20881570: PC807.1 PU509.16 PU509.17
N20881862: PC820.2 PR5012.2 PR5015.1 PU509.14
N20904379: RT22.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
N20905578: CT104.1 UT4.H7
N20905857: RT83.2 UT4.F1
N20960615: QE54.2 RE449.2 RE543.1
N20960628: QE39.5 RE455.2 RE456.1
N20960654: QE29.5 RE396.2 RE397.1
N20960689: QE29.2 RE399.2 RE401.1
N20960760: QE39.2 RE453.1 RE454.2
N20960882: QE49.2 QE49.3 RE543.2
N20960884: QE40.2 RE458.1 RE460.2
N20960892: QE40.5 RE461.2 RE462.1
N20960976: QE41.2 RE465.1 RE467.2
N20960982: QE41.5 RE466.2 RE468.1
N20961145: QE42.2 RE472.1 RE474.2
N20961166: QE42.5 RE471.2 RE473.1
N20961197: QE43.2 RE479.1 RE480.2
N20961228: QE43.5 RE476.2 RE478.1
N20961418: QE44.2 RE485.1 RE486.2
N20961454: QE44.5 RE482.2 RE484.1
N20961510: QE45.2 RE491.1 RE492.2
N20961531: QE45.5 RE488.2 RE490.1
N20961580: QE46.2 RE496.1 RE498.2
N20961592: QE46.5 RE495.2 RE497.1
N20961740: QE47.2 RE501.1 RE503.2
N20961750: QE47.5 RE502.2 RE504.1
N20961813: QE48.2 RE508.1 RE510.2
N20961825: QE48.5 RE507.2 RE509.1
N21146007: PC6125.2 PR6129.2
N21146153: PC6126.2 PR6130.2
N21146805: PC6218.2 PR6226.2
N21148887: PR591.2 PU510.1
N21148889: PR594.2 PU510.2
N21287548: PR820.2 PU802.4
N21374779: PC8222.1 PQ8202.2 PR8214.2
N21374792: PC8216.1 PR8208.2 PR8211.1 PR8215.2 PU8200.7
N21374806: PQ8202.3 PR8215.1
N22226841: QV97.2 UX1.4
N22279740: DV13.1 RV653.2
N22279742: DV12.1 RV649.2
N22280311: QE49.5 RE512.1 RE513.2
N22281033: QE50.5 RE531.2 RE532.1
N22281062: QE54.5 RE533.2 RE544.1
N22281110: QE50.2 QE50.3 RE544.2
N22281666: QE51.5 RE534.2 RE535.1
N22281686: QE55.2 RE539.2 RE545.1
N22281703: QE52.5 RE536.2 RE537.1
N22281752: QE55.5 RE538.2 RE546.1
N22281797: QE52.2 QE52.3 RE546.2
N22281839: QE51.2 QE51.3 RE545.2
N22282133: QE53.5 RE540.2 RE541.1
N22282153: QE56.2 RE542.2 RE547.1
N22282201: QE53.2 QE53.3 RE547.2
N22363411: CE63.2 RE530.2 UE10.3
N22579775: R367.1 U18.3
N24948778: QE13.6 RE153.2
N24949488: QE21.6 RE155.2
N24950010: QE22.6 RE157.2
N25433867: PC218.1 PQ202.5 PR214.2
N25435297: PQ202.3 PR215.2
N25436981: PR205.1 PR207.1 PR213.1 PR215.1 PU201.6
N25523951: PC217.1 PQ202.2 PR212.2
N25523965: PQ202.6 PR213.2
N26393873: RV672.1 UV3.12
N26393875: RV671.1 UV3.9
N26668634: CG313.1 RG102.2 RG523.2
N26671206: CG314.1 RG103.2 RG524.2
N26672234: CG315.1 RG113.2 RG525.2
N26672631: CG316.1 RG114.2 RG526.2
N26673021: CG317.1 RG124.2 RG527.2
N26673418: CG318.1 RG125.2 RG528.2
N26979734: QG4.1 RG133.1
N26987587: RL2.2 UL1.5
N26987818: QL3.1 RL13.2 RL14.2
N26987825: CL31.1 JLAN.12 LL1.2
N27160639: QV2.1 RV12.2
N27381541: RG529.1 UG11.9
N27381544: QG5.3 RG63.2 RG529.2 UG11.8
N27864293: RE14.2 UE2.3
N27864303: CE20.1 RE11.1 UE2.6
N27864309: RE9.1 UE2.5
N27864330: RE13.2 UE2.7
N27864389: CE8.1 UE1.20
N27864390: CE9.1 UE1.19
N27864395: CE18.1 UE1.11
N27864397: CE17.1 UE1.12
N27864399: CE16.1 UE1.13
N27864402: CE15.1 UE1.14
N27864404: CE14.1 UE1.15
N27864406: CE13.1 UE1.16
N27864434: RE10.1 UE2.2
N27869543: DF1.1 JFAN1.2 RF3.1
N27869598: DF2.1 JFAN2.2 RF6.1
N28776742: RG535.2 UG24.2 UG24.3
N28827302: LX8.1 RX38.2
N28827395: LX7.1 RX37.2
N28827433: LX6.1 RX36.2
N28827473: LX5.1 RX35.2
N28827533: LX4.1 RX34.2
N28827572: LX3.1 RX33.2
N28827613: LX2.1 RX32.2
N28827656: LX1.1 RX31.2
N29018046: QU1.2 RU24.2 RU25.1
N29026996: JLAN.9 RL8.1
N29187218: RV45.1 UV17.3
N29403961: RE32.2 UE4.24
N29403963: RE37.1 UE4.30
N29418337: PC508.2 PR525.1
N29418339: PR522.1 PR525.2 PR531.1 PU500.5
N29418355: PC533.2 PR546.2
N29418359: PR546.1 PR549.1 PR550.2 PU500.17
N29418369: PC514.1 PR532.2
N29418371: PC5011.2 PH504.2 PR545.1 PR547.2
N29418373: PR532.1 PR533.1 PR536.1 PU500.30
N29418377: PR545.2 PU500.15
N29418393: PC5010.2 PH500.2 PR513.2 PR514.1
N29418395: PR514.2 PU500.3
N29418397: PC505.2 PR521.2 PU500.4
N29418405: PR527.1 PU500.36
N29418417: PC509.2 PR524.1 PU500.33
N29418423: PC520.2 PR537.1 PU500.29
N29418425: PC519.1 PR539.1 PU500.28
N29418433: PR515.2 PR520.1 PU500.47
N29418441: PR518.1 PU500.40
N29418445: PR517.1 PU500.39
N29418451: PR516.1 PU500.38
N29418455: PR519.1 PU500.37
N29418473: PC536.1 PR551.1 PU500.16
N29418487: PC504.1 PR506.2 PU500.41
N29418491: PR523.1 PU500.48
N29419473: PC500.2 PR500.2 PU500.2
N29419486: PC518.2 PR540.2 PU500.8
N29419576: PC506.2 PR521.1
N29419623: PH502.1 PR534.2
N29419647: PC521.1 PR537.2
N29419655: PC522.1 PR536.2
N29419663: PH501.2 PR530.1
N29419667: PH503.2 PR544.1
N29419693: PC518.1 PR538.2
N29419713: PR526.2 PU500.1
N29419730: PC509.1 PR528.2
N29419832: PC503.1 PR505.2 PU500.42
N29419860: PC535.2 PR548.1 PU500.14
N29419910: PC538.2 PR551.2
N29419918: PC537.1 PR549.2
N29419943: PC532.1 PR541.1 PU500.20
N29419947: PC532.2 PR543.1
N29425467: PL503.2 PR575.1 PR577.2 PR578.1 PU504.11 PU504.12 PU504.13 PU504.14 PU504.15 PU504.16 PU504.17 PU504.18 PU504.19 PU504.20 PU504.21
N29425497: PL502.2 PR565.1 PR567.2 PR568.1 PU503.11 PU503.12 PU503.13 PU503.14 PU503.15 PU503.16 PU503.17 PU503.18 PU503.19 PU503.20 PU503.21
N29425633: PL501.2 PR555.1 PR557.2 PR558.1 PU502.11 PU502.12 PU502.13 PU502.14 PU502.15 PU502.16 PU502.17 PU502.18 PU502.19 PU502.20 PU502.21
N29426641: PR573.2 PU504.1
N29426805: PC548.1 PR555.2
N29426831: PC556.1 PR565.2
N29426855: PC564.1 PR575.2
N29435109: PL508.1 PR5002.1 PR5003.1 PU511.8
N29435333: PL506.2 PR593.1 PR595.2 PR596.1 PU510.11 PU510.12 PU510.13 PU510.14 PU510.15 PU510.16 PU510.17 PU510.18 PU510.19 PU510.20 PU510.21
N29435335: PC587.1 PR5002.2
N29436554: PL505.2 PR584.1 PR586.2 PR587.1 PU507.11 PU507.12 PU507.13 PU507.14 PU507.15 PU507.16 PU507.17 PU507.18 PU507.19 PU507.20 PU507.21
N29436709: PC580.1 PR593.2
N29436789: PC570.1 PR584.2
N29438561: PR512.2 PU500.43
N29438565: PR510.2 PU500.44
N29438567: PR502.2 PR509.1 PR510.1
N29438569: PR501.2 PR507.1 PR508.1
N29438571: PR508.2 PU500.45
N29438583: PR503.2 PR511.1 PR512.1
N29438934: PR504.2 PU500.46
N29599145: PC507.1 PR522.2
N29808551: RM100.2 UM8.49
N29808553: RM99.2 UM8.50
N30070819: RG131.1 UG6.J13
N30070822: RG127.1 UG6.J1
N30070830: RG129.1 UG6.J10
N30306722: CM99.1 RM28.1 RM29.1
N30306724: CM98.1 RM27.1 RM38.1
N30306755: CM16.1 CM17.1 RM18.2 UM4.20
N30306794: RM25.2 UM4.18
N30306843: RM28.2 UM4.13
N30306845: RM27.2 UM4.14
N30314421: CG64.1 UG12.12
N30314423: CG65.1 UG12.10
N30316795: QG502.6 RG516.2 UG22.2
N30317275: RG546.2 UG23.2 UG23.3
N30319723: CG443.1 DG6.2 RG550.2 UG28.2
N30322028: QG503.5 QG503.6 RG509.2
N30322035: QG503.3 RG510.2
N30322061: QG504.5 QG504.6 RG511.2
N30322074: QG504.3 RG512.2
N30322100: QG505.5 QG505.6 RG513.2
N30322113: QG505.3 RG514.2
N30322153: QG507.5 QG507.6 RG541.2
N30322159: QG507.3 RG542.2
N30322217: QG509.5 QG509.6 RG543.2
N30322223: QG509.3 RG544.2
N30365509: QG502.5 RG554.2
N30365512: RG554.1 UG22.4
N30365520: QG502.2 RG553.2
N30373122: RG545.1 UG26.4
N30712936: PR727.1 PU700.15
N30746783: PR210.2 PU201.10
N31077401: PQ710.3 PR732.2
N31077403: PQ710.5 PQ710.6 PR729.1 PR730.2
N31077444: PC724.1 PQ710.2 PR731.2
N31195648: PR8219.2 PU8200.4
N31245253: PQ8202.5 PQ8202.6 PR8221.2
N31306212: PR5006.2 PU511.1
N31395965: PQ707.4 PR726.1
N31397225: PQ701.4 PR725.1
N31412307: PC590.1 PR5007.2 PR5008.1 PU509.11
N31413382: PC593.1 PR5010.2
N31426894: PC541.2 PU502.5
N31426895: PC541.1 PR554.1
N31426896: PR554.2 PU502.7
N31426902: PR552.2 PU502.1
N31426905: PR556.2 PU502.2
N31426910: PC5005.1 PR5028.2 PU502.24
N31427446: PC540.2 PR553.1 PU502.3
N31432086: PC550.1 PR564.1
N31432111: PC550.2 PU503.5
N31432114: PR564.2 PU503.7
N31436402: PR566.2 PU503.2
N31436405: PR563.2 PU503.1
N31436410: PC558.1 PR574.1
N31436413: PC558.2 PU504.5
N31436414: PR574.2 PU504.7
N31436415: PR576.2 PU504.2
N31438582: PC5007.1 PR5030.2 PU504.24
N31438896: PC557.2 PR5020.1 PU504.3
N31439632: PC567.1 PR583.1
N31439653: PC567.2 PU507.5
N31439658: PR583.2 PU507.7
N31439736: PR585.2 PU507.2
N31439790: PR590.2 PU507.1
N31442956: PC566.2 PR5022.1 PU507.3
N31442990: PC5008.1 PR5031.2 PU507.24
N31443441: PC549.2 PR5004.1 PU503.3
N31452286: PC574.2 PU510.5
N31452288: PC574.1 PR592.1
N31452290: PR592.2 PU510.7
N31459506: PC573.2 PR5024.1 PU510.3
N31460044: PC5009.1 PR5032.2 PU510.24
N31466143: PC725.1 PQ703.4 PR733.1
N31494164: PC586.1 PR5005.1
N31494196: PC586.2 PU511.4
N31494209: PR5005.2 PU511.5
N31494627: PR5001.1 PU511.12
N31495785: PC588.2 PR5025.1 PU511.2
N31495969: PC5002.2 PR5026.2 PU511.11
N31535656: PR107.1 PU100.19
N31545452: RG556.1 UG9.BH1
N31545504: RG555.1 UG9.BG4
N31565200: PR599.1 PU502.26
N31565645: PR5011.1 PU503.26
N31565698: PC5006.1 PR5029.2 PU503.24
N31566286: PR5019.1 PU504.26
N31567454: PR5021.1 PU507.26
N31567631: PR5023.1 PU510.26
N32111887: PC8215.1 PR8208.1 PU8200.8
N32112416: PC8209.1 PR8203.2
N32112456: PC8219.1 PR8210.2
N32519781: RG1.2 UG29.4
N32520109: QG510.2 RG1.1
N32576494: QE57.5 RE640.2 RE641.1
N32576646: QE57.3 RE639.2
N32910596: RG564.1 UG9.BE5
N33138349: RG65.2 UG11.5
N33204017: RG566.1 UG9.BD2
N33413702: RE651.1 UE7.3
N33479859: RT108.1 RT109.2 UT4.D6
N33792732: RL5.1 UL2.3
N33792861: RE20.1 UE9.3
N34045293: RM72.2 UM8.27
N34045300: RM64.1 RM66.1 UM8.48
N35007428: RM20.2 UM4.4
N36403640: QM1.2 QM2.6 RM92.2
N36403695: QM2.3 QM3.2 RM94.2
N37551658: RM61.2 UM8.52
N39829069: R181.2 U2407.7
N39831434: C3.1 UZ21.6
N41521526: CE51.1 QE2.2 RE85.1
N45888836: RU3.2 UU1.16
N45888842: RU2.2 UU1.15
N45888957: RU7.2 UU1.8
N45888961: RU1.2 UU1.4
N45889254: CU27.1 DU8.2 RU5.2 UU5.2
N46084233: QX2.2 RX2.1
N59110666: RE646.1 UE5.2
N72585933: PC211.1 PR202.2
N83720760: PC6210.2 PR6210.1
N121164389: CPU1.BH31 RH153.2
N121358327: CPU1.H13 RH154.2
N121386646: CPU1.BR30 RH158.2
N121386855: CPU1.BP31 RH155.2
N121507165: CPU1.BR25 RH57.2
N121507167: CPU1.BP25 RH58.2
N121507169: CPU1.BT29 RH166.2
N122563835: CPU1.BR33 RH519.2
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N198830997: RV23.2 UV21.48
N212152397: JRTC1.1 PR2.2
N213961754: PC14.2 PQ8.2 PR28.2
N249440990: T122.1(TP-1) UT4.G10
N249441180: T114.1(TP-1) UT4.D10
N249443250: T71.1(TP-1) UT4.H6
N249443770: T64.1(TP-1) UT4.B2
N257291080: C2506.1 U17.12
N257291250: C2507.1 U17.10
N2494451224: T65.1(TP-1) UT4.C2
N2494451226: T120.1(TP-1) UT4.G11
N2494451228: T121.1(TP-1) UT4.E10
N2494451230: T70.1(TP-1) UT4.D7
N2494451263: T62.1(TP-1) UT4.F4
N2494451264: T63.1(TP-1) UT4.G4

Pads without a net: CPU1 A27 A33 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ17 BJ19 BJ20 BJ21 BJ23 BJ26 BJ27 BJ28 BJ35 BJ36 BK17 BK19 BK20 BK21 BK23 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL34 BM14 BM15 BM16 BM17 BM22 BM24 BM30 BM31 BN1 BN15 BN16 BN17 BN33 BN35 BP1 BP13 BP15 BP16 BP17 BR15 BR16 BR17 BR31 BR35 BT15 BT16 BT17 BT30 C30 C33 C34 C38 D1 D34 E1 E2 E30 E33 F30 F33 G3 G13 H24 J3 J24 N29 R14; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JHDMI 14; JKB 2; JKBBL 17 18 19 20; JSSD1 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD2 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JTP 8 9 10; JWLAN 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 24 26 28 34 36 38 40 47 50 51 52 53 54 56 57 58 59 60 62 63 65; PBATT1 11; PD1 3; PD3 3; PJPDC1 10 11; PU502 6 25 27; PU503 6 25 27; PU504 6 25 27; PU507 6 25 27; PU509 10 12; PU510 6 25 27; PU700 13 14; PU800 10 12; PU802 1 7; PU1300 5; PU6200 14 15 16 17; PU8200 6; QE56 3 4 5; QE57 1 2 6; QG500 1 2 6; QG501 1 6; RP5 7 8; U2407 8 11; UA1 4 8 47 48 49 50; UA4 13 31 32 35 36; UC1 1; UE3 12 13 19 20 21 22 28 29; UE4 12 13 19 20 21 22 28 29; UE5 36 37 44; UE6 13 17 23; UE10 7 13 21; UG1 A5 A10 U5 U10; UG2 A5 A10 U5 U10; UG3 A5 A10 U5 U10; UG4 A5 A10 U5 U10; UG5 A5 A10 U5 U10; UG6 A5 A10 U5 U10; UG9 A9 A17 A42 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA9 AA44 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AD1 AD2 AD3 AD4 AD5 AD6 AD7 AD8 AD9 AD45 AD46 AF2 AF3 AF4 AF6 AF7 AF8 AF9 AF49 AG1 AG2 AG4 AG5 AG6 AG7 AG8 AG9 AG52 AJ1 AJ3 AJ4 AJ5 AJ6 AJ7 AJ8 AK2 AK3 AK4 AK5 AK6 AK7 AK8 AK9 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AR50 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 B50 BA1 BA2 BA3 BA5 BA6 BA7 BA8 BA9 BB2 BB3 BB6 BB7 BB8 BD4 BD5 BD14 BE7 BE12 BE23 BE35 BE38 BF12 BF21 BF23 BF24 BF33 BF35 BF36 BF38 BF39 BG1 BG6 BG11 BG12 BG21 BG23 BG24 BG33 BG35 BG36 BG38 BG39 BG41 BH6 BH11 BH12 BH23 BH35 BH38 BH41 BJ1 BJ2 BJ9 BJ11 BK11 BK12 BK14 BK18 BK20 BK21 BK36 BK38 BK39 BK41 BK42 BK44 BL11 BL12 BL14 BL18 BL20 BL21 BL36 BL38 BL39 BL41 BL42 BM8 BM9 BM11 BM12 BM20 BM21 BM35 BM36 BM38 BM39 BM41 BM42 C2 C3 C24 C35 D1 D2 D3 D17 D41 E1 E3 E29 F1 F2 F3 F4 F5 F9 F29 F41 G9 G14 G35 G41 H2 H3 H4 H5 H6 H7 H14 H24 H35 J2 J3 J4 J5 J6 J7 J14 J23 J24 J35 J41 J46 J47 L1 L2 L3 L4 L5 L6 L7 L8 M1 M2 M3 M4 M5 M7 M8 M9 M44 M45 P1 P2 P3 P4 P5 P6 P7 P8 P9 P45 R1 R2 R3 R4 R5 R6 R7 R8 R9 U1 U2 U3 U4 U5 U6 U8 V1 V2 V3 V4 V5 V6 V7 V8 V9 V44 V45 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y8 Y50; UG11 10 13 16 17; UH1 A16 A21 AA1 AA2 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB42 AB43 AB44 AC43 AD2 AD3 AD31 AD38 AE17 AE44 AE45 AF17 AF41 AG14 AG15 AG39 AG43 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ38 AJ42 AK44 AK45 AL27 AL39 AL42 AL43 AL44 AM43 AM44 AN17 AN24 AN29 AN36 AN38 AN41 AN42 AR15 AR17 AR19 AR22 AR27 AR29 AR31 AR38 AT27 AT29 AT31 AT42 AT43 AU43 AV2 AV3 AV4 AV13 AV15 AV19 AW2 AW17 AW31 AW33 AW35 B15 B16 B19 B20 B21 B23 B24 BA4 BA33 BA35 BA40 BA41 BB17 BB22 BB31 BB33 BB36 BB38 BB41 BC8 BC15 BC18 BC22 BC23 BC26 BC32 BC33 BC35 BC36 BC38 BD1 BD14 BD17 BD18 BD21 BD23 BD24 BD27 BD28 BD33 BD34 BD35 BD36 BD38 BD39 BE2 BE5 BE6 BE34 BE39 C15 C19 C20 C23 C24 E17 E20 E45 F45 G15 G17 G19 G37 G44 G45 H15 H40 H42 H43 H44 J45 K13 K15 K17 K22 K24 K37 K44 L17 L22 L24 L37 L39 M44 M45 N2 N3 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R36 R39 R41 R42 R43 R44 T44 T45 U2 U3 U5 U7 U13 U35 U36 U39 U41 U42 U43 V1 V2 V44 W2 W3 W7 W10 W11 W13 W39 W43 W44 Y5 Y41 Y43; UL1 24 25 26 28 40; UM4 7 8; UM8 10 11 12 13 15 16 17 18 21 22 23 28 29 30 31 32 33 34 35; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 A9 B9; UU1 9; UU5 1; UV3 11 14; UV21 22 23 24 25 50; UV22 12 13 14

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 912 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 10169 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 256 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 121 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 11.4
  TOP w0.254: PR206.1 56.65,50.12 v2(56.53,50)
  IN1 w0.254: v2(56.53,50) 57.3,50 59.63,47.67 61.13,47.67 61.55,47.26 62.57,47.26 63.49,46.34 v2(65.73,46.34)
  vias: v3(68.02,47.01)
1V8_AON_ON: length 171.8
  TOP w0.114: v2(195.21,68.35) 195.04,68.53 193.86,68.53 192.59,67.26 191.52,67.26 191.09,66.83 189.56,66.83 188.16,65.43 188.16,64.85 187.24,63.92 182.37,63.92 v1(181.78,63.32) 181.11,62.66 179.92,62.66 179.72,62.46 179.72,61.94 179.31,61.53 179.31,61.17 179.07,60.94 178.78,60.94 178.26,60.41 QG503.2 ; v2(89.3,68.54) 89.42,68.41 91.9,68.41 92.22,68.1 92.22,66.45 92.41,66.25 93.8,66.25 94.26,66.71 UG25.4
  IN2 w0.097: v2(195.66,77.43) 196.55,77.43 199.72,74.26 199.72,71.59 200.1,71.21 200.1,69.11 199.51,68.52 196.51,68.52 196.5,68.53 195.39,68.53 v2(195.21,68.35) ; v2(145.68,74) 144.61,72.93 144.61,70.57 140.04,65.99 91.85,65.99 v2(89.3,68.54)
  IN3 w0.124: v2(145.68,74) 146.38,74 149.24,71.14 149.24,70.93 151.05,69.11 154.7,69.11 156.54,70.95 157.62,70.95 158.38,70.19 164.6,70.19 166.26,71.85 166.26,73.43 166.38,73.56 168.69,73.56 169.43,72.81 171.05,72.81 171.34,73.1 171.34,75.34 172.1,76.1 177.81,76.1 179.21,77.49 183.78,77.49 184.23,77.05 185.24,77.05 186.25,76.05 188.88,76.05 190.77,77.94 190.77,78.76 191.09,79.08 191.86,79.08 193.19,77.75 195.34,77.75 v2(195.66,77.43)
  BOTTOM w0.114: v2(195.21,68.35) 195.07,68.49 RG70.2 194.98,69.08 UG12.3
1V8_ENP: length 5.7
  BOTTOM w0.114: PR808.1 240.35,154.56 v1(240.35,155.87)
  BOTTOM w0.254: PR808.1 PC811.1 PR807.1 237.82,153.94 237.82,153.06 238.03,152.85 PU802.5
1V8_MAIN_EN: length 269.2
  TOP w0.114: v2(179.34,58.83) 179.34,58.38 178.48,57.52 177.48,57.52 177.32,57.36 175.36,57.36 v1(175.21,57.5) 175.08,57.63 175.08,59.02 175.46,59.4 QG504.2 ; UG26.2 96.15,64.6 94.25,62.7 93.98,62.7 92.92,61.63 92.05,61.63 86,55.59 v2(84.47,55.59) ; v2(183.65,55.07) 183.65,55.81 RG549.1 184.1,56.85 184.1,59.02 DG3.2 183.34,58.38 182.9,58.38 DG6.1 182.74,58.23 RG550.1
  IN2 w0.097: v2(180.01,61.68) 180.01,62.28 175.35,66.94 175.35,75.73 175.97,76.35 180.74,76.35 181.69,77.3 182.2,77.3 182.45,77.05 v2(182.96,77.05)
  IN3 w0.122: 183.59,55.17 183.59,55.13 v2(183.65,55.07)
  IN3 w0.124: v2(86.31,20.28) 86.82,20.28 86.85,20.31 88.06,20.31 88.79,19.58 89.87,19.58 90.57,18.88 94.83,18.88 95.52,19.58 99.77,19.58 100.09,19.9 100.92,19.9 101.23,19.58 109.23,19.58 109.85,20.2 109.85,21.49 110.21,21.85 111.74,21.85 112.92,20.68 115.83,20.68 116.82,19.69 122.42,19.69 123.25,20.53 145.42,20.53 146.32,21.43 149.43,21.43 153.37,25.36 153.37,32.47 151.91,33.93 151.91,49.74 152.8,50.63 152.8,58.26 156.3,61.76 156.3,63.03 156.8,63.52 163.91,63.52 167.91,59.52 171.85,59.52 172.29,59.08 172.29,58.13 173.69,56.73 177.69,56.73 178.7,57.75 178.7,58.19 v2(179.34,58.83) 180.85,57.31 182.92,57.31 183.59,56.64 183.59,55.17
  IN4 w0.137: v2(84.47,55.59) 84.47,53.73 83.64,52.9 83.64,41.6 83.25,41.2 83.25,28.95 84.55,27.65 84.55,26.39 86.22,24.72 86.22,23.81 86.06,23.65 86.06,20.6 86.31,20.34 v2(86.31,20.28) ; v2(180.01,61.68) 180.12,61.57 180.12,59.61 v2(179.34,58.83)
  IN5 w0.089: 187.59,78.19 187.97,78.57 188.42,78.57 188.8,78.19
  IN5 w0.097: v2(182.96,77.05) 184.1,78.19 184.1,78.83 184.52,79.25 185.33,79.25 186.51,78.07 187.47,78.07 187.59,78.19 ; v2(191.47,69.56) 191.47,70.38 190.6,71.25 190.6,76.39 188.8,78.19
  BOTTOM w0.114: v2(182.96,77.05) 182.54,77.46 182.54,78.14 183.39,78.98 183.39,79.34 183.2,79.53 UG9.BE1 ; v2(191.47,69.56) 191.47,68.6 CG487.1 191.78,68.29 193.75,68.29 194.08,68.62 RG71.2 194.18,69.08 UG12.5
3/5V_B+: length 1
  BOTTOM w0.203: v2(36.97,28.17) 36.78,28.17 36.55,27.95 PU100.12
  vias: v1(47.93,25.26) v2(46.88,28.62) v2(46.88,27.98) v2(47.51,28.62) v2(47.51,27.98) v2(48.15,28.62) v2(48.15,27.98)
3V3_SYS_EN: length 276.3
  TOP w0.114: RG515.2 191.01,79.59 v2(191.02,79.59) 191.4,79.59 191.72,79.27 CG240.1 191.34,79.08 190.68,78.42 UG14.4 ; RG567.2 116.42,11.8 v2(116.65,11.57) ; v2(188.02,54.3) 188.02,53.55 187.49,53.02 185.65,53.02 185.33,52.7 184.52,52.7 183.28,53.94 180.29,53.94 v1(179.21,55.02) 176.8,55.02 175.46,56.35 172.73,56.35 172.16,56.92 172.16,58.76 172.67,59.27 QG505.2 ; RG545.2 98.17,65.25 96.45,63.52 95.38,63.52 94.34,62.48 94.07,62.48 93.01,61.42 92.14,61.42 85.88,55.16 84.33,55.16 v2(83.83,55.65)
  IN3 w0.124: v2(117.13,22.28) 117.13,22.41 115.27,24.28 109.62,24.28 108.57,23.24 103.97,23.24 102.75,22.02 100.74,22.02 100.74,22.01 89.92,22.01 89.79,21.88 87.22,21.88 86.28,22.82 85.87,22.82 v2(85.36,23.33) ; v2(191.02,79.59) 191.78,79.59 193.4,77.98 195.81,77.98 196.29,77.49 196.29,76.86 195.47,76.03 195.47,74.83 192.64,72 189.9,72 189.16,71.25 189.16,67 188.26,66.09 188.26,54.54 v2(188.02,54.3) 188.02,37.88 189.12,36.79 189.12,25.75 187.89,24.52 185.75,24.52 182.66,21.42 179.35,21.42 178.38,20.45 155.69,20.45 155.25,20.01 123.38,20.01 122.6,19.24 120.38,19.24 116.35,15.2 116.35,11.87 v2(116.65,11.57)
  IN4 w0.137: v2(83.83,55.65) 83.83,53.43 83.41,53 83.41,41.7 83.01,41.3 83.01,28.85 84.31,27.55 84.31,25.79 85.29,24.8 85.29,23.39 v2(85.36,23.33)
  BOTTOM w0.114: v2(116.65,11.57) 118.77,13.69 121.38,13.69 122.07,14.39 122.07,16.2 117.24,21.04 117.24,22.17 v2(117.13,22.28)
3V_EN: length 10.7
  TOP w0.254: v2(33.26,29.55) 33.03,29.32 v3(33.03,28.7) 33.03,26.14 33.73,25.44 33.73,24.3 34.62,23.41 36.78,23.41 37.1,23.09 PR100.1
  BOTTOM w0.203: v2(33.26,29.55) 33.57,29.55 33.71,29.4 PU100.6
3V_F383_ON: length 12.8
  TOP w0.203: RE83.1 85.86,6.35 85.86,7.21 85.99,7.34 UE5.128
  TOP w0.254: UE9.4 76.48,4.32 v3(79.53,4.32) 84.58,4.32 85.11,4.85 RE83.1
3VS: length 1.6
  BOTTOM w0.114: v1(60.91,62.89) 59.83,61.81 C2524.1
3VS_GATE: length 2.7
  BOTTOM w0.203: R174.2 C258.1 54.88,60.91 55.69,60.91 55.8,60.8 U17.5
5V_EN: length 5.6
  TOP w0.254: v2(33.24,25.13) 33.24,24.16 v1(33.89,23.5) 34.73,22.66 PR112.1
  BOTTOM w0.203: PU100.20 33.71,25.6 v2(33.24,25.13)
5VS:
  vias: v1(58.47,58.16)
+0.6VS: length 269.1
  IN1 w1.016: 149.81,29.74 149.38,29.31 148.54,28.47 126.86,28.47 126.1,27.71 125.68,27.71 123.98,26 120.09,26 119.5,26.59 109.66,26.59 107.78,28.47 87.26,28.47 86.74,27.95 86.74,27.27 84.95,25.48 78.18,25.48 77.43,26.22 77.43,46.31 80.12,49 80.12,49.55 80.25,49.68 80.25,55.47 76.77,58.95 73.86,58.95
  IN3 w1.016: 142.62,28.7 142.27,29.06 142.27,35.61 144.53,37.87 144.53,40.68 145.63,41.77 147.29,41.77 148.01,41.05 ; 142.62,28.7 149.1,28.7 149.95,29.55 ; 142.62,28.7 142.62,26.58 139.24,23.2 121.05,23.2 119.07,25.18 109.25,25.18 108.2,24.14 105.04,24.14 102.55,26.63 95.25,26.63 94.81,27.08 91.58,27.08 89.31,24.81 85.46,24.81 85.21,25.06 82.75,25.06 80.14,22.44 79.07,22.44 78.43,21.79 76.99,21.79 75.79,22.99 75.79,28.03 76.19,28.43 76.19,55.77 73.82,58.15
  IN5 w1.016: 148.92,38.65 148.92,38.63 146.19,35.9 146.19,30.63 146.91,29.91 148.9,29.91
  BOTTOM w0.305: v2(150.38,30.38) 148.76,30.38 148.28,29.89 JDIMM2.258 ; v2(148.65,40.3) 148.27,40.67 148.27,41.7 JDIMM1.258
  vias: v2(72.37,58.68) v2(72.77,59.24) v2(73.01,58.68) v2(148.65,39.67) v2(150.7,30.89) v3(70,55.36)
+0.6VSP:
  vias: v1(61.93,51.97) v2(62.23,53.1) v2(64.52,52.4) v2(65.16,52.4)
+0.9V_CIO:
  vias: v1(148.64,153.73) v2(147.55,153.89) v2(148.85,154.54)
+0.9V_DP: length 9.9
  IN1 w0.457: v2(155.78,149.95) 155.91,150.07 155.91,150.92 154.95,151.87 154.06,151.87 153.29,151.1 150.63,151.1 150.15,151.58 150.15,153.05 149.96,153.24 v2(149.5,153.24)
  vias: v1(155.11,150.81) v2(146.9,155.84) v2(146.9,155.19) v2(148.85,155.84) v2(148.85,153.24) v2(155.21,150.14)
+0.9V_LVR_OUT: length 16.6
  TOP w0.305: v1(158.42,156.63) v2(158.86,157.06)
  TOP w0.356: CT83.1 159,157.96 158.8,157.77 158.55,157.77 CT84.1
  TOP w0.381: CT84.1 158.41,157.35 158.7,157.06 v2(158.86,157.06)
  TOP w0.508: CT82.1 CT81.1 159.19,157.23 159.02,157.06 v2(158.86,157.06)
  IN4 w0.508: v2(158.86,157.06) 158.56,157.06 158.1,157.52 156.92,157.52 156.41,158.03 156.41,159.43 156.03,159.81 151.84,159.81 151.43,159.4 v2(151.43,157.14)
  vias: v2(148.85,157.14) v2(148.85,156.49)
+0.9V_PCIE: length 0.8
  BOTTOM w0.203: 153.33,155.69 v1(153.33,156.51)
  vias: v2(150.15,155.84) v2(150.8,155.84) v2(151.46,155.84) v2(152.08,155.84)
+0.9V_SVR: length 2.8
  BOTTOM w0.203: LT1.2 138.42,159.73 v1(138.42,157.15)
  vias: v2(138.8,162.3) v2(139.38,162.3) v2(139.97,162.3) v2(140.55,162.3) v2(148.2,156.49) v2(148.2,155.84) v2(148.86,158.44) v2(149.49,159.1) v2(149.49,158.44) v2(150.15,158.44)
+0.9V_USB: length 14.5
  TOP w0.203: CT77.1 155.37,148.11 v1(155.17,147.9)
  TOP w0.381: v2(155.4,149.41) 155.37,149.38 CT77.1
  IN3 w0.508: v2(150.8,153.89) 150.8,154.77 151.21,155.17 153.46,155.17 153.98,154.66 153.98,149.15 154.38,148.74 155.14,148.74 155.4,149 v2(155.4,149.41)
  BOTTOM w0.254: CT56.1 151.4,153.3 v2(150.8,153.89)
+1.0VS_VGA_PGOOD: length 355.9
  TOP w0.124: v2(188.36,78.12) 188.36,78.13 188.48,78.26 UG27.2
  TOP w0.127: v2(257.19,59.21) 256.87,59.52 v3(256.87,59.7)
  IN3 w0.137: v2(257.19,59.21) 258.53,60.55 258.53,66.39 256.02,68.9 253.16,68.9 249.63,72.42 249.63,87.21 247.94,88.91 247.94,89.35 246.21,91.07 246.21,93.91 246.65,94.35 246.65,103.03 246.3,103.39 246.3,153.86 243.79,156.36 237.83,156.36 237.6,156.14 237.32,155.86 237.32,153.4 236.79,152.87 236.79,147.14 233.65,144 233.57,144 233.2,143.62 198.5,143.62 197.51,144.62 192.46,144.62 191.54,145.53 175.88,145.53 170.76,150.65 166,150.65 162.76,153.88 v2(162.76,154.84)
  IN4 w0.137: v2(257.19,59.21) 256.94,59.21 254.7,56.97 254.7,53.54 251.41,50.25 247.16,50.25 245.12,48.22 245.12,46.33 240.25,41.45 234.81,41.45 228.86,35.5 228.86,34.35 225.4,30.89 223.15,30.89 221.5,29.23 217.82,29.23 217.18,29.87 217.18,31.27 216.55,31.9 215.28,31.9 214.7,31.32 214.7,29.6 214.26,29.17 211.72,29.17 211.15,29.74 211.15,33.09 210.16,34.08 203.76,34.08 201.56,31.88 201.56,30.25 200.93,29.62 199.28,29.62 198.9,29.23 197.44,29.23 196.1,30.57 196.1,33.74 194.45,35.39 193.24,35.39 190.9,37.74 190.9,41.81 189.59,43.12 189.59,49.13 189.85,49.39 189.85,62.34 188.77,63.43 186.55,63.43 183.84,66.14 183.84,68.03 184.23,68.42 184.23,73.04 v2(185.13,73.94)
  IN5 w0.097: v2(188.36,78.12) 187.84,77.61 186.27,77.61 185.75,78.13 184.6,78.13 184.38,77.91 184.38,74.69 v2(185.13,73.94)
  BOTTOM w0.114: PU800.9 162.24,153.53 PR821.1 161.76,154.6 162,154.84 v2(162.76,154.84)
+1.0VS_VGAP: length 11.2
  IN4 w0.254: v2(166.07,158.41) 166.19,158.29 169.68,158.29 170.44,157.53 170.44,153.9 v2(170.58,153.76)
  BOTTOM w0.114: v1(164.54,159.54) PR804.1
  BOTTOM w0.254: v2(166.07,158.41) PC809.1 PR804.1
+1.2V_DDR: length 192.1
  TOP w0.381: UC1.5 94.38,75 94.37,75.02 CH197.1
  TOP w0.508: 99.9,73.75 99.86,73.7 94.12,73.7 93.71,74.11 CH197.1
  BOTTOM w0.203: CPU1.AJ12 122.34,92.25 v2(122.06,91.96) 121.69,91.6 CPU1.AL11 ; CPU1.K6 137.68,88.53 137.24,88.53 137.04,88.34 CPU1.L6 ; CPU1.Y12 130,92.25 v2(130.29,91.96) ; v2(124.8,90.75) CPU1.AG9
  BOTTOM w0.254: CPU1.AR12 117.81,92.25 v2(117.49,91.92) 117.16,92.25 CPU1.AT12 ; CPU1.AF5 125.17,87.69 v2(124.86,88) ; CPU1.AY6 114.47,88.34 v2(114.81,88) 115.15,88.34 CPU1.AW6 ; v2(124.86,88) 124.55,87.69 CPU1.AG5 ; v2(124.86,88) 124.97,88 CPU1.AF6 ; v2(117.32,87.97) 117.4,87.97 CPU1.AR6 CPU1.AP6 118.86,88.6 CPU1.AP7 ; CPU1.L12 137.35,92.45 137.78,92.45 CPU1.K12 138.29,91.94 v2(138.39,91.94) ; v2(125.77,92.54) 126.06,92.25 CPU1.AE12 ; v2(132.41,88.01) 132.73,88.34 CPU1.T6 ; CPU1.K6 CPU1.J6 CPU1.J5 ; v2(136.66,88.02) 136.69,88.05 136.73,88.05 137.01,88.34 CPU1.L6 ; CPU1.W6 130.33,88.3 v2(129.9,87.86) 129.5,88.26 CPU1.AA6
  BOTTOM w0.305: v2(105.81,27.61) 105.78,27.64 JDIMM2.96 ; v2(105.81,27.61) 105.02,26.82 95.84,26.82 95.28,27.38 JDIMM2.54 95.28,30.1 v2(95.51,30.34) ; v2(105.81,27.61) 105.81,27.52 106.31,27.01 109.9,27.01 v2(110.42,27.53) ; JDIMM2.112 109.78,27.83 110.07,27.53 v2(110.42,27.53) ; v2(84.9,30.15) 84.78,30.02 JDIMM2.12 ; v2(114.59,27.61) 114.57,27.59 v2(112.58,27.59) ; v2(114.59,27.61) 114.28,27.92 JDIMM2.130 ; v2(114.59,27.61) v2(116.08,27.61) ; v2(110.65,39.62) 110.35,39.62 109.77,40.2 JDIMM1.112 ; v2(116.96,40.38) 117.28,40.7 JDIMM1.142 ; v2(124.1,38.45) 123.6,38.95 122.05,38.95 121.59,38.48 ; v2(124.1,38.45) 124.53,38.02 JDIMM2.163 ; v2(124.1,38.45) 123.91,38.45 123.53,38.06 JDIMM2.159 ; 120.97,27.61 120.78,27.81 JDIMM2.148 ; 120.97,27.61 121.96,27.61 v2(121.97,27.63) ; 120.97,27.61 v2(120.26,27.61) 120.25,27.61 117.95,27.61 v2(117.95,27.61) 117.36,27.61 ; v2(115.95,52.19) 117.02,51.12 JDIMM1.141 ; JDIMM1.117 111.02,51.26 110.42,51.87 v2(110.21,51.87) ; JDIMM1.135 115.53,50.96 115.26,51.23 114.88,51.23 v2(114.81,51.29) 114.43,51.29 114.05,50.91 114.02,50.91 JDIMM1.129 ; v2(110.65,40.29) 111.09,40.29 111.27,40.48 JDIMM1.118 ; 122.45,40.51 122.28,40.68 JDIMM1.154 ; v2(95.06,40.38) 95.27,40.6 JDIMM1.54 ; 121.59,38.48 122.03,38.04 JDIMM2.153 ; 121.59,38.48 v2(120.5,38.48) ; v2(112.58,27.59) 112.78,27.79 JDIMM2.124 ; v2(112.58,27.59) 112.55,27.62 v2(111.05,27.62) ; v2(110.65,38.96) 112.49,38.96 v2(112.51,38.93) ; v2(110.65,38.96) 110.06,38.96 109.53,38.42 JDIMM2.111 ; v2(110.65,38.96) v2(110.65,38.36) 111.03,37.99 JDIMM2.117 ; v2(137.86,39.69) 138.3,39.69 138.77,40.16 JDIMM1.220 ; v2(111.05,27.62) 110.96,27.53 v2(110.42,27.53) ; v2(111.05,27.62) 111.28,27.84 JDIMM2.118 ; JDIMM2.123 112.53,38.32 v2(112.51,38.34) 112.51,38.93 v2(112.51,38.93) ; JDIMM1.96 105.77,40.07 106.1,39.74 v2(106.29,39.74) ; v2(120.5,38.48) 120.53,38.46 JDIMM2.147 ; v2(120.5,38.48) 120.42,38.57 119.9,38.57 119.39,39.08 117.93,39.08 117.29,38.43 v2(117.03,38.43) JDIMM2.141 ; JDIMM1.148 120.77,40.75 v2(120.53,40.51) ; JDIMM1.241 144.02,50.97 143.64,51.36 v2(143.4,51.36) ; v2(121.97,27.63) 123.42,27.63 123.78,27.99 JDIMM2.160 ; v2(121.97,27.63) 122.28,27.93 JDIMM2.154 ; v2(112.51,38.93) 113.27,38.93 ; v2(129.05,31.24) 128.28,30.47 JDIMM2.178 128.28,27.15 128.67,26.76 138.19,26.76 138.88,27.45 v2(138.88,27.61) 138.78,27.71 JDIMM2.220 ; JDIMM2.241 144.03,38.04 v2(143.64,38.43) 142.99,39.07 v2(134.33,39.07) 133.53,38.27 JDIMM2.199 ; v2(84.99,40.42) 84.78,40.63 JDIMM1.12 ; JDIMM2.129 114.03,38.18 113.27,38.93 ; v2(122.55,39.81) 122.72,39.81 123.77,40.86 JDIMM1.160 ; v2(115.95,38.48) 115.53,38.05 JDIMM2.135 ; v2(115.95,38.48) 116.98,38.48 ; v2(115.95,38.48) 115.5,38.93 113.27,38.93 ; v2(100.37,51.21) 100.53,51.06 JDIMM1.75 ; JDIMM2.142 117.28,27.7 117.36,27.61 ; JDIMM1.130 114.28,40.46 114.93,39.81 v2(115.95,39.81) 115.95,40.66 115.77,40.83 JDIMM1.136 ; v2(89.86,51.14) 90.02,50.97 JDIMM1.33 ; 117.36,27.61 v2(116.08,27.61) ; v2(116.08,27.61) 116.08,27.72 115.78,28.03 JDIMM2.136 ; JDIMM1.199 133.53,51.42 133.92,51.81 v2(134.67,51.81) ; v2(112.51,40.39) 112.77,40.65 JDIMM1.124 ; v2(100.67,38.33) 100.53,38.18 JDIMM2.75 ; v2(128.13,43.3) 128.28,43.15 JDIMM1.178 ; JDIMM2.33 v2(90.03,38.35) ; v2(112.47,51.26) 112.52,51.2 112.52,49.9 ; CPU1.R6 CPU1.T6
  BOTTOM w0.356: 122.45,40.51 v2(122.52,40.44) 122.52,39.84 v2(122.55,39.81) 122.55,39.1 122.7,38.95 ; 115.5,38.93 115.95,39.39 v2(115.95,39.81) 116.7,39.81 116.96,40.07 v2(116.96,40.38) ; v2(120.53,40.51) 120.53,38.51 v2(120.5,38.48) ; v2(112.51,38.93) 112.51,38.93 v2(112.51,40.39) ; v2(110.65,40.29) v2(110.65,39.62) v2(110.65,38.96) ; v2(117.03,38.43) 116.98,38.48
  vias: v2(79.57,30.88) v2(79.57,30.24) v2(79.57,29.61) v2(79.57,28.97) v2(79.57,28.34) v2(80.14,31.19) v2(80.14,30.56) v2(80.14,29.92) v2(80.14,29.29) v2(80.14,28.65) v2(80.71,30.88) v2(80.71,30.24) v2(80.71,29.61) v2(80.71,28.97) v2(80.71,28.34) v2(81.28,31.19) v2(81.28,30.56) v2(81.28,29.92) v2(81.28,29.29) v2(81.28,28.65) v2(99.08,87.99) v2(99.34,88.56) v2(110.21,52.51) v2(110.21,51.24) v2(112.47,52.53) v2(112.47,51.89) v2(121.15,51.16) v2(123.62,51.25) v3(105.96,70)
+1.2V_VCCPLL_OC: length 10.5
  TOP w0.508: v2(108.34,92.6) 107.74,92.6 106.77,93.57 106,93.57 104.58,94.99 v3(103.05,94.99) 102.44,94.99 v2(101.73,94.29)
  BOTTOM w0.203: CPU1.BH13 108.21,92.6 v2(108.34,92.6)
  BOTTOM w0.305: v2(139.24,91.37) 139.56,91.71 CPU1.G11
  BOTTOM w0.508: v2(101.73,94.29) 101.12,94.29 C11.1
+1.2VP: length 81.1
  TOP w0.203: v2(65.49,50.84) 65.39,50.94 64.04,50.94 63.86,51.13 PU201.19 ; v2(60.27,53.55) 60.27,53.29 60.51,53.05 PU201.5
  IN4 w0.254: v2(73.61,37.76) 73.69,37.76 74.26,38.33 74.26,46.2 76.79,48.73 76.79,54.32 74.8,56.3 63.93,56.3 61.17,53.55 v2(60.27,53.55)
  IN4 w0.508: v2(65.49,50.84) 64.6,50.84 63.86,51.57 63.86,55.19 64.34,55.67 74.54,55.67 76.15,54.06 76.15,48.86 73.75,46.45 73.75,38.54 v2(73.61,38.4)
  BOTTOM w0.203: v1(64.02,45.81) 64.21,45.62 66.63,45.62
  BOTTOM w0.254: PR205.2 58.19,53.08 59.81,53.08 v2(60.27,53.55)
+1.8VA_TBTA_LDO: length 3.3
  TOP w0.127: CT100.1 123.83,151.9 v1(123.6,151.68)
  TOP w0.508: v2(122.98,153.67) 122.98,153.53 123.76,152.74 CT100.1
  BOTTOM w0.203: v2(122.98,153.67) 122.98,153.66 UT4.K1
+1.8VD_TBTA_LDO: length 3.2
  BOTTOM w0.229: 122.79,147.43 122.85,147.5 123.48,147.5 124.05,148.06 UT4.A2
  BOTTOM w0.381: CT99.1 122.44,147.09 122.79,147.43
+1.8VS: length 662.8
  TOP w0.508: UX1.5 196.5,154.92 v2(196.93,155.35)
  TOP w1.016: 157.53,65.97 v3(162.27,65.97) 162.97,65.97 163.08,65.85 166.05,65.85 168.16,67.97 172.29,67.97 173.18,68.86 173.18,70.06 176.48,73.37 177.75,73.37 177.75,73.43 181.93,73.43 184.99,70.37 184.99,68.92 185.73,68.19 186.37,68.19 186.63,68.44 191.28,68.44 191.68,68.03 192.42,68.03 193.75,69.37 195.47,69.37
  IN1 w0.508: v2(235.85,144.8) 234.44,146.21 231.93,146.21 v2(231.6,145.88) ; v2(166.73,164.32) 168.4,164.32 171.32,161.39 175.07,161.39 175.68,160.78 193.78,160.78 194.45,160.11 v2(194.45,159.47)
  IN2 w0.508: v2(26.65,25.67) 26.65,26.3 27.58,27.24 v2(27.58,27.96)
  IN2 w1.524: 239.28,144.31 240.31,144.31 245.92,138.7 245.92,88.2 248.63,85.5 248.63,70.43 249.33,69.73 249.33,58.25 246.51,55.43 246.51,52.68
  IN3 w0.508: v2(196.93,155.35) 196.93,153.73 195.45,152.25 195.45,149.39 196.67,148.17 196.67,146.91 197.3,146.28 199.3,146.28 199.66,146.65 202.45,146.65 202.64,146.46 207,146.46 207.21,146.67 222.9,146.67 224.23,145.34 230.26,145.34 230.81,145.88 v2(231.6,145.88)
  IN3 w1.016: 209.12,27.9 209.63,27.9 209.82,27.71 211.41,27.71 211.55,27.57 218.18,27.57 218.71,28.1 ; 219.91,29.36 227.92,29.36 233,34.44 233,38.07 236.29,41.36 240.23,41.36 244.5,45.63 244.5,50 ; 156.75,64.77 156.72,64.79 154.78,64.79 153.71,63.73 153.71,60.78 150.53,57.6 150.53,52.9 148.07,50.43 148.07,43.42 150.53,40.95 150.53,39.79 149.01,38.27 147.59,38.27 146.12,36.81 146.12,30.67 146.58,30.22 148.68,30.22 150.22,31.76 151.16,31.76 151.94,30.98 151.94,29.25 149.79,27.1 149.79,23.52 148.97,22.71 146.3,22.71 145.03,21.43 121.8,21.43 121.54,21.17 116.73,21.17 114.66,23.25 110.66,23.25 109.17,21.76 109.17,20.98 108.54,20.34 104.83,20.34 104.06,21.12 101.11,21.12 101.11,21.11 90.29,21.11 90.16,20.98 86.85,20.98 85.91,21.92 82.97,21.92 80.46,19.4 76.67,19.4 74.45,21.63 74.45,28.23 69.99,32.69 69.99,46.13 68.34,47.78 65.04,47.78 63.07,45.81 60.34,45.81 55.96,41.43 51.64,41.43 50.62,40.41 48.4,40.41 47.13,41.68 37.73,41.68 36.02,39.97 v2(36.02,39.39) 36.02,36.98 34.81,35.77 34.81,34.25 35.51,33.55 35.51,32.09 35.32,31.9 34.3,31.9 32.84,30.44 30.43,30.44 29.99,30 29.99,29.36
  IN3 w1.524: 246.47,52.69 246.5,52.72 246.5,55 249.53,58.04 249.53,70.13 248.45,71.21 248.45,86.7 246.78,88.37 246.78,88.87 245.05,90.59 245.05,94.39 245.49,94.83 245.49,102.55 245.14,102.91 245.14,142.52 243.41,144.25 239.4,144.25
  IN3 w3.048: 191.25,55.41 194.76,51.9 224.77,51.9 227.38,49.29 238.39,49.29 240.68,51.58 243.49,51.58
  IN4 w0.508: v2(194.45,159.47) 194.83,159.85 196.74,159.85 198.01,158.58 198.01,156.42 196.93,155.35 v2(196.93,155.35)
  BOTTOM w0.508: CV20.1 194.57,159.47 v2(194.45,159.47) ; CV1056.1 164.78,163.92 165.74,163.92 UX2.5 166.14,164.32 v2(166.73,164.32) ; PR6229.1 v2(218.72,30)
  vias: v2(27.85,25.67) v2(28.84,28.66) v2(29.44,28.66) v2(156.73,66.25) v2(156.73,65.62) v2(195.81,68.15) v2(196.39,68.15) v2(196.67,69.56) v2(196.67,68.92) v2(206.96,27.52) v2(207.6,27.33) v2(236.49,144.8) v2(237.07,144.8) v2(237.66,144.8) v2(238.24,144.8) v2(245.7,51.65) v2(245.7,51.07) v2(245.7,50.48) v2(246.22,50.75)
+1.8VSP: length 18.9
  IN1 w0.254: v2(234.21,148.01) 235.51,146.71 240.74,146.71 241.79,147.76 v2(241.79,155.63)
  BOTTOM w0.114: v1(233.67,151.75) 234.15,151.75
  BOTTOM w0.254: PC816.1 242.05,154.71 PR810.2 v2(241.79,155.63)
+1.35VS_B+: length 19.5
  TOP w0.254: PR8201.2 v2(260.56,62.69)
  IN1 w0.254: v2(260.56,62.69) 260.56,59.73 258.13,57.3 v2(245.76,57.3)
  vias: v2(245.19,55.59) v2(245.19,54.7) v2(245.76,58.95) v2(245.76,58.25) v2(245.76,56.6) v3(246.09,61.06)
+1.35VS_VGA: length 128.6
  TOP w0.381: CG122.1 237.11,113.3 CG125.1
  IN1 w0.4: v2(232.65,83.91) v2(232.65,83.11) ; v2(232.65,83.91) v2(232.65,84.71) v2(232.65,85.51) ; v2(232.65,83.91) v2(233.45,83.91) ; v2(217.41,135.58) v2(217.41,136.38) v2(217.41,137.18) ; v2(232.65,102.75) v2(232.65,103.55) ; v2(215.01,133.98) v2(215.81,133.98) v2(216.61,133.98) ; v2(234.68,120.37) v2(234.68,119.57) v2(234.68,118.77) ; v2(180.34,133.98) v2(181.14,133.98) v2(181.94,133.98) ; v2(235.85,101.95) v2(236.65,102.75) ; v2(239.05,83.11) v2(239.85,83.91)
  IN5 w0.4: v2(232.65,74.31) v2(232.65,75.11) v2(232.65,75.91) ; v2(235.48,111.57) v2(236.28,111.57) v2(237.08,111.57) ; v2(233.38,76.71) v2(234.25,76.71) v2(235.05,76.71) v2(235.85,76.71) ; v2(223.81,133.98) v2(224.61,133.98) v2(224.61,133.18) ; v2(234.68,110.77) v2(234.68,109.97) v2(234.68,109.17) ; v2(232.65,95.55) v2(232.65,94.75) ; v2(223.81,131.58) v2(224.61,131.58)
  BOTTOM w0.152: UG6.G14 UG6.G13
  BOTTOM w0.203: v2(208.61,141.18) 209.41,141.18 UG1.B1
  BOTTOM w0.25: UG9.K21 v2(207.4,93.95) 207.1,93.65 UG9.L21 ; UG9.L20 207.1,92.95 v2(207.4,92.65) UG9.K20
  BOTTOM w0.254: v2(240.65,102.75) 240.25,102.35 UG6.T3 ; v2(208.61,141.18) 208.21,141.58 UG1.B3 ; UG1.T3 v2(208.61,130.78) ; UG2.E5 183.94,132.89 v2(183.54,133.3) ; UG2.C5 183.94,131.18 v2(183.54,130.78) ; UG4.P3 v2(217.41,140.38) ; UG1.G1 v2(210.21,137.98) ; UG4.B12 224.21,130.38 v2(224.61,129.98) ; v2(207.81,140.38) 208.21,139.98 UG1.D3 ; UG6.B14 229.05,93.35 v2(228.65,92.95) ; 209.81,138.38 UG1.F1 209.41,137.98 v2(209.41,137.98) UG1.G2 ; UG3.P1 232.68,109.57 v2(232.28,109.17) ; UG1.B12 v2(200.61,141.18) ; v2(233.88,110.77) UG3.M3 234.28,111.17 v2(234.68,110.77) UG3.L2 ; UG9.L39 206.75,106.5 v2(206.65,106.5) ; UG9.L23 206.9,95.05 v2(206.65,94.8) ; v2(241.88,116.37) 241.48,116.77 UG3.C10 ; v2(239.05,104.35) 238.65,103.95 UG6.P1 ; v2(206.61,97) 206.75,97.15 UG9.L26 ; UG6.C5 v2(229.45,101.15) v2(229.45,101.95) UG6.B3 ; UG3.T3 v2(230.68,110.77) ; UG6.P3 v2(239.05,101.95) ; UG9.L36 206.9,104.15 v2(206.65,104.4) ; v2(240.65,104.35) 240.25,103.95 UG6.T1 ; v2(231.96,101.15) 231.85,101.15 UG6.E5 ; UG9.L32 206.9,101.35 v2(206.65,101.1) ; v2(199.01,141.18) 199.41,141.58 UG1.B14 ; UG9.K12 v2(207.4,87.65) ; v2(210.21,141.98) UG1.B1 209.81,141.58 v2(209.41,141.98) ; UG4.D3 217.01,131.98 v2(216.61,132.38) ; UG2.R10 v2(187.54,141.18) ; UG6.R5 239.46,100.75 239.86,100.35 v2(239.88,100.35) ; UG4.T3 v2(217.41,141.98) ; UG5.C5 239.45,77.91 v2(239.85,78.31) ; UG5.P14 v2(230.25,85.51) ; UG2.C10 v2(188.34,130.78) ; v2(223.01,130.78) 222.61,131.18 UG4.C10 ; v2(181.94,129.98) 182.34,130.38 UG2.B3 ; v2(237.45,101.15) 237.85,100.75 UG6.N5 ; UG9.L30 207.1,99.95 v2(207.4,100.25) UG9.K30 ; UG2.P3 182.34,139.98 v2(182.74,140.38) ; UG5.T14 v2(228.65,85.51) ; UG1.L4 v2(207.81,134.78) 207.81,134.78 UG1.K3 208.21,135.18 v2(207.83,135.56) ; UG9.K24 v2(207.4,96.05) 207.1,95.75 UG9.L24 ; UG3.L1 v2(234.68,109.17) 234.28,109.57 UG3.M1 234.28,109.57 v2(233.88,109.17) ; UG2.B12 v2(189.94,129.98) ; v2(206.65,98.1) 206.9,97.85 UG9.L27 ; v2(237.85,81.36) 237.85,81.36 UG5.E10 ; UG6.D3 v2(231.05,102.75) ; UG3.B3 v2(241.88,111.57) ; v2(233.08,111.57) 232.68,111.17 UG3.P3 ; v2(239.85,85.51) 240.25,85.11 UG5.B14 ; UG2.T3 v2(181.94,141.98) ; UG6.C10 v2(229.45,96.35) ; UG3.E5 239.88,112.77 v2(239.48,113.17) ; UG1.R5 206.61,131.18 v2(207.01,130.78) ; v2(240.65,93.15) 240.25,93.55 UG6.T14 ; UG2.D3 v2(181.94,132.38) ; UG2.E10 v2(188.34,132.38) UG2.D11 v2(189.14,131.58) UG2.D12 189.61,131.98 v2(189.94,131.64) ; v2(241.88,113.17) 241.48,112.77 UG3.C5 ; v2(242.68,117.97) 242.28,118.37 UG3.B12 ; UG6.D14 230.65,93.35 v2(230.25,92.95) ; UG5.T12 v2(228.65,83.91) ; UG9.AF43 v2(196.8,108.75) ; UG1.N5 v2(207.01,133.18) ; UG4.T1 v2(215.01,141.98) ; UG9.K41 v2(207.4,107.35) ; v2(207.81,132.38) 208.21,131.98 UG1.P3 ; UG4.P14 v2(226.21,140.38) ; UG9.K35 v2(207.4,103.15) 207.1,103.45 UG9.L35 ; UG3.N5 v2(233.88,112.37) ; UG2.B1 180.74,130.38 v2(180.34,129.98) ; UG3.D3 240.68,111.17 v2(241.08,111.57) ; UG5.D1 v2(239.05,74.31) ; UG6.B1 v2(228.65,104.35) ; UG3.D11 240.68,117.57 ; UG5.T3 228.65,75.91 v2(228.65,75.91) ; UG2.L11 v2(188.34,137.98) ; UG9.M10 v2(206,86.25) ; UG6.D1 v2(230.25,104.35) ; UG5.R5 v2(229.45,77.51) ; UG5.D3 238.66,76.31 v2(239.06,76.71) ; v2(239.85,83.91) 240.25,83.51 UG5.B12 ; UG2.P1 v2(180.34,140.38) ; UG3.T1 v2(230.68,109.17) ; UG1.T12 v2(200.61,129.98) ; v2(206.65,102.3) 206.9,102.05 UG9.L33 ; UG5.N10 v2(231.05,82.31) UG5.P11 v2(230.25,83.11) UG5.P12 ; UG5.T1 v2(228.65,74.31) ; UG4.B3 v2(217.41,130.78) ; UG4.D14 v2(226.41,131.98) ; v2(180.34,131.58) 180.74,131.98 UG2.D1 ; UG5.R10 v2(229.45,82.31) ; UG6.T12 v2(239.85,95.55) ; UG5.C10 239.45,81.91 v2(239.85,81.51) ; v2(218.21,133.18) 218.22,133.18 218.22,133.17 218.61,132.78 UG4.E5 ; UG5.B3 v2(239.85,76.71) ; UG9.K27 v2(207.4,98.15) ; UG2.D14 191.28,131.98 v2(191.66,131.6) ; UG5.P1 230.64,74.71 v2(230.25,74.31) ; UG6.B12 v2(228.65,94.75) ; UG9.K29 v2(207.4,98.95) ; UG9.AG11 195.55,86.9 v2(195.55,87) ; UG3.T14 v2(230.68,120.37) ; UG4.C5 v2(218.21,130.78) ; UG2.N10 v2(187.54,139.58) ; UG3.R5 v2(231.48,112.37) ; 235.9,118.37 UG3.K12 ; UG3.R10 v2(231.48,117.17) ; UG9.K36 v2(207.4,104.45) ; UG3.T12 v2(230.68,118.77) ; UG5.E5 237.85,77.91 237.31,78.45 v2(237.25,78.45) ; UG2.N5 183.94,139.18 v2(183.54,138.78) ; UG5.B1 v2(240.65,74.31)
  BOTTOM w0.3: UG9.AR42 190.2,108.25 v2(190.45,108) ; UG9.V42 201.85,108.1 v2(201.85,108) ; UG9.AK10 v2(193.4,86.25) ; v2(195.55,108) 195.55,108.1 UG9.AG42 ; UG9.L18 206.75,91.8 v2(206.65,91.8) ; UG9.K23 v2(207.4,94.75) ; UG9.AG10 v2(195.5,86.25) ; UG9.Y43 v2(201,108.75) ; v2(200.95,108) 200.95,108.1 UG9.Y42 ; UG9.AJ11 194.65,86.9 v2(194.65,87) ; UG9.R43 v2(203.9,108.75) ; UG9.P43 v2(205.2,108.75) ; UG9.K39 v2(207.4,106.55) ; v2(203.95,108) 203.95,108.1 UG9.R42 ; UG9.K17 v2(207.4,90.55) ; UG9.AN43 v2(191.3,108.75) ; v2(199.75,108) 199.75,108.1 UG9.AA42 ; UG9.AC42 198.85,108.1 v2(198.85,108) ; UG9.AR43 v2(190.5,108.75) ; UG9.K32 v2(207.4,101.05) ; UG9.AK43 v2(193.4,108.75) ; UG9.AM42 192.55,108.1 v2(192.55,108) ; UG9.M43 v2(206,108.75) ; UG9.P42 205.15,108.1 v2(205.15,108) ; UG9.AD43 v2(197.6,108.75) ; UG9.K33 v2(207.4,102.35) ; v2(193.45,108) 193.45,108.1 UG9.AK42 ; UG9.AM43 v2(192.6,108.75) ; 193.45,86.9 v2(193.45,87) ; v2(194.65,108) 194.65,108.1 UG9.AJ42 ; UG9.K26 v2(207.4,96.85) ; UG9.U43 v2(203.1,108.75) ; UG9.K38 v2(207.4,105.25) ; v2(197.65,108) 197.65,108.1 UG9.AD42 ; UG9.AJ10 v2(194.7,86.25) ; UG9.AJ43 v2(194.7,108.75) ; UG9.AA43 v2(199.7,108.75) ; UG9.AG43 v2(195.5,108.75) ; UG9.K18 v2(207.4,91.85) ; UG9.AC43 v2(198.9,108.75) ; UG9.V43 v2(201.8,108.75)
  BOTTOM w0.381: CG167.1 240.65,106.76 v2(240.65,104.35)
  BOTTOM w0.508: v2(228.65,85.51) 228.49,85.67 CG151.1 ; CG152.1 237.16,86.86 v2(237.43,86.59) ; CG406.1 180.99,142.94 v2(181.09,142.84) ; CG150.1 240.15,87.16 v2(239.84,86.85) ; CG344.1 v2(244.25,78.26)
  vias: v2(180.34,141.98) v2(180.34,137.98) v2(180.34,133.18) v2(181.86,138.01) v2(182.74,137.18) v2(182.74,136.38) v2(182.74,135.58) v2(182.74,134.78) v2(185.12,141.57) v2(189.14,141.18) v2(189.14,140.38) v2(189.14,136.38) v2(189.14,133.98) v2(189.94,138.78) v2(189.94,137.98) v2(189.94,134.78) v2(189.94,133.98) v2(189.94,133.18) v2(191.54,141.98) v2(191.54,140.38) v2(191.54,138.78) v2(191.54,137.98) v2(191.63,132.55) v2(191.6,130.17) v2(196.8,86.25) v2(197.6,86.25) v2(197.65,87) v2(198.85,87) v2(198.9,86.25) v2(199.01,139.58) v2(199.01,138.78) v2(199.01,137.98) v2(199.01,131.58) v2(199.01,129.98) v2(199.7,86.25) v2(199.81,133.98) v2(199.75,87) v2(200.61,138.78) v2(200.61,137.98) v2(200.61,134.78) v2(200.61,133.98) v2(200.95,87) v2(201,86.25) v2(201.41,140.38) v2(201.41,136.38) v2(201.41,133.98) v2(201.41,131.58) v2(201.8,86.25) v2(202.21,140.38) v2(202.21,137.98) v2(202.21,133.18) v2(202.21,131.58) v2(203.01,141.18) v2(203.05,87) v2(203.1,86.25) v2(203.16,139.18) v2(203.9,86.25) v2(203.95,87) v2(205.2,86.25) v2(206.21,141.18) v2(206.21,138.78) v2(207.4,89.75) v2(207.4,88.45) v2(207.81,137.98) v2(207.81,137.18) v2(207.81,136.38) v2(208.61,133.98) v2(208.61,133.18) v2(209.41,133.98) v2(210.21,140.38) v2(210.21,138.78) v2(210.21,133.18) v2(210.21,131.58) v2(210.21,130.78) v2(215.01,140.38) v2(215.01,138.78) v2(215.01,137.98) v2(215.01,133.18) v2(215.01,131.58) v2(215.01,130.78) v2(215.81,137.98) v2(216.61,137.98) v2(217.41,134.78) v2(218.21,138.78) v2(219.01,141.18) v2(222.01,71.78) v2(222.01,70) v2(222.21,141.18) v2(222.21,138.78) v2(222.2,70.89) v2(222.52,72.1) v2(222.52,71.46) v2(222.52,70.32) v2(222.84,70.89) v2(223.01,140.38) v2(223.01,139.58) v2(223.01,137.98) v2(223.01,132.38) v2(223.15,72.1) v2(223.15,71.46) v2(223.15,70.32) v2(223.47,70.89) v2(223.81,141.18) v2(223.81,140.38) v2(223.81,136.38) v2(223.79,72.1) v2(223.79,71.46) v2(223.79,70.32) v2(224.11,70.89) v2(224.42,72.1) v2(224.42,71.46) v2(224.42,70.32) v2(224.61,138.78) v2(224.61,137.98) v2(224.61,134.78) v2(224.74,70.89) v2(225.06,71.46) v2(225.06,70.32) v2(225.38,70.89) v2(225.69,71.46) v2(225.99,70.89) v2(225.99,70.26) v2(226.21,141.98) v2(226.21,138.78) v2(226.21,137.98) v2(226.3,71.46) v2(226.41,134.38) v2(226.41,133.58) v2(226.41,130.38) v2(226.58,70.89) v2(226.58,70.26) v2(226.9,71.46) v2(227.17,70.89) v2(227.17,70.26) v2(227.52,71.46) v2(227.76,70.89) v2(228.04,70.32) v2(228.13,71.46) v2(228.41,70.89) v2(228.73,71.46) v2(228.68,70.32) v2(229.01,70.89) v2(229.33,71.46) v2(229.31,70.32) v2(229.64,70.89) v2(229.95,70.32) v2(229.96,71.46) v2(230.25,95.55) v2(230.25,70.89) v2(230.57,71.46) v2(230.58,70.32) v2(230.86,70.89) v2(231.05,96.35) v2(231.05,76.71) v2(231.85,104.35) v2(231.85,94.75) v2(231.85,92.98) v2(231.85,85.51) v2(231.85,77.51) v2(231.85,75.91) v2(231.85,74.31) v2(232.28,120.37) v2(232.28,117.97) v2(232.65,92.98) v2(233.08,117.17) v2(233.45,101.95) v2(233.36,94.75) v2(233.88,120.37) v2(234.25,101.95) v2(234.68,117.97) v2(235.05,101.95) v2(235.05,95.55) v2(235.05,83.11) v2(235.6,129.82) v2(235.6,129.18) v2(236.11,130.14) v2(236.11,129.5) v2(236.65,104.35) v2(236.65,103.55) v2(236.65,96.35) v2(236.65,94.75) v2(236.65,93.15) v2(236.65,85.51) v2(236.65,83.91) v2(236.65,83.11) v2(236.65,82.31) v2(236.65,76.71) v2(236.65,75.11) v2(236.65,74.31) v2(237.08,118.77) v2(237.45,104.35) v2(237.45,97.15) v2(237.45,94.75) v2(237.45,93.15) v2(237.45,85.51) v2(237.45,75.91) v2(237.45,74.31) v2(237.88,111.57) v2(238.25,96.35) v2(238.25,85.51) v2(238.36,107.56) v2(238.68,120.37) v2(238.68,118.77) v2(238.67,117.96) v2(238.68,117.17) v2(238.68,111.57) v2(238.68,109.17) v2(239.05,97.15) v2(239.05,96.35) v2(239.05,95.55) v2(239.05,93.15) v2(239.48,120.37) v2(239.48,109.17) v2(239.85,97.15) v2(239.88,116.22) v2(240.28,120.37) v2(240.28,117.17) v2(241.08,117.97) v2(241.08,109.17) v2(241.88,120.37) v2(242.51,97.12) v2(242.57,104.77) v2(242.64,101.09) v2(242.56,98.13) v2(242.68,109.17) v2(242.69,102.82) v2(242.75,99.59) v3(238.8,131.55)
