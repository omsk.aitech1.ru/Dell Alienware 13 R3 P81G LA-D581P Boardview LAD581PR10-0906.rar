# Allegro board LAD581PR10-0906.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR8216  0_0402_5%  [R0402_0OHM]  255.02 55.38 90 top
PR8217  0_0402_5%  [R_0402]  188.85 52.16 0 top
PR8219  0_0402_5%  [R0402_0OHM]  255.93 58.95 180 top
PR8220  10K_0402_5%  [R_0402]  255.93 57.16 180 top
PR8221  10K_0402_5%  [R_0402]  263.22 62 180 top
PT1  PAD~D  [TPC12]  127.9 132.89 180 bottom
PT2  PAD~D  [TPC12]  136.26 132.82 180 bottom
PT3  PAD~D  [TPC12]  144.41 132.76 180 bottom
PT4  PAD~D  [TPC12]  111.26 132.82 180 bottom
PT5  PAD~D  [TPC12]  119.71 132.89 180 bottom
PT6  PAD~D  [TPC12]  152.22 126.92 90 bottom
PU100  TPS51225CRUKR_QFN20_3X3  [TPS51225CRUKR_QFN20_3X3-S]  32.96 26.75 90 bottom
PU201  RT8207PGQW_WQFN20_3X3  [RT8207PGQW_WQFN20_3X3-S]  62.11 52.28 180 top
PU300  TPS51212DSCR_SON10_3X3  [TPS51212DSCR_SON10_3X3-S]  214.33 19.12 90 top
PU500  ISL95829HRTZ-TS2778 TQFN48 CPU CODE  [ISL95855HRTZ-T_TQFN48_6X6-S]  90.5 131.02 0 bottom
PU502  -  [SIC632CDT1GE3_POWERPAK31_5X5]  129.76 135.62 270 bottom
PU503  -  [SIC632CDT1GE3_POWERPAK31_5X5]  138.29 135.57 270 bottom
PU504  -  [SIC632CDT1GE3_POWERPAK31_5X5]  146.25 135.6 270 bottom
PU507  -  [SIC632CDT1GE3_POWERPAK31_5X5]  113.3 135.56 270 bottom
PU509  -  [SY8286RAC_QFN20_3X3]  90.49 105.87 0 bottom
PU510  -  [SIC632CDT1GE3_POWERPAK31_5X5]  121.64 135.65 270 bottom
PU511  -  [SIC531CDT1GE3_POWERPAK22_4X3]  154.12 129.16 270 bottom
PU700  BQ24780SRUYR_QFN28_4X4  [BQ24780RUYR_WQFN28_4X4-S]  60.46 33.73 180 top
PU800  -  [SY8286RAC_QFN20_3X3]  165.57 151.53 90 bottom
PU802  -  [RT8061AZQW_WDFN10_3X3]  238.47 150.85 90 bottom
PU1300  -  [RT9059GSP_SO8]  165.81 21.13 180 bottom
PU6100  -  [NCP81278MNTXG_QFN20_3X3]  201.67 32 180 bottom
PU6200  -  [NCP81278MNTXG_QFN20_3X3]  214.62 31.87 180 bottom
PU8200  RT8812AGQW-GP  [RT8812AGQW_WQFN20_3X3-S]  253.02 60.63 0 top
Q7  -  [DMN65D8LDW-7_SOT363-6]  117.17 6.49 90 top
Q8  -  [DMN65D8LDW-7_SOT363-6]  115.5 2.49 0 top
Q9  -  [DMN65D8LDW-7_SOT363-6]  118.45 2.51 0 top
Q28  -  [DMN66D0LDW-7_SOT363-6]  223.34 21.12 270 bottom
Q29  -  [DMN66D0LDW-7_SOT363-6]  219.47 16.49 270 bottom
Q34  -  [DMN66D0LDW-7_SOT363-6]  219.4 21.12 270 bottom
Q2407  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  107.08 132.17 90 bottom
Q2408  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  192.8 32.34 180 top
Q2409  SI3456DDV-T1-GE3_TSOP6~D  [SI3456DDV-T1-GE3_TSOP6]  202.54 4.39 90 top
Q2410  L2N7002WT1G 1N SC-70-3  [SSM3K7002FU_SC70-3]  200.29 2.42 90 top
Q2411  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  220.87 33.68 180 bottom
QE1  -  [DMN66D0LDW-7_SOT363-6]  256.6 44.48 0 top
QE2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  81.18 23.89 270 top
QE3  -  [DMN66D0LDW-7_SOT363-6]  262.16 51.14 180 top
QE4  -  [DMN66D0LDW-7_SOT363-6]  264.73 49.24 0 top
QE5  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  146.53 14.67 0 top
QE8  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  112.41 11.62 180 top
QE13  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  165.41 152.99 0 top
QE21  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  171.63 152.93 0 top
QE22  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  176.9 152.99 0 top
QE29  -  [MMDT3904-7-F_SOT363-6]  129.98 3.4 0 top
QE39  -  [MMDT3904-7-F_SOT363-6]  143.07 3.4 0 top
QE40  -  [MMDT3904-7-F_SOT363-6]  145.63 3.4 0 top
QE41  -  [MMDT3904-7-F_SOT363-6]  132.61 3.4 0 top
QE42  -  [MMDT3904-7-F_SOT363-6]  135.23 3.4 0 top
QE43  -  [MMDT3904-7-F_SOT363-6]  124.45 14.83 0 top
QE44  -  [MMDT3904-7-F_SOT363-6]  140.46 3.39 0 top
QE45  -  [MMDT3904-7-F_SOT363-6]  127.36 3.4 0 top
QE46  -  [MMDT3904-7-F_SOT363-6]  137.85 3.4 0 top
QE47  -  [MMDT3904-7-F_SOT363-6]  124.74 3.4 0 top
QE48  -  [MMDT3904-7-F_SOT363-6]  122.15 3.4 0 top
QE49  -  [DMN66D0LDW-7_SOT363-6]  124.71 8.92 0 top
QE50  -  [DMN66D0LDW-7_SOT363-6]  129.98 8.92 0 top
QE51  -  [DMN66D0LDW-7_SOT363-6]  132.78 14.95 0 top
QE52  -  [DMN66D0LDW-7_SOT363-6]  139.06 14.89 0 top
QE53  -  [DMN66D0LDW-7_SOT363-6]  129.62 14.96 0 top
QE54  -  [BC857BS_SOT363-6]  127.32 8.85 0 top
QE55  -  [BC857BS_SOT363-6]  135.64 14.89 0 top
QE56  -  [BC857BS_SOT363-6]  127.06 14.89 0 top
QE57  -  [DMN66D0LDW-7_SOT363-6]  179.55 15.05 270 bottom
QG2  -  [MESS138W-G_SOT323-3]  196.86 137.76 90 bottom
QG3  -  [MESS138W-G_SOT323-3]  239.73 125.82 90 bottom
QG4  -  [MESS138W-G_SOT323-3]  236.68 90.26 270 bottom
QG5  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  183.53 71.92 90 bottom
QG6  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  186.08 64.12 180 bottom
QG7  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  187.8 70.09 180 bottom
QG500  -  [DMN66D0LDW-7_SOT363-6]  171.33 74.69 0 bottom
QG501  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  186.64 77.21 180 top
QG502  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  187.91 61.03 90 top
QG503  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  177.61 59.53 0 top
QG504  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  174.81 59.53 0 top
QG505  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  172.02 59.53 0 top
QG506  -  [MESS138W-G_SOT323-3]  179.21 75.46 270 bottom
QG507  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  188.74 50.9 270 top
QG509  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  220.67 27.59 0 top
QG510  -  [MESS138W-G_SOT323-3]  184.37 67.27 0 bottom
QG511  -  [MESS138W-G_SOT323-3]  186.92 53.89 270 top
QH5  DMN66D0LDW-7  [DMN66D0LDW-7_SOT363-6]  175.77 25.94 270 bottom
QL3  -  [2N7002K_SOT23-3]  233.66 155.65 90 bottom
QM1  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  125.67 163.51 0 bottom
QM2  -  [DMN66D0LDW-7_SOT363-6]  128.26 162.13 0 bottom
QM3  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  132.33 163.18 0 bottom
QU1  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  301.32 48.7 180 top
QV1  -  [SI3457CDV-T1-GE3_TSOP6]  118.76 157.55 270 top
QV2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  117.73 153.73 90 top
QV96  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  169.3 158.88 90 bottom
QV97  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  196.35 151.14 90 top
QX1  -  [BSS138-G_SOT23-3]  177.59 157.95 270 bottom
QX2  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  195.47 158.33 90 bottom
QX3  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  165.68 165.88 90 bottom
R2  0_0603_5%  [R0603_0OHM]  215.09 5.8 90 top
R144  2.2K_0402_5%  [R_0402]  224.36 19.7 90 bottom
R145  2.2K_0402_5%  [R_0402]  220.42 19.89 90 bottom
R146  2.2K_0402_5%  [R_0402]  220.41 22.44 0 bottom
R147  2.2K_0402_5%  [R_0402]  217.69 17.6 90 bottom
R150  2.2K_0402_5%  [R_0402]  220.42 16.93 270 bottom
R154  2.2K_0402_5%  [R_0402]  218.84 18.52 270 bottom
R174  10K_0402_5%  [R_0402]  53.84 59.83 0 bottom
R179  300K_0402_5%~D  [R_0402]  201.44 2.89 270 top
R180  1.5M_0402_5%~D  [R_0402]  202.39 2.89 270 top
R181  10K_0402_5%  [R_0402]  71.76 59.14 45 bottom
R185  0_0402_5%  [R0402_0OHM]  65.43 60.61 225 bottom
R307  100K_0402_1%  [R_0402]  118.25 6.81 90 top
R325  100K_0402_1%  [R_0402]  118.29 5.41 0 top
R363  10K_0402_5%  [R_0402]  225.92 28.21 0 top
R365  10K_0402_5%  [R_0402]  229.3 7.26 0 top
R367  10K_0402_5%  [R_0402]  153.11 60.74 270 top
R368  0_0402_5%  [R0402_0OHM]  67.24 57.53 45 bottom
RA1  0_0603_5%  [R_0603]  13.67 36.35 90 top
RA2  22_0402_5%  [R_0402]  31.87 35.32 0 bottom
RA3  0_0603_5%  [R0603_0OHM]  24.71 47 270 top
RA4  0_0603_5%  [R_0603]  17.87 25.2 0 top
RA5  0_0603_5%  [R_0603]  28.2 30.66 0 bottom
RA6  0_0603_5%  [R_0603]  24.4 41.17 0 top
RA7  0_0603_5%  [R_0603]  17.1 15.05 315 top
RA8  0_0603_5%  [R0603_0OHM]  23.56 44.46 0 top
RA9  10K_0402_5%  [R_0402]  30.99 32.77 90 top
RA10  33_0402_1%  [R_0402]  30.42 32.98 270 bottom
RA11  0_0603_5%  [R0603_0OHM]  35.13 37.57 270 top
RA12  0_0402_5%  [R_0402]  25.17 30.44 0 bottom
RA13  10K_0402_5%  [R_0402]  36.78 38.87 90 top
RA15  1K_0402_1%  [R_0402]  30.94 30.52 270 top
RA16  10K_0402_5%  [R_0402]  29.99 29.6 90 top
RA17  0_0402_5%  [R_0402]  31.55 33.92 0 bottom
RA18  22_0402_5%  [R_0402]  32.47 33.03 180 bottom
RA19  0_0402_5%  [R0402_0OHM]  30.87 44.48 270 bottom
RA21  100K_0201_1%  [R_0201]  28.96 46.15 270 bottom
RA22  1K_0402_1%  [R_0402]  28.2 44.48 270 bottom
RA24  10K_0402_5%  [R_0402]  32.78 39.13 180 top
RA25  0_0402_5%  [R0402_0OHM]  31.87 36.46 0 top
RA26  2.2K_0201_5%  [R_0201]  18.81 21.86 180 bottom
RA27  33_0402_5%  [R_0402]  31.61 42.62 0 bottom
RA28  2.2K_0201_5%  [R_0201]  18.81 16.72 180 bottom
RA29  33_0402_5%  [R_0402]  31.61 42.62 0 top
RA30  33_0402_5%  [R_0402]  31.61 41.23 0 bottom
RA31  33_0402_5%  [R_0402]  31.61 40.34 0 bottom
RA32  100K_0402_1%  [R_0402]  32.78 36.46 180 bottom
RA33  33_0402_5%  [R_0402]  32.96 40.47 0 top
RA34  200K_0402_1%  [R_0402]  31.87 37.35 0 top
RA35  2_0402_1%  [R_0402]  18.27 16.62 180 top
RA36  100K_0402_1%  [R_0402]  31.87 38.24 0 top
RA37  2_0402_1%  [R_0402]  18.71 22.76 270 top
RA38  0_0201_5%  [R0201_0OHM]  17.2 28.6 180 top
RA39  0_0201_5%  [R0201_0OHM]  17.1 25.68 180 top
RA40  2.2K_0201_5%  [R_0201]  19.18 30.91 180 top
RA41  2.2K_0201_5%  [R_0201]  19.04 35.84 180 top
RA42  8.2_0402_5%~D  [R_0402]  19.54 30.02 180 top
RA43  8.2_0402_5%~D  [R_0402]  19.2 36.75 180 top
RA44  22K_0201_5%  [R_0201]  19.04 37.68 180 top
RA45  22K_0201_5%  [R_0201]  17.54 29.73 180 top
RA46  0_0201_5%  [R0201_0OHM]  16.49 24.66 0 bottom
RA47  0_0201_5%  [R0201_0OHM]  16.69 27.2 180 bottom
RA50  1K_0402_5%  [R_0402]  31.82 19.12 90 bottom
RA51  0_0402_5%  [R0402_0OHM]  27.32 20.74 270 bottom
RA52  1K_0402_5%  [R_0402]  28.72 22.71 270 bottom
RA53  1K_0402_5%  [R_0402]  30.93 19.12 90 bottom
RA55  0_0402_5%  [R0402_0OHM]  32.66 20.21 180 top
RA56  0_0402_5%  [R0402_0OHM]  32.66 21.1 180 top
RA57  0.2_0805_1%  [R_0805]  31.35 15.19 0 bottom
RA58  39K_0402_0.1%  [R_0402]  25.01 27.35 270 top
RA59  39K_0402_0.1%  [R_0402]  24.14 27.35 270 top
RA60  0.2_0805_1%  [R_0805]  22.11 12.08 90 top
RA61  39K_0402_0.1%  [R_0402]  21.55 27.35 270 top
RA62  22.1K_0402_1%  [R_0402]  29.67 22.2 270 bottom
RA63  39K_0402_0.1%  [R_0402]  20.69 27.35 270 top
RA64  39K_0402_0.1%  [R_0402]  20.16 24.5 0 top
RA65  39K_0402_0.1%  [R_0402]  20.18 23.2 0 top
RA66  10K_0402_5%  [R_0402]  27.5 27.33 270 bottom
RA67  10K_0402_5%  [R_0402]  26.61 26.42 90 bottom
RA68  0_0603_5%  [R0603_0OHM]  25.09 45.61 90 bottom
RA69  0_0603_5%  [R0603_0OHM]  28.83 44.46 90 top
RA70  10K_0402_5%  [R_0402]  28.52 24.95 270 bottom
RA73  10_0402_5%  [R_0402]  29.49 13.19 0 bottom
RA74  10_0402_5%  [R_0402]  26.87 13.65 270 top
RA75  10_0402_5%  [R_0402]  25.11 13.25 0 top
RA76  10_0402_5%  [R_0402]  20.21 15.17 270 bottom
RA77  10K_0402_0.1%  [R_0402]  25.87 27.35 270 top
RA78  10K_0402_0.1%  [R_0402]  23.28 27.35 270 top
RA79  10K_0402_0.1%  [R_0402]  22.42 27.35 270 top
RA80  10K_0402_0.1%  [R_0402]  18.9 26.49 0 top
RA81  10K_0402_0.1%  [R_0402]  20.16 25.37 0 top
RA82  10K_0402_0.1%  [R_0402]  20.79 21.44 90 top
RA83  0_0805_5%  [R0805_0OHM]  20.4 15.8 270 top
RA84  0_0201_5%  [R0201_0OHM]  15.25 25.27 270 bottom
RA85  0_0201_5%  [R_0201]  15.51 27.8 90 bottom
RC2  24.9_0402_1%  [R_0402]  141.43 81.42 180 bottom
RC9  1K_0402_5%  [R_0402]  66.98 66.05 0 top
RC30  24.9_0402_1%  [R_0402]  146.69 113.41 90 bottom
RC35  51_0402_1%  [R_0402]  67.96 69.95 270 top
RC62  49.9K_0402_1%  [R_0402]  175.65 28.6 270 bottom
RC63  49.9K_0402_1%  [R_0402]  176.09 29.11 270 top
RC65  49.9K_0402_1%  [R_0402]  174.38 28.6 270 bottom
RC66  20_0402_5%  [R_0402]  146.2 106.1 270 bottom
RC348  51_0402_1%  [R_0402]  67.91 68.16 180 top
RC353  1K_0402_5%  [R_0402]  66.98 67.01 0 top
RC354  1K_0402_1%  [R_0402]  69.68 65.07 180 top
RC355  1K_0402_1%  [R_0402]  66.13 67.78 180 top
RD5  0_0402_5%  [R0402_0OHM]  146.75 25.75 90 top
RD28  0_0402_5%  [R0402_0OHM]  145.93 41.18 90 top
RD29  0_0402_5%  [R0402_0OHM]  149.29 41.12 90 top
RD30  0_0402_5%  [R0402_0OHM]  125.99 36.67 90 top
RD35  470_0402_1%  [R_0402]  106.38 41.92 90 top
RD38  0_0402_5%  [R0402_0OHM]  144.98 26.67 270 top
RD40  0_0402_5%  [R0402_0OHM]  127.45 29.33 270 top
RE1  4.7K_0402_5%  [R_0402]  254.88 39.45 0 top
RE2  4.7K_0402_5%  [R_0402]  254.88 40.34 0 top
RE7  1K_0402_1%~D  [R_0402]  272.89 39.2 180 top
RE8  10K_0402_5%  [R_0402]  258.78 49.73 90 top
RE9  15_0402_5%  [R_0402]  67.58 14.3 90 bottom
RE10  15_0402_5%  [R_0402]  70.81 2.88 270 bottom
RE11  15_0402_5%  [R_0402]  68.52 13.21 90 bottom
RE12  10K_0402_5%~D  [R_0402]  72.01 1.84 90 bottom
RE13  10K_0402_5%~D  [R_0402]  70.74 14.12 270 bottom
RE14  10K_0402_5%~D  [R_0402]  69.47 1.97 90 bottom
RE15  100K_0402_5%  [R_0402]  256.99 43.39 0 top
RE16  100K_0402_5%  [R_0402]  267.16 50.58 270 top
RE17  100K_0402_5%  [R_0402]  259.73 49.73 90 top
RE20  10K_0402_5%  [R_0402]  77.86 2.13 90 top
RE21  100K_0402_5%  [R_0402]  263.29 50.65 270 top
RE23  100K_0402_5%  [R_0402]  257.84 47.4 180 top
RE24  0_0603_5%  [R0603_0OHM]  84.65 8.84 270 top
RE25  4.7K_0402_1%  [R_0402]  185.04 146.88 90 top
RE26  4.7K_0402_1%~D  [R_0402]  177.65 20.71 180 bottom
RE27  4.7K_0402_1%  [R_0402]  173.57 22.62 90 bottom
RE28  100K_0402_5%  [R_0402]  115.27 12.48 180 top
RE29  4.7K_0402_1%~D  [R_0402]  176.74 19.78 0 bottom
RE30  4.7K_0402_1%  [R_0402]  176.74 18.82 0 bottom
RE31  10K_0402_5%~D  [R_0402]  187.13 152.48 0 top
RE32  4.7K_0402_1%  [R_0402]  168.82 21.17 270 bottom
RE37  10K_0402_5%  [R_0402]  172.67 22.62 90 bottom
RE40  4.7K_0402_1%~D  [R_0402]  188.04 154.38 180 top
RE42  4.7K_0402_1%~D  [R_0402]  185.93 155.67 90 top
RE43  4.7K_0402_1%~D  [R_0402]  188.04 153.43 180 top
RE44  4.7K_0402_1%~D  [R_0402]  185.04 155.66 90 top
RE63  100K_0402_5%  [R_0402]  84.19 14.62 0 top
RE64  100K_0402_1%  [R_0402]  102.87 23.31 0 top
RE66  33K_0402_1%  [R_0402]  102.01 23.31 90 top
RE70  10K_0402_5%  [R_0402]  84.19 12.71 0 top
RE74  43_0402_1%  [R_0402]  84.19 16.65 0 top
RE75  10K_0402_5%  [R_0402]  102.11 3.65 270 top
RE76  43_0402_1%  [R_0402]  85.11 10.81 180 top
RE78  0_0402_5%  [R0402_0OHM]  79.95 24.22 270 top
RE79  10K_0402_5%  [R_0402]  84.19 19.57 0 top
RE83  10K_0402_5%  [R_0402]  85.11 5.6 180 top
RE84  10K_0402_5%  [R_0402]  84.19 17.54 0 top
RE85  53.6K_0402_5%  [R_0402]  84.2 18.44 0 top
RE89  0_0402_5%  [R_0402]  92.08 2.73 90 top
RE91  47K_0402_5%  [R_0402]  69.1 11.28 270 top
RE92  2.2K_0201_5%  [R_0201]  91.35 27.71 0 top
RE93  2.2K_0201_5%  [R_0201]  91.36 27.12 0 top
RE94  2.2K_0201_5%  [R_0201]  91.29 26.12 0 top
RE95  2.2K_0201_5%  [R_0201]  91.29 25.49 0 top
RE100  4.7K_0402_5%  [R_0402]  92.14 24.74 270 top
RE101  4.7K_0402_5%  [R_0402]  91.25 24.74 270 top
RE153  1K_0402_1%  [R_0402]  164.35 153.81 90 top
RE154  10K_0402_5%  [R_0402]  165.93 149.75 45 top
RE155  1K_0402_1%  [R_0402]  170.65 154.51 90 top
RE156  10K_0402_5%  [R_0402]  171.83 151.87 0 top
RE157  1K_0402_1%  [R_0402]  175.91 154.51 90 top
RE158  10K_0402_5%  [R_0402]  177.35 151.91 0 top
RE396  10K_0201_1%  [R_0201]  131.52 6.76 180 top
RE397  1M_0201_1%  [R_0201]  130.94 6.18 0 top
RE398  1M_0201_1%  [R_0201]  131.62 2.5 180 top
RE399  10K_0201_1%  [R_0201]  129.77 1.87 0 top
RE400  1M_0201_1%  [R_0201]  129.67 6.18 0 top
RE401  1M_0201_1%  [R_0201]  130.35 2.5 180 top
RE449  10K_0201_1%  [R_0201]  124.37 8.13 0 top
RE451  1M_0201_1%  [R_0201]  142.78 6.18 0 top
RE452  1M_0201_1%  [R_0201]  144.64 2.5 180 top
RE453  1M_0201_1%  [R_0201]  143.44 2.5 180 top
RE454  10K_0201_1%  [R_0201]  142.85 1.87 0 top
RE455  10K_0201_1%  [R_0201]  144.64 6.82 180 top
RE456  1M_0201_1%  [R_0201]  144.06 6.18 0 top
RE457  1M_0201_1%  [R_0201]  145.43 6.18 0 top
RE458  1M_0201_1%  [R_0201]  145.98 2.5 180 top
RE459  1M_0201_1%  [R_0201]  147.25 2.5 180 top
RE460  10K_0201_1%  [R_0201]  145.39 1.87 0 top
RE461  10K_0201_1%  [R_0201]  147.28 6.82 180 top
RE462  1M_0201_1%  [R_0201]  146.7 6.18 0 top
RE463  1M_0201_1%  [R_0201]  132.31 6.18 0 top
RE464  1M_0201_1%  [R_0201]  134.23 2.5 180 top
RE465  1M_0201_1%  [R_0201]  132.96 2.5 180 top
RE466  10K_0201_1%  [R_0201]  134.16 6.82 180 top
RE467  10K_0201_1%  [R_0201]  132.37 1.87 0 top
RE468  1M_0201_1%  [R_0201]  133.58 6.18 0 top
RE469  1M_0201_1%  [R_0201]  136.77 2.5 180 top
RE470  1M_0201_1%  [R_0201]  134.93 6.18 0 top
RE471  10K_0201_1%  [R_0201]  136.72 6.82 180 top
RE472  1M_0201_1%  [R_0201]  135.56 2.5 180 top
RE473  1M_0201_1%  [R_0201]  136.13 6.18 0 top
RE474  10K_0201_1%  [R_0201]  134.98 1.8 0 top
RE475  1M_0201_1%  [R_0201]  126.04 13.93 180 top
RE476  10K_0201_1%  [R_0201]  126.04 18.25 180 top
RE477  1M_0201_1%  [R_0201]  124.18 17.61 0 top
RE478  1M_0201_1%  [R_0201]  125.45 17.61 0 top
RE479  1M_0201_1%  [R_0201]  124.77 13.93 180 top
RE480  10K_0201_1%  [R_0201]  124.18 13.3 0 top
RE481  1M_0201_1%  [R_0201]  142.1 2.5 180 top
RE482  10K_0201_1%  [R_0201]  142 6.82 180 top
RE483  1M_0201_1%  [R_0201]  140.15 6.18 0 top
RE484  1M_0201_1%  [R_0201]  141.42 6.18 0 top
RE485  1M_0201_1%  [R_0201]  140.83 2.5 180 top
RE486  10K_0201_1%  [R_0201]  140.25 1.8 0 top
RE487  1M_0201_1%  [R_0201]  128.96 2.5 180 top
RE488  10K_0201_1%  [R_0201]  128.89 6.76 180 top
RE489  1M_0201_1%  [R_0201]  127.04 6.18 0 top
RE490  1M_0201_1%  [R_0201]  128.31 6.18 0 top
RE491  1M_0201_1%  [R_0201]  127.69 2.5 180 top
RE492  10K_0201_1%  [R_0201]  127.1 1.87 0 top
RE493  1M_0201_1%  [R_0201]  139.5 2.5 180 top
RE494  1M_0201_1%  [R_0201]  137.52 6.18 0 top
RE495  10K_0201_1%  [R_0201]  139.37 6.82 180 top
RE496  1M_0201_1%  [R_0201]  138.23 2.5 180 top
RE497  1M_0201_1%  [R_0201]  138.79 6.18 0 top
RE498  10K_0201_1%  [R_0201]  137.64 1.87 0 top
RE499  1M_0201_1%  [R_0201]  124.4 6.18 0 top
RE500  1M_0201_1%  [R_0201]  126.35 2.5 180 top
RE501  1M_0201_1%  [R_0201]  125.08 2.5 180 top
RE502  10K_0201_1%  [R_0201]  126.25 6.76 180 top
RE503  10K_0201_1%  [R_0201]  124.5 1.87 0 top
RE504  1M_0201_1%  [R_0201]  125.67 6.18 0 top
RE505  1M_0201_1%  [R_0201]  123.69 2.5 180 top
RE506  1M_0201_1%  [R_0201]  121.78 6.13 0 top
RE507  10K_0201_1%  [R_0201]  123.64 6.82 180 top
RE508  1M_0201_1%  [R_0201]  122.42 2.5 180 top
RE509  1M_0201_1%  [R_0201]  123.05 6.18 0 top
RE510  10K_0201_1%  [R_0201]  121.83 1.87 0 top
RE512  1M_0201_1%  [R_0201]  125.67 11.64 0 top
RE513  1K_0201_1%  [R_0201]  126.25 12.25 180 top
RE530  47K_0402_5%  [R_0402]  119.2 6.81 90 top
RE531  1K_0201_1%  [R_0201]  131.5 12.34 180 top
RE532  1M_0201_1%  [R_0201]  130.91 11.71 0 top
RE533  10K_0201_1%  [R_0201]  129.57 8.09 0 top
RE534  1K_0201_1%  [R_0201]  134.23 18.38 180 top
RE535  1M_0201_1%  [R_0201]  133.64 17.74 0 top
RE536  1K_0201_1%  [R_0201]  140.58 18.31 180 top
RE537  1M_0201_1%  [R_0201]  139.99 17.68 0 top
RE538  10K_0201_1%  [R_0201]  138.13 16.57 270 top
RE539  10K_0201_1%  [R_0201]  134.67 13.99 180 top
RE540  1K_0201_1%  [R_0201]  130.99 18.38 180 top
RE541  1M_0201_1%  [R_0201]  130.41 17.74 0 top
RE542  10K_0201_1%  [R_0201]  129.45 13.93 0 top
RE543  10K_0201_1%  [R_0201]  125.64 8.13 0 top
RE544  10K_0201_1%  [R_0201]  130.91 8.09 0 top
RE545  10K_0201_1%  [R_0201]  133.4 13.99 180 top
RE546  10K_0201_1%  [R_0201]  138.13 15.3 270 top
RE547  10K_0201_1%  [R_0201]  130.72 13.93 0 top
RE639  1.1K_0402_1%  [R_0402]  180.47 16.1 180 bottom
RE640  1K_0201_1%  [R_0201]  178.83 15.92 180 bottom
RE641  1M_0201_1%  [R_0201]  176.67 14.71 270 bottom
RE642  4.7K_0402_5%  [R_0402]  95.26 2.68 90 top
RE643  4.7K_0402_5%  [R_0402]  96.15 2.68 90 top
RE644  100K_0402_5%  [R_0402]  122.32 15.44 90 top
RE645  10K_0402_5%  [R_0402]  80.48 13.87 180 top
RE646  0_0201_5%  [R0201_0OHM]  88.85 3.55 270 top
RE647  10K_0402_5%  [R_0402]  121.06 6.83 90 top
RE650  10K_0402_5%  [R_0402]  147.22 17.55 180 top
RE651  10K_0402_5%  [R_0402]  169.43 166.62 180 top
RF1  10K_0402_5%  [R_0402]  63.36 54.78 0 top
RF2  10K_0402_5%  [R_0402]  66.57 54.78 180 top
RF3  10K_0402_5%  [R_0402]  62.45 58.7 180 top
RF4  10K_0402_5%  [R_0402]  245 82.05 90 bottom
RF5  10K_0402_5%  [R_0402]  245 84.75 270 bottom
RF6  10K_0402_5%  [R_0402]  243.66 86.88 90 bottom
RG1  0_0201_5%  [R_0201]  185.88 68.03 270 bottom
RG2  10K_0201_5%  [R_0201]  173.56 96.07 270 bottom
RG3  10K_0201_5%  [R_0201]  184.85 58.83 0 bottom
RG6  10K_0201_5%  [R_0201]  183.59 64.36 270 bottom
RG7  0_0201_5%  [R_0201]  183.89 60.98 180 bottom
RG8  10K_0201_5%  [R_0201]  183.34 76.52 270 bottom
RG9  10K_0201_5%  [R_0201]  185.62 79.02 90 top
RG11  1.8K_0402_1%  [R_0402]  189.05 70.78 270 bottom
RG12  1.8K_0402_1%  [R_0402]  187.34 73.38 180 bottom
RG13  10K_0201_5%  [R_0201]  186.09 58.83 0 bottom
RG14  10K_0201_5%  [R_0201]  178.58 61.8 90 bottom
RG15  10K_0201_5%  [R_0201]  183.95 75.34 180 bottom
RG16  100K_0201_5%  [R_0201]  182.65 75.82 270 top
RG17  1.8K_0402_5%  [R_0402]  183.59 66.2 270 bottom
RG18  1.8K_0402_5%  [R_0402]  187.34 65.04 90 bottom
RG19  1.8K_0402_5%  [R_0402]  181.55 84.92 0 top
RG20  1.8K_0402_5%  [R_0402]  183.43 84.12 90 top
RG21  10K_0201_5%  [R_0201]  188.1 65.2 90 bottom
RG22  10K_0201_5%  [R_0201]  184.99 81.47 270 top
RG23  2.49K_0402_1%  [R_0402]  174.88 108.29 0 bottom
RG24  100K_0201_5%  [R_0201]  183.66 81.47 270 top
RG25  1M_0201_1%  [R_0201]  174.73 94.7 0 bottom
RG26  10K_0201_5%  [R_0201]  175.3 91.91 0 bottom
RG36  1K_0402_1%  [R_0402]  183.59 94.7 180 top
RG37  1K_0402_1%  [R_0402]  180.42 93.14 180 top
RG38  1K_0402_1%  [R_0402]  180.61 89.76 225 top
RG47  10K_0402_5%  [R_0402]  211.15 138.15 270 top
RG48  10K_0402_5%  [R_0402]  181.1 137.18 0 top
RG49  10K_0402_5%  [R_0402]  237.83 109.88 180 top
RG50  10K_0402_5%  [R_0402]  214.07 138.34 270 top
RG51  10K_0402_5%  [R_0402]  235.42 78.38 180 top
RG52  10K_0402_5%  [R_0402]  235.98 106.27 270 top
RG53  10K_0402_5%  [R_0402]  181.17 134.96 0 top
RG54  10K_0402_5%  [R_0402]  211.02 135.36 270 top
RG55  10K_0402_5%  [R_0402]  214.07 134.72 270 top
RG56  10K_0402_5%  [R_0402]  235.54 109.74 90 top
RG57  10K_0402_5%  [R_0402]  234.61 107.15 0 top
RG58  10K_0402_5%  [R_0402]  234.51 79.34 0 top
RG59  10_0402_1%  [R_0402]  207.61 76.29 180 bottom
RG60  1.8K_0402_1%  [R_0402]  197.05 74.19 0 bottom
RG61  1.8K_0402_1%  [R_0402]  197.05 75.08 0 bottom
RG62  10_0402_1%  [R_0402]  207.61 74.95 180 bottom
RG63  10K_0402_1%  [R_0402]  197.04 75.97 0 bottom
RG64  10_0402_1%  [R_0402]  207.67 73.18 180 bottom
RG65  10K_0402_1%  [R_0402]  198.16 72.4 90 bottom
RG66  10_0402_1%  [R_0402]  207.67 72.22 180 bottom
RG67  40.2_0402_1%  [R_0402]  204.55 109.19 270 top
RG68  40.2_0402_1%  [R_0402]  204.7 110.06 90 top
RG69  60.4_0402_1%  [R_0402]  204.55 111.84 90 top
RG70  10K_0402_5%  [R_0402]  195.99 68.99 180 bottom
RG71  4.7K_0402_5%  [R_0402]  193.17 68.99 0 bottom
RG74  10K_0402_5%  [R_0402]  165.83 73.11 180 bottom
RG75  33_0402_5%~D  [R_0402]  170.12 78.19 0 bottom
RG76  33_0402_5%~D  [R_0402]  165.81 73.99 90 bottom
RG77  33_0402_5%~D  [R_0402]  170.05 77.11 0 bottom
RG78  100K_0402_1%  [R_0402]  180.23 78.46 270 top
RG79  100K_0402_1%  [R_0402]  176.93 77.55 90 top
RG80  100K_0402_1%  [R_0402]  176.93 74.01 270 bottom
RG81  100K_0402_1%  [R_0402]  175.97 74.01 270 bottom
RG82  100K_0402_1%  [R_0402]  176.93 81.18 270 top
RG83  100K_0402_1%  [R_0402]  181.12 78.46 270 top
RG84  10K_0402_1%  [R_0402]  172.4 76.92 0 bottom
RG85  10K_0402_1%  [R_0402]  171.27 85.25 270 bottom
RG86  10K_0402_1%  [R_0402]  172.4 77.94 0 bottom
RG87  10K_0402_1%  [R_0402]  173.32 76.03 180 bottom
RG88  10K_0402_1%  [R_0402]  172.23 84.34 90 bottom
RG89  10K_0402_1%  [R_0402]  173.32 78.89 180 bottom
RG90  100K_0402_1%  [R_0402]  179.27 77.55 90 top
RG91  100K_0402_1%  [R_0402]  177.94 78.46 270 top
RG92  100K_0402_1%  [R_0402]  176.93 75.26 90 bottom
RG93  100K_0402_1%  [R_0402]  175.97 75.26 90 bottom
RG94  100K_0402_1%  [R_0402]  177.88 82.07 180 top
RG95  100K_0402_1%  [R_0402]  182.07 77.55 90 top
RG98  100K_0402_5%~D  [R_0402]  174.58 76.17 270 bottom
RG99  10M_0402_5%  [R_0402]  174.83 82.21 270 bottom
RG101  10K_0402_5%  [R_0402]  180.72 83.46 0 top
RG102  40.2_0402_1%  [R_0402]  197.94 134.01 180 top
RG103  40.2_0402_1%  [R_0402]  193.31 133.18 0 top
RG104  1K_0402_1%  [R_0402]  211.98 135.36 270 top
RG105  1K_0402_1%  [R_0402]  179.4 135.84 90 top
RG106  1K_0402_1%  [R_0402]  202.2 135.61 270 top
RG107  1K_0402_1%  [R_0402]  186.89 136.54 90 top
RG108  121_0402_1%  [R_0402]  198.39 136.31 270 top
RG109  121_0402_1%  [R_0402]  192.48 135.97 90 top
RG110  549_0402_1%  [R_0402]  193.5 137.07 270 bottom
RG111  931_0402_1%  [R_0402]  195.66 136.1 180 bottom
RG112  1.33K_0402_1%  [R_0402]  193.56 135.29 270 bottom
RG113  40.2_0402_1%  [R_0402]  235.03 121.82 90 top
RG114  40.2_0402_1%  [R_0402]  228.42 133.18 0 bottom
RG115  1K_0402_1%  [R_0402]  236.68 108.29 270 top
RG116  1K_0402_1%  [R_0402]  214.07 135.65 90 top
RG117  1K_0402_1%  [R_0402]  236.23 113.31 180 top
RG118  1K_0402_1%  [R_0402]  221.38 135.84 90 top
RG119  121_0402_1%  [R_0402]  236.98 121.63 0 top
RG120  121_0402_1%  [R_0402]  228.23 136.35 90 bottom
RG121  549_0402_1%  [R_0402]  238.47 122.33 180 bottom
RG122  931_0402_1%  [R_0402]  238.47 123.21 180 bottom
RG123  1.33K_0402_1%  [R_0402]  236.63 124.1 180 bottom
RG124  40.2_0402_1%  [R_0402]  234.77 87.08 90 top
RG125  40.2_0402_1%  [R_0402]  234.96 91.46 270 top
RG126  1K_0402_1%  [R_0402]  234.57 73.49 0 top
RG127  1K_0402_1%  [R_0402]  234.52 105.36 90 top
RG128  1K_0402_1%  [R_0402]  235.21 80.73 0 top
RG129  1K_0402_1%  [R_0402]  234.57 97.94 0 top
RG130  121_0402_1%  [R_0402]  234.95 84.73 0 top
RG131  121_0402_1%  [R_0402]  234.89 93.88 0 top
RG132  549_0402_1%  [R_0402]  232.73 91.15 0 bottom
RG133  931_0402_1%  [R_0402]  235.55 91.15 180 bottom
RG134  1.33K_0402_1%  [R_0402]  234.63 89.37 0 bottom
RG137  10_0402_1%  [R_0402]  201.75 68.53 90 bottom
RG138  10_0402_1%  [R_0402]  202.64 68.53 90 bottom
RG146  33_0402_5%~D  [R_0402]  164.59 67.65 0 bottom
RG147  10K_0402_5%  [R_0402]  165.44 69.94 180 bottom
RG148  33_0402_5%~D  [R_0402]  172.4 67.33 0 bottom
RG149  33_0402_5%~D  [R_0402]  172.4 66 0 bottom
RG150  100K_0201_5%  [R_0201]  184.28 83.48 315 top
RG151  100K_0201_5%  [R_0201]  180.23 79.49 90 top
RG500  10K_0201_5%  [R_0201]  173.75 73.1 90 bottom
RG501  100K_0201_5%  [R_0201]  185.31 76.52 270 bottom
RG502  10K_0201_5%  [R_0201]  178.13 75.32 90 bottom
RG503  10K_0201_5%  [R_0201]  183.66 79.21 90 top
RG504  10K_0201_5%  [R_0201]  185.78 74.36 0 top
RG505  10K_0201_5%  [R_0201]  187.78 59.69 270 top
RG506  10K_0201_5%  [R_0201]  183.62 61.58 90 top
RG509  10K_0402_5%  [R_0402]  177.42 62.44 0 top
RG510  51_0402_5%  [R_0402]  177.8 58.57 0 top
RG511  10K_0402_5%  [R_0402]  174.63 62.44 0 top
RG512  51_0402_5%  [R_0402]  175.58 58.57 0 top
RG513  10K_0402_5%  [R_0402]  171.77 62.44 0 top
RG514  51_0402_5%  [R_0402]  172.99 57.61 90 top
RG515  10K_0402_5%  [R_0402]  190.39 81.13 270 top
RG516  10K_0201_5%  [R_0201]  181.59 60.03 0 top
RG517  10K_0201_5%  [R_0201]  181.32 73.75 180 bottom
RG518  10K_0201_5%  [R_0201]  174.73 94.07 0 bottom
RG519  100K_0201_5%  [R_0201]  177.6 75.02 180 top
RG522  10K_0201_5%  [R_0201]  185.62 81.47 270 top
RG523  40.2_0402_1%  [R_0402]  197.94 133.12 180 top
RG524  40.2_0402_1%  [R_0402]  193.31 134.07 0 top
RG525  40.2_0402_1%  [R_0402]  235.98 121.82 90 top
RG526  40.2_0402_1%  [R_0402]  228.42 134.07 0 bottom
RG527  40.2_0402_1%  [R_0402]  235.73 87.08 90 top
RG528  40.2_0402_1%  [R_0402]  235.92 91.46 270 top
RG529  0_0201_5%  [R_0201]  197.47 76.8 180 bottom
RG535  100K_0201_5%  [R_0201]  166.83 60.13 270 top
RG536  2.2K_0201_5%  [R_0201]  163.65 61.97 270 top
RG537  0_0201_5%  [R_0201]  183.59 61.71 90 bottom
RG538  0_0201_5%  [R_0201]  170.17 76.29 180 bottom
RG539  0_0201_5%  [R_0201]  164.92 73.9 90 bottom
RG541  10K_0402_5%  [R_0402]  190.02 48.47 180 top
RG542  100_0402_1%  [R_0402]  188.83 44.53 90 top
RG543  10K_0402_5%  [R_0402]  220.54 30.44 0 top
RG544  100_0402_1%  [R_0402]  220.16 25.3 0 top
RG545  68K_0402_1%  [R_0402]  97.26 68.16 0 top
RG546  100K_0201_5%  [R_0201]  190.58 79.15 180 top
RG549  15K_0402_5%  [R_0402]  184.39 56.55 0 top
RG550  100K_0402_5%  [R_0402]  182.74 57.25 180 top
RG551  0_0201_5%  [R_0201]  93.14 62.89 180 top
RG552  0_0201_5%  [R_0201]  93.14 63.52 180 top
RG553  0_0201_5%  [R_0201]  187.91 56.63 90 top
RG554  0_0201_5%  [R_0201]  186.17 60.03 180 top
RG555  0_0402_5%  [R_0402]  174.91 80.16 270 bottom
RG556  0_0402_5%  [R_0402]  174.91 77.48 90 bottom
RG557  10K_0402_5%  [R_0402]  187.83 75.91 270 top
RG558  10K_0201_1%  [R_0201]  167.77 25.14 180 bottom
RG559  10K_0201_1%  [R_0201]  167.76 23.32 180 bottom
RG561  100K_0201_5%  [R_0201]  185.75 55.7 0 top
RG562  100K_0402_5%  [R_0402]  185.7 62.83 0 bottom
RG563  0_0201_5%  [R_0201]  188.74 53.76 90 top
RG564  0_0201_5%  [R_0201]  183.02 80.36 270 top
RG565  0_0201_5%  [R_0201]  183.66 77.89 90 top
RG566  0_0201_5%  [R_0201]  183.93 76.54 270 bottom
RG567  0_0201_5%  [R_0201]  117.01 12.1 180 top
RG568  0_0201_5%  [R_0201]  120.59 15.69 270 top
RG569  0_0201_5%  [R_0201]  116.42 12.71 0 top
RG570  0_0201_5%  [R_0201]  120.01 15.69 270 top
RH1  1K_0402_1%  [R_0402]  67.91 65.07 180 top
RH2  10K_0402_5%  [R_0402]  174 48.82 270 top
RH4  0_0402_5%  [R_0402]  182.88 46.58 0 top
RH5  1K_0402_5%  [R_0402]  180.03 57.18 270 bottom
RH6  0_0603_5%  [R_0603]  168.23 37.74 0 top
RH7  0_0603_5%  [R_0603]  179.15 44.98 180 top
RH9  100K_0402_5%  [R_0402]  185.04 52.86 270 bottom
RH12  0_0805_5%  [R0805_0OHM]  157.01 44.27 0 top
RH16  1K_0402_1%  [R_0402]  179.33 52.48 0 top
RH23  10K_0201_5%  [R_0201]  174.35 38.76 0 top
RH24  10K_0201_5%  [R_0201]  174.35 39.39 0 top
RH25  10K_0201_5%  [R_0201]  173.04 31.89 0 top
RH26  10K_0201_5%  [R_0201]  173.01 31.2 0 top
RH38  30_0402_5%  [R_0402]  176.22 57.14 270 bottom
RH39  30_0402_5%  [R_0402]  176.22 59.56 270 bottom
RH57  49.9_0402_1%  [R_0402]  99.43 100.09 0 bottom
RH58  49.9_0402_1%  [R_0402]  99.43 101.87 0 bottom
RH59  49.9_0402_1%  [R_0402]  100.35 100.98 180 bottom
RH70  10M_0402_5%  [R_0402]  184.15 49.24 270 bottom
RH71  2.7K_0402_1%  [R_0402]  161.94 55.69 180 bottom
RH72  1M_0402_5%~D  [R_0402]  158.75 55.7 0 bottom
RH73  12.1_0402_1%  [R_0402]  174.7 56.22 90 bottom
RH75  1K_0402_5%  [R_0402]  186.34 36.22 180 top
RH78  1K_0402_5%  [R_0402]  186.34 35.33 180 top
RH79  620_0402_5%  [R_0402]  171.62 56.83 180 bottom
RH83  20K_0402_5%~D  [R_0402]  181.43 47.11 270 top
RH84  20K_0402_5%~D  [R_0402]  181.62 48.85 90 top
RH85  8.2K_0402_5%  [R_0402]  185.42 40.67 0 top
RH88  10K_0402_5%  [R_0402]  178.25 49.87 270 top
RH89  22_0402_5%  [R_0402]  185.89 42.13 180 bottom
RH90  100K_0402_5%  [R_0402]  177.3 49.43 270 top
RH104  15_0402_1%  [R_0402]  186.14 32.35 180 bottom
RH109  113_0402_1%  [R_0402]  171.47 55.04 90 bottom
RH111  10K_0402_5%~D  [R_0402]  187.91 41.65 270 bottom
RH135  10K_0402_5%  [R_0402]  186.33 43.45 180 top
RH148  121_0402_1%  [R_0402]  143.27 81.42 180 bottom
RH149  75_0402_1%  [R_0402]  139.64 81.35 90 bottom
RH150  100_0402_1%  [R_0402]  138.75 81.35 90 bottom
RH151  100_0402_1%  [R_0402]  97.21 110.31 0 bottom
RH152  56.2_0402_1%  [R_0402]  97.21 111.27 0 bottom
RH153  220_0402_5%  [R_0402]  98.12 112.22 180 bottom
RH154  60.4_0402_1%  [R_0402]  144.74 92.23 90 top
RH155  20_0402_5%  [R_0402]  97.21 108.28 0 bottom
RH156  51_0402_5%  [R_0402]  99.37 105.62 0 bottom
RH158  499_0402_1%  [R_0402]  99.44 107.59 0 bottom
RH163  1K_0402_5%  [R_0402]  138.67 106.89 180 top
RH164  1K_0402_5%  [R_0402]  144.74 90.45 90 top
RH165  1K_0402_5%  [R_0402]  97.21 107.33 0 bottom
RH166  49.9_0402_1%  [R_0402]  97.22 106.45 0 bottom
RH167  30_0402_5%  [R_0402]  143.91 99.8 180 top
RH184  1K_0402_5%  [R_0402]  103.73 103.16 180 top
RH185  1K_0402_5%  [R_0402]  100.35 96.92 180 bottom
RH186  1K_0402_5%  [R_0402]  105.24 97.49 180 top
RH187  1K_0402_5%  [R_0402]  100.35 97.87 180 bottom
RH192  30_0402_5%  [R_0402]  143.91 101.49 180 top
RH193  100_0402_1%  [R_0402]  157.93 41.67 90 bottom
RH197  100_0402_1%  [R_0402]  126.07 114.01 90 bottom
RH199  100K_0402_5%  [R_0402]  180.3 34 180 top
RH201  100_0402_1%  [R_0402]  143.85 115.81 270 bottom
RH203  100_0402_1%  [R_0402]  121.88 114.01 90 bottom
RH206  1K_0402_1%~D  [R_0402]  123.89 42.16 270 top
RH207  1K_0402_1%~D  [R_0402]  122.99 29.32 0 top
RH209  1K_0402_1%~D  [R_0402]  125.67 41.25 90 top
RH210  1K_0402_1%~D  [R_0402]  124.77 28.43 0 top
RH211  24.9_0402_1%  [R_0402]  124.78 44.38 270 top
RH212  24.9_0402_1%  [R_0402]  124.77 27.48 0 top
RH453  10K_0402_5%  [R_0402]  184.97 45.1 0 bottom
RH460  1K_0402_5%  [R_0402]  174.5 22.61 90 bottom
RH461  1K_0402_5%  [R_0402]  175.39 22.61 90 bottom
RH462  1K_0402_5%  [R_0402]  179.77 28.2 90 top
RH463  1K_0402_5%  [R_0402]  177.99 28.2 90 top
RH466  100_0402_1%  [R_0402]  124.21 114.9 270 bottom
RH469  100_0402_1%  [R_0402]  142.96 115.81 270 bottom
RH472  100_0402_1%  [R_0402]  123.32 114.9 270 bottom
RH484  2_0402_1%  [R_0402]  126.56 42.16 270 top
RH485  2_0402_1%  [R_0402]  122.99 28.43 0 top
RH489  1K_0402_5%  [R_0402]  184.15 56.26 90 bottom
RH493  2.2K_0402_5%  [R_0402]  183.27 56.26 90 bottom
RH494  51_0402_5%  [R_0402]  99.37 103.65 0 bottom
RH495  51_0402_5%  [R_0402]  97.42 104.39 270 bottom
RH496  51_0402_5%  [R_0402]  99.37 104.66 0 bottom
RH497  51_0402_5%  [R_0402]  99.44 108.48 0 bottom
RH501  499_0402_1%  [R_0402]  181.93 31.88 180 top
RH502  499_0402_1%  [R_0402]  181.93 32.77 180 top
RH506  1M_0402_5%  [R_0402]  185.42 42.45 0 top
RH512  10K_0402_5%  [R_0402]  170.58 28.35 180 bottom
RH513  10K_0402_5%  [R_0402]  172.6 29.11 270 top
RH515  8.2K_0402_5%  [R_0402]  184.97 46.05 0 bottom
RH516  10K_0402_5%  [R_0402]  174.12 28.2 90 top
RH518  10K_0402_5%~D  [R_0402]  173.82 45.47 90 top
RH519  0_0402_5%~D  [R_0402]  97.21 109.3 0 bottom
RH521  10K_0402_5%  [R_0402]  175.14 28.2 90 top
RH525  330K_0402_5%  [R_0402]  93.59 76.29 180 top
RH531  1M_0402_5%  [R_0402]  182.22 47.99 180 top
RH533  8.2K_0402_5%  [R_0402]  184.97 43.51 0 bottom
RH537  10K_0201_5%  [R_0201]  173.49 28.6 270 bottom
RH545  10K_0402_5%  [R_0402]  184.97 47 0 bottom
RH571  8.2K_0402_5%  [R_0402]  180.91 57.24 0 bottom
RH580  1K_0402_5%  [R_0402]  172.23 49.41 90 top
RH581  1K_0402_5%  [R_0402]  172.48 55.02 90 bottom
RH584  10K_0402_5%  [R_0402]  168.09 28.15 0 top
RH585  10K_0402_5%  [R_0402]  169 29.11 180 top
RL1  4.7K_0402_5%~D  [R_0402]  199.04 154.6 270 bottom
RL2  30K_0402_5%  [R_0402]  198.19 153.31 0 top
RL3  2.37K_0402_1%~D  [R_0402]  204.86 152.78 90 bottom
RL4  5.1K_0402_1%~D  [R_0402]  199.34 152.41 180 top
RL5  10K_0402_5%  [R_0402]  192.79 148.93 270 bottom
RL8  330_0402_5%  [R_0402]  208.62 160.43 180 bottom
RL9  75_0402_1%~D  [R_0402]  219.91 159.03 90 bottom
RL10  75_0402_1%~D  [R_0402]  218.71 159.03 90 bottom
RL11  75_0402_1%~D  [R_0402]  212.29 159.03 90 bottom
RL12  75_0402_1%~D  [R_0402]  211.09 159.03 90 bottom
RL13  130_0402_1%~D  [R_0402]  231.83 157.24 0 bottom
RL14  1K_0402_1%~D  [R_0402]  235.16 158.13 180 bottom
RL15  130_0402_5%~D  [R_0402]  231.83 159.15 0 bottom
RM5  10K_0402_5%  [R_0402]  125.92 167.01 90 bottom
RM6  10K_0402_5%  [R_0402]  130.38 165.94 180 bottom
RM14  1K_0201_1%  [R_0201]  95.16 150.77 0 bottom
RM17  100K_0402_5%  [R_0402]  130.37 167.01 90 bottom
RM18  2.2_0402_1%  [R_0402]  93.86 152.81 270 bottom
RM20  1K_0402_1%  [R_0402]  90.24 141.99 90 bottom
RM21  1K_0402_1%  [R_0402]  92.14 141.86 90 bottom
RM23  1K_0201_1%  [R_0201]  109.46 153.82 180 bottom
RM25  475_0402_1%  [R_0402]  90.75 152.81 270 bottom
RM26  1K_0201_1%  [R_0201]  109.46 153.25 180 bottom
RM27  33_0402_1%  [R_0402]  88.33 152.81 270 bottom
RM28  33_0402_1%  [R_0402]  87.32 152.81 270 bottom
RM29  49.9_0402_1%  [R_0402]  86.3 154.18 90 bottom
RM31  100K_0402_5%  [R_0402]  293.66 59.23 0 top
RM38  49.9_0402_1%  [R_0402]  89.41 154.18 90 bottom
RM41  100K_0402_5%  [R_0402]  118.94 166.94 90 bottom
RM42  470K_0402_5%  [R_0402]  119.84 166.09 270 bottom
RM61  20K_0402_5%  [R_0402]  108.78 147.51 90 bottom
RM62  1K_0201_1%  [R_0201]  108.03 144.45 90 bottom
RM64  1K_0201_1%  [R_0201]  108.88 152.04 0 bottom
RM66  1K_0201_1%  [R_0201]  108.88 152.68 0 bottom
RM70  1K_0201_1%  [R_0201]  98.82 144.45 90 bottom
RM72  10K_0201_1%  [R_0201]  95.16 152.17 0 bottom
RM75  1K_0201_1%  [R_0201]  108.03 143.06 270 bottom
RM76  1K_0201_1%  [R_0201]  98.24 144.46 90 bottom
RM79  1K_0201_1%  [R_0201]  108.73 143.06 270 bottom
RM81  1K_0201_1%  [R_0201]  97.55 144.45 90 bottom
RM82  1K_0201_1%  [R_0201]  109.46 154.52 180 bottom
RM84  1K_0201_1%  [R_0201]  96.98 144.45 90 bottom
RM85  1K_0201_1%  [R_0201]  109.46 155.22 180 bottom
RM86  1K_0201_1%  [R_0201]  108.73 144.45 90 bottom
RM87  10K_0201_1%  [R_0201]  95.75 151.47 180 bottom
RM89  0_0402_5%  [R_0402]  135.78 166.57 90 bottom
RM90  0_0402_5%  [R_0402]  136.67 166.57 90 bottom
RM91  549_0402_1%  [R_0402]  125.3 159.72 180 bottom
RM92  100K_0402_5%~D  [R_0402]  126.17 159.72 0 bottom
RM93  100_0402_1%  [R_0402]  132.23 158.48 90 bottom
RM94  100K_0402_5%~D  [R_0402]  133.12 158.48 90 bottom
RM96  4.7K_0402_5%  [R_0402]  91.19 141.86 90 bottom
RM97  0_0402_5%  [R_0402]  143.45 167.03 0 top
RM98  0_0402_5%  [R_0402]  143.45 167.92 0 top
RM99  0_0402_5%  [R_0402]  109.69 150.2 180 bottom
RM100  0_0402_5%  [R_0402]  109.69 151.09 180 bottom
RN5  10K_0402_5%  [R_0402]  295.22 64.76 270 top
RN15  0_0201_5%  [R_0201]  294.77 61.91 270 top
RN16  10K_0402_5%  [R_0402]  293.83 54.49 90 top
RN17  0_0201_5%  [R_0201]  291.63 60.16 0 top
RP2  33_0804_8P4R_5%  [RP_0804_8P4R]  182.07 25.56 90 top
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  186.51 41.04 180 bottom
RP5  10K_0804_8P4R_5%  [RP_0804_8P4R]  186.51 38.06 180 bottom
RPH5  15_0804_8P4R_5%  [RP_0804_8P4R]  186.51 35.01 180 bottom
RPH6  10K_8P4R_5%  [RP_0804_8P4R]  169.57 26.96 270 bottom
RPT1  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  159.51 147.85 90 bottom
RT1  0_0201_5%  [R0201_0OHM]  156.52 162.14 180 top
RT2  0_0201_5%  [R_0201]  145.75 144.78 270 bottom
RT3  3.01K_0201_1%  [R_0201]  156.1 148.2 90 top
RT4  1M_0201_1%  [R_0201]  142.16 155.2 180 top
RT5  14K_0402_1%  [R_0402]  146.24 155.1 270 bottom
RT6  10K_0201_5%  [R_0201]  141.16 148.71 270 top
RT7  10K_0201_5%  [R_0201]  140.53 148.71 270 top
RT8  10K_0201_5%  [R_0201]  139.89 148.71 270 top
RT9  10K_0201_5%  [R_0201]  139.26 148.71 270 top
RT10  0_0201_5%  [R0201_0OHM]  140.55 151.65 90 top
RT11  1M_0201_1%  [R_0201]  141.14 150 180 top
RT12  0_0201_5%  [R_0201]  144.63 156.21 270 bottom
RT13  0_0201_5%  [R0201_0OHM]  137.51 152.67 0 top
RT14  0_0201_5%  [R_0201]  139.35 152.86 0 top
RT15  0_0201_5%  [R0201_0OHM]  142.66 157.5 0 bottom
RT16  0_0201_5%  [R_0201]  139.93 154.19 180 top
RT17  100_0201_5%  [R_0201]  139.93 156.22 180 top
RT18  100_0201_5%  [R_0201]  145.04 148.77 270 top
RT19  14K_0402_1%  [R_0402]  151.64 151.22 0 bottom
RT20  10K_0201_5%  [R_0201]  146.37 144.19 90 bottom
RT21  10K_0201_5%  [R_0201]  144.5 162.39 0 bottom
RT22  0_0201_5%  [R_0201]  128.09 146.07 270 bottom
RT23  0_0201_5%  [R0201_0OHM]  138.09 154.67 180 top
RT24  10K_0201_5%  [R_0201]  145.11 144.19 90 bottom
RT25  4.75K_0402_0.5%  [R_0402]  147.56 158.66 270 bottom
RT26  3.3K_0201_5%  [R_0201]  141.58 153.42 0 top
RT27  3.3K_0201_5%  [R_0201]  141.58 153.99 0 top
RT28  10K_0201_5%  [R_0201]  141.12 152.24 270 top
RT29  10K_0201_5%  [R_0201]  141.69 152.24 270 top
RT30  10K_0201_5%  [R_0201]  143.25 158.14 180 bottom
RT31  10K_0201_5%  [R_0201]  139.93 153.43 180 top
RT32  10K_0201_5%  [R_0201]  140.12 154.3 180 bottom
RT33  10K_0201_5%  [R_0201]  139.35 155.46 0 top
RT34  100K_0201_5%  [R_0201]  141.72 152.85 180 top
RT35  100K_0201_5%  [R_0201]  137.51 153.43 0 top
RT36  100K_0201_5%  [R_0201]  139.93 154.83 180 top
RT37  100K_0201_5%  [R_0201]  144.03 156.22 270 bottom
RT38  100K_0201_5%  [R_0201]  141.14 149.37 180 top
RT39  100K_0201_5%  [R_0201]  146.89 150.58 270 bottom
RT40  1M_0201_1%  [R_0201]  145.93 162.85 90 top
RT41  100K_0201_5%  [R_0201]  137.51 154.07 0 top
RT42  1M_0201_1%  [R_0201]  145.37 164.72 270 top
RT43  499_0201_1%  [R_0201]  151.74 159.01 135 bottom
RT44  499_0201_1%  [R_0201]  152.15 159.42 135 bottom
RT45  100K_0201_5%  [R_0201]  145.36 162.85 90 top
RT46  100K_0201_5%  [R_0201]  146.51 162.85 90 top
RT47  100K_0201_5%  [R_0201]  142.16 154.63 180 top
RT48  3.3K_0402_5%  [R_0402]  139.46 153.06 270 bottom
RT49  3.3K_0402_5%  [R_0402]  137.99 152.15 90 bottom
RT50  3.3K_0402_5%  [R_0402]  137.05 153.07 270 bottom
RT51  3.3K_0402_5%  [R_0402]  133.71 145.76 45 bottom
RT53  0_0402_5%  [R0402_0OHM]  119.77 143.21 0 bottom
RT57  10K_0201_5%  [R_0201]  123.52 145.31 90 bottom
RT58  10K_0201_5%  [R_0201]  126.25 145.31 90 bottom
RT59  0_0201_5%  [R0201_0OHM]  125.36 145.31 90 bottom
RT60  0_0201_5%  [R0201_0OHM]  124.41 145.31 90 bottom
RT61  0_0201_5%  [R_0201]  120.85 154.71 180 bottom
RT62  100K_0201_5%  [R_0201]  123.5 150.85 270 top
RT63  100K_0201_5%  [R_0201]  130.53 149.06 0 bottom
RT64  10K_0201_5%  [R_0201]  129.11 156.07 90 bottom
RT65  10K_0201_5%  [R_0201]  130.57 154.43 270 bottom
RT66  10K_0201_5%  [R_0201]  120.86 148.67 180 bottom
RT67  10K_0201_5%  [R_0201]  120.86 147.78 180 bottom
RT68  100K_0201_5%  [R_0201]  125.67 156.02 90 bottom
RT69  100K_0201_5%  [R_0201]  124.78 156.02 90 bottom
RT70  100K_0201_5%  [R_0201]  120.31 156.49 0 bottom
RT71  100K_0201_5%  [R_0201]  123.77 156.02 90 bottom
RT72  100K_0201_5%  [R_0201]  122.88 156.02 90 bottom
RT73  100K_0201_5%  [R_0201]  120.89 155.85 180 bottom
RT74  0_0201_5%  [R0201_0OHM]  131.12 151.09 180 bottom
RT75  15K_0402_1%  [R_0402]  120.98 152.1 180 bottom
RT76  100K_0201_5%  [R_0201]  146.95 145.44 180 bottom
RT77  100K_0201_5%  [R_0201]  150.19 145.44 0 bottom
RT78  100K_0201_5%  [R_0201]  147.65 145.44 0 bottom
RT79  100K_0201_5%  [R_0201]  149.49 145.44 180 bottom
RT80  10K_0201_5%  [R_0201]  144.86 157.85 90 bottom
RT83  0_0201_5%  [R_0201]  124.07 150.27 90 top
RT86  10K_0201_5%  [R_0201]  146.45 160.2 90 bottom
RT94  10K_0201_5%  [R_0201]  137.49 155 270 bottom
RT95  0_0805_5%  [R0805_0OHM]  148.12 167.35 180 top
RT97  0_0402_5%  [R0402_0OHM]  141.38 155.98 180 bottom
RT98  0_0201_5%  [R0201_0OHM]  141.85 142.01 180 bottom
RT99  0_0201_5%  [R0201_0OHM]  139.5 150.01 180 top
RT100  0_0201_5%  [R0201_0OHM]  136.41 151.32 270 bottom
RT101  0_0201_5%  [R0201_0OHM]  140.58 142.01 180 bottom
RT102  0_0201_5%  [R_0201]  130.53 149.69 0 bottom
RT107  10K_0201_5%  [R_0201]  127.33 145.31 90 bottom
RT108  0_0201_5%  [R_0201]  132.72 149.59 270 bottom
RT109  0_0201_5%  [R_0201]  133.32 149.01 90 bottom
RU1  10K_0402_5  [R_0402]  22.12 46.05 180 top
RU2  19.1K_0402_1%  [R_0402]  17.21 49.68 270 top
RU3  19.1K_0402_1%  [R_0402]  17.21 46.99 90 top
RU4  100K_0402_5%  [R_0402]  70.04 60.9 90 top
RU5  220K_0402_5%  [R_0402]  70.04 60.03 270 top
RU6  1M_0402_5%  [R_0402]  65.08 61.86 0 top
RU7  10K_0402_5  [R_0402]  23.96 50.05 180 top
RU14  100K_0402_1%  [R_0402]  296.99 37.28 90 top
RU15  100K_0402_5%  [R_0402]  293.44 46.04 90 top
RU16  100K_0402_5%  [R_0402]  294.33 46.04 90 top
RU17  100K_0402_5%  [R_0402]  297.88 46.04 90 top
RU18  100K_0402_5%  [R_0402]  296.99 46.04 90 top
RU19  100K_0402_5%  [R_0402]  296.1 46.04 90 top
RU20  100K_0402_5%  [R_0402]  295.22 46.04 90 top
RU21  10K_0402_5%  [R_0402]  294.39 37.28 90 top
RU23  100K_0402_1%  [R_0402]  295.28 37.28 90 top
RU24  10K_0201_1%  [R_0201]  302.21 39.94 270 top
RU25  20K_0201_1%  [R_0201]  300.9 36.85 0 top
RU26  10K_0201_1%  [R_0201]  300.9 50.25 0 top
RV1  10K_0201_1%  [R_0201]  135.18 156.29 0 bottom
RV8  100K_0201_1%  [R_0201]  136.23 155.87 90 top
RV9  100K_0402_5%  [R_0402]  120.02 153.38 180 top
RV12  100K_0402_5%  [R_0402]  119.1 152.42 180 top
RV13  0_0402_5%  [R_0402]  127.34 157.19 270 top
RV15  100K_0201_5%  [R_0201]  191.34 154.88 270 top
RV16  100K_0201_5%  [R_0201]  190.7 154.88 270 top
RV17  1M_0201_1%  [R_0201]  194.39 153.3 180 bottom
RV18  5.1M_0402_5%  [R_0402]  198.71 159.9 90 bottom
RV19  100K_0402_5%  [R_0402]  161.36 115.03 270 bottom
RV20  100K_0402_5%  [R_0402]  162.31 114.11 90 bottom
RV21  4.7K_0402_1%~D  [R_0402]  157.67 100.99 270 bottom
RV22  4.7K_0402_1%~D  [R_0402]  157.67 98.71 270 bottom
RV23  1M_0402_5%  [R_0402]  162.89 103.71 180 bottom
RV24  4.99K_0402_1%  [R_0402]  159.84 107.86 270 top
RV27  6.04 +-1% 0402  [R_0402]  187.16 162.58 180 bottom
RV28  6.04 +-1% 0402  [R_0402]  187.16 161.7 180 bottom
RV29  6.04 +-1% 0402  [R_0402]  181.57 162.84 180 bottom
RV30  6.04 +-1% 0402  [R_0402]  181.57 161.95 180 bottom
RV33  6.04 +-1% 0402  [R_0402]  178.65 162.39 180 bottom
RV34  6.04 +-1% 0402  [R_0402]  178.65 161.5 180 bottom
RV45  10K_0201_1%  [R_0201]  136.96 163.41 180 bottom
RV47  0_0402_5%  [R0402_0OHM]  133.99 165.09 0 bottom
RV81  0_0402_5%  [R0402_0OHM]  121.91 159.27 90 bottom
RV500  158_0402_1%  [R_0402]  184.41 160.74 0 bottom
RV501  158_0402_1%  [R_0402]  187.14 160.81 0 bottom
RV502  158_0402_1%  [R_0402]  181.61 160.81 0 bottom
RV503  158_0402_1%  [R_0402]  179.64 160.93 0 bottom
RV600  100K_0201_1%  [R_0201]  136.37 162.77 0 bottom
RV618  0_0402_5%  [R0402_0OHM]  187.29 153.63 180 bottom
RV619  0_0402_5%  [R0402_0OHM]  187.29 152.74 180 bottom
RV622  4.7K_0402_1%~D  [R_0402]  155.58 98.71 270 bottom
RV623  4.7K_0402_1%~D  [R_0402]  155.58 100.99 270 bottom
RV624  4.7K_0402_1%~D  [R_0402]  160.73 107.86 270 top
RV625  4.7K_0402_1%~D  [R_0402]  162.19 107.86 270 top
RV626  4.7K_0402_1%~D  [R_0402]  156.47 98.71 270 bottom
RV627  4.7K_0402_1%~D  [R_0402]  156.47 100.99 270 bottom
RV628  4.7K_0402_1%~D  [R_0402]  158.56 98.71 270 bottom
RV629  4.7K_0402_1%~D  [R_0402]  158.56 100.99 270 bottom
RV630  4.7K_0402_1%~D  [R_0402]  160.54 98.65 270 bottom
RV631  4.7K_0402_1%~D  [R_0402]  161.43 97.74 90 bottom
RV634  4.7K_0402_1%~D  [R_0402]  153.67 100.08 90 bottom
RV635  4.7K_0402_1%~D  [R_0402]  154.63 100.08 90 bottom
RV638  5.6_0402_1%  [R_0402]  179.66 158.83 90 bottom
RV639  5.6_0402_1%  [R_0402]  181.62 158.7 90 bottom
RV640  5.6_0402_1%  [R_0402]  184.16 158.63 90 bottom
RV641  5.6_0402_1%  [R_0402]  185.05 158.63 90 bottom
RV642  5.6_0402_1%  [R_0402]  182.51 158.7 90 bottom
RV643  5.6_0402_1%  [R_0402]  188.1 158.7 90 bottom
RV645  5.6_0402_1%  [R_0402]  180.54 158.83 90 bottom
RV646  5.6_0402_1%  [R_0402]  187.21 158.7 90 bottom
RV648  10K_0402_5%  [R_0402]  172.34 159.32 90 bottom
RV649  2K_0402_5%  [R_0402]  169.95 157.72 180 bottom
RV650  33_0402_1%  [R_0402]  170.82 162.21 270 bottom
RV651  33_0402_1%  [R_0402]  169.87 162.21 270 bottom
RV652  10K_0402_5%  [R_0402]  167.97 159.7 270 bottom
RV653  2K_0402_5%  [R_0402]  170.82 157.72 0 bottom
RV655  10K_0402_5%  [R_0402]  170.88 165.61 90 bottom
RV659  10K_0402_5%  [R_0402]  174.18 125.69 0 bottom
RV664  100K_0402_5%  [R_0402]  186.37 151.79 0 bottom
RV665  100K_0402_5%  [R_0402]  186.37 154.52 0 bottom
RV669  100K_0201_1%  [R_0201]  176.16 124.52 270 bottom
RV670  100K_0201_1%  [R_0201]  176.16 125.14 90 bottom
RV671  2.2K_0201_5%  [R_0201]  189.31 162.67 90 top
RV672  2.2K_0201_5%  [R_0201]  189.94 162.67 90 top
RV673  6.04 +-1% 0402  [R_0402]  184.37 162.58 180 bottom
RV674  6.04 +-1% 0402  [R_0402]  184.37 161.7 180 bottom
RX1  100K_0402_5%  [R_0402]  173.75 157.05 90 bottom
RX2  150K_0402_5%  [R_0402]  196.85 159.96 90 bottom
RX4  100K_0402_5%  [R_0402]  193.18 154.91 270 top
RX5  10K_0402_5%  [R_0402]  192.04 149.94 90 top
RX6  150K_0402_5%  [R_0402]  168.91 165.61 90 bottom
RX7  10K_0402_5%  [R_0402]  192.91 149.95 0 top
RX8  100K_0402_5%  [R_0402]  168.18 161.63 180 bottom
RX31  499_0201_1%  [R_0201]  187.91 158.42 90 top
RX32  499_0201_1%  [R_0201]  187.28 158.42 90 top
RX33  499_0201_1%  [R_0201]  184.93 158.36 90 top
RX34  499_0201_1%  [R_0201]  184.29 158.36 90 top
RX35  499_0201_1%  [R_0201]  182.45 158.42 90 top
RX36  499_0201_1%  [R_0201]  181.81 158.42 90 top
RX37  499_0201_1%  [R_0201]  180.29 158.61 90 top
RX38  499_0201_1%  [R_0201]  179.66 158.61 90 top
SW1  TST71A-N-220-S017 SPST  [SW_TST71-N-220-T170-S017_2P]  78.57 21.27 0 top
SW2  TST71A-N-220-S017 SPST  [SW_TST71-N-220-T170-S017_2P]  175.6 162.01 180 bottom
T2  PAD~D  [TPC12]  142.66 152.56 0 top
T6  PAD~D  [TPC12]  182.51 85.95 0 top
T7  PAD~D  [TPC12]  139.83 150.82 45 top
T9  PAD~D  [TPC12]  142.58 151.1 45 top
T10  PAD~D  [TPC12]  176.61 94.83 180 bottom
T11  PAD~D  [TPC12]  175.53 93.05 180 bottom
T12  PAD~D  [TPC12]  176.73 93.5 180 bottom
T13  PAD~D  [TPC12]  174.19 92.86 180 bottom
T19  PAD~D  [TPC12]  166.03 54.25 0 top
T21  PAD~D  [TPC12]  165.99 52.97 0 top
T41  PAD~D  [TPC12]  140.97 86.37 0 top
T43  PAD~D  [TPC12]  102.72 84.35 0 top
T44  PAD~D  [TPC12]  103.1 86.13 0 top
T62  PAD~D  [TPC12]  125.11 150.41 0 top
T63  PAD~D  [TPC12]  125.05 151.73 0 top
T64  PAD~D  [TPC12]  121.26 146.93 180 bottom
T65  PAD~D  [TPC12]  122.19 148.09 180 bottom
T66  PAD~D  [TPC12]  104.9 107.95 0 top
T67  PAD~D  [TPC12]  106.14 108.33 0 top
T68  PAD~D  [TPC12]  107.2 94.61 0 top
T69  PAD~D  [TPC12]  107.99 93.56 0 top
T70  PAD~D  [TPC12]  126.42 150.16 0 top
T71  PAD~D  [TPC12]  126.33 152.03 0 top
T73  PAD~D  [TPC12]  107.89 95.77 0 top
T74  PAD~D  [TPC12]  105.82 96.06 0 top
T75  PAD~D  [TPC12]  105.81 101.32 0 top
T76  PAD~D  [TPC12]  107.86 100.93 0 top
T81  PAD~D  [TPC12]  106.81 109.47 0 top
T82  PAD~D  [TPC12]  108.49 109.04 0 top
T85  PAD~D  [TPC12]  145.43 82.02 180 bottom
T88  PAD~D  [TPC12]  101.7 83.34 0 top
T89  PAD~D  [TPC12]  144.15 82.06 180 bottom
T112  PAD~D  [TPC12]  98.4 102.89 180 bottom
T113  PAD~D  [TPC12]  101.4 103.61 180 bottom
T114  PAD~D  [TPC12]  129.81 149.21 180 bottom
T120  PAD~D  [TPC12]  129.87 151.15 180 bottom
T121  PAD~D  [TPC12]  130 149.95 180 bottom
T122  PAD~D  [TPC12]  130.13 151.6 180 bottom
TC24  PAD~D  [TPC12]  20.68 20.06 90 top
TL1  MHPC_NS692417  [MHPC_NS692417_24P]  222.52 147.36 180 bottom
U16  AOZ1334DI-02_WSON8  [TPS22961DNYR_WSON8]  242.92 14.61 90 top
U17  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  56.45 59.2 90 bottom
U18  -  [SY6288C20AAC_SOT23-5]  151.96 59.15 90 top
U19  -  [TPS22961DNYR_WSON8]  147.81 73.85 0 top
U20  -  [TPS22961DNYR_WSON8]  151.75 73.85 0 top
U2407  -  [F75305M_MSOP10]  70 59.36 135 bottom
UA1  ALC3266-CG_QFN56_7X7  [ALC3266-CG_QFN56_7X7-S]  30.16 40.78 180 bottom
UA2  MAX9892ERT+T_UCSP6~D  [MAX9892ERTLFT_UCSP_6P]  16.49 25.44 90 bottom
UA3  MAX9892ERT+T_UCSP6~D  [MAX9892ERTLFT_UCSP_6P]  16.52 27.66 270 top
UA4  ALC1309-CG_QFN56_7X7  [ALC1309-CG_QFN56_7X7-S]  29.46 18.62 180 top
