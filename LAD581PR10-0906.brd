# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_LED_B#_DRV#: length 15.7
  TOP w0.114: v2(213.1,14.15) 213.1,14.39 215.89,17.18 217.54,17.18 v3(219.64,19.28) 220.41,20.05 220.41,21.26 v2(220.85,21.7)
  BOTTOM w0.114: JTP.3 212.2,13.59 212.76,14.15 v2(213.1,14.15) ; Q28.6 221.32,21.12 220.85,21.59 v2(220.85,21.7)
TP_LED_EN: length 120.6
  TOP w0.114: v2(97.52,9.66) 97.52,8.31 98.27,7.56 UE5.25 ; v2(183.22,4.94) 183.22,4.22 v3(184.97,2.47) 185.57,1.87 196.62,1.87 197.82,3.07 Q2410.2
  IN5 w0.097: v2(97.52,9.66) 99.32,11.46 99.99,11.46 102.82,14.29 102.82,16.92 105.11,19.2 117.97,19.2 120.33,16.84 124.08,16.84 126.17,18.93 138.38,18.93 139.07,18.24 145.18,18.24 145.62,17.8 150,17.8 150.64,17.17 151.08,17.17 154.59,13.66 161.02,13.66 165.95,8.73 172.39,8.73 172.86,8.25 174.64,8.25 174.74,8.15 180.18,8.15 183.22,5.1 v2(183.22,4.94)
TP_LED_G#: length 239.4
  TOP w0.114: v2(179.91,152.81) 180.12,152.59 UE3.11
  IN4 w0.137: v2(179.91,152.81) 191.28,152.81 191.97,152.11 194.9,152.11 195.53,151.47 195.53,149.95 196.61,148.87 196.61,146.46 197.37,145.7 199.97,145.7 201.69,143.98 240.93,143.98 245.96,138.94 245.96,86.92 245.86,86.81 245.86,83.5 245.96,83.39 245.96,83.07 249.95,79.08 249.95,72.29 252.62,69.62 256.64,69.62 259.57,66.69 259.57,64.65 261.25,62.97 261.25,57.78 258.43,54.96 258.43,50.85 255.8,48.22 249.95,48.22 241.35,39.62 235.57,39.62 230.69,34.74 230.69,33.59 225.99,28.89 223.84,28.89 221.81,26.86 221.81,22.07 220.88,21.14 218.27,21.14 215.72,18.59 v2(215.72,18.4)
  BOTTOM w0.114: Q29.5 218.39,15.84 218.84,16.28 R154.2 218.49,17.6 217.99,17.11 217.01,17.11 v1(216.37,17.74) v2(215.72,18.4)
TP_LED_G#_DRV: length 4.3
  BOTTOM w0.114: v1(221.44,16.79) 220.66,16.01 R150.2 220.4,16.01 220.03,15.65 220.03,15.56 219.66,15.19 Q29.3 219.06,15.19 218.94,15.31 218.94,15.71 219.06,15.84 Q29.2
TP_LED_G#_DRV#: length 9.1
  BOTTOM w0.114: JTP.4 211.7,13.64 212.83,14.77 215.48,14.77 v3(216.23,15.52) 217.2,16.49 Q29.6
TP_LED_R#: length 232.3
  TOP w0.114: UE3.10 180.32,153.09 180.16,153.25 v2(179.53,153.25)
  IN4 w0.137: v2(179.53,153.25) 179.48,153.2 179.48,152.6 179.72,152.36 191.34,152.36 191.91,151.79 194.64,151.79 195.15,151.28 195.15,149.82 196.29,148.68 196.29,146.33 197.25,145.38 199.91,145.38 201.63,143.66 240.62,143.66 245.72,138.55 245.72,87.02 245.62,86.91 245.62,83.4 245.72,83.29 245.72,82.93 249.71,78.94 249.71,72.19 252.53,69.37 256.56,69.37 259.33,66.59 259.33,64.55 261.01,62.87 261.01,57.88 258.14,55.01 258.14,51.01 255.62,48.49 249.76,48.49 241.13,39.86 235.47,39.86 230.45,34.83 230.45,33.68 225.89,29.12 223.74,29.12 221.25,26.63 v2(221.25,23.71)
  BOTTOM w0.114: Q34.5 217.59,20.47 ; 217.59,20.47 217.69,20.47 218.14,20.92 218.14,21.74 v1(219.05,22.65) 220.23,23.84 221.12,23.84 v2(221.25,23.71) ; 217.59,20.47 218.08,19.98 218.08,18.88 217.72,18.52 R147.2
TP_LED_R#_DRV: length 3.5
  BOTTOM w0.114: v1(220.03,18.85) 220.03,19.33 219.54,19.82 Q34.3 219.32,19.82 219.05,20.09 219.05,20.21 219.32,20.47 Q34.2 219.87,20.47 219.9,20.44 220.03,20.44 220.4,20.8 R145.2
TP_LED_R#_DRV#: length 12.8
  BOTTOM w0.114: Q34.6 216.49,21.12 215.31,19.94 215.31,17.38 v1(213.37,15.44) 213.19,15.26 213.02,15.26 211.2,13.44 JTP.5
TRIP_+1VALWP: length 2.8
  TOP w0.114: v1(216.19,18.2) 216.19,18.71 PR303.2
  TOP w0.254: PR303.2 215.78,19.14 215.37,19.56 215.19,19.56 215.14,19.62 PU300.2
TS_EN: length 287.2
  TOP w0.114: v2(122.3,160.96) 122.1,160.75 JEDP.34 ; UE6.14 67.15,4.34 67.02,4.22 66.5,4.22 65.99,4.72 v2(65.55,4.72) ; v2(156.16,136.49) 156.55,136.1 159.47,136.1 160.96,134.6 160.96,118.19 v3(160.54,117.76) 159.02,116.24 159.02,115.36 158.37,114.71 157.58,114.71 155.85,112.98 155.85,106.57 153.72,104.44 153.72,95.19 156.8,92.11 156.8,88.02 154.58,85.8 154.58,80.15 154.99,79.74 154.99,69.08 153.36,67.45 148.29,67.45 v2(146.45,65.61)
  IN2 w0.097: v2(136.84,157.68) 136.6,157.68 133.02,154.1 133.02,149.44 131.6,148.02 131.6,141.87 132.4,141.07 151.09,141.07 154.19,137.97 154.93,137.97 156.16,136.74 v2(156.16,136.49)
  IN3 w0.124: v2(122.3,160.96) 122.3,160.81 122.72,160.39 133.99,160.39 136.69,157.68 v2(136.84,157.68)
  IN4 w0.137: v2(146.45,65.61) 144.05,63.21 138.81,63.21 131.35,55.75 131.35,41.15 131.09,40.89 131.09,28.06 131.41,27.74 131.41,26.67 128.2,23.46 122.04,23.46 117.64,19.06 113.97,19.06 109.09,23.93 102.11,23.93 101.78,24.27 93.37,24.27 92.5,23.39 92.5,22.19 91.52,21.21 91.52,15.77 91.76,15.53 91.76,14.72 91.12,14.08 91.12,12.44 90.52,11.84 90.52,10.95 89.47,9.9 88.58,9.9 86.88,8.2 81.7,8.2 78.11,4.61 71.73,4.61 69.93,2.82 68.43,2.82 66.52,4.72 v2(65.55,4.72)
TYPEC_DET#: length 214.1
  TOP w0.114: RU26.2 301.32,50.09 QU1.1 302.31,48.7 v2(302.78,49.17) ; v2(119.03,15.96) 119.03,15.6 119.01,15.58 v1(119.01,15.33) 119.01,14.44 119.16,14.29 UE10.18
  IN3 w0.124: v2(119.03,15.96) 119.03,16.2 120.06,17.23 123.8,17.23 125.43,18.86 138.28,18.86 140.25,16.89 163.43,16.89 165.52,14.8 166.96,14.8 167.26,15.1 178.56,15.1 179.46,16 186.07,16 186.44,15.63 190.71,15.63 195.1,11.25 214.11,11.25 216.58,13.71 230.13,13.71 232.66,16.24 234.91,16.24 251.27,32.59 251.27,34.62 v2(253,36.36)
  IN5 w0.097: v2(253,36.36) 253.46,35.9 259.17,35.9 260.27,37 293.53,37 296.56,40.03 296.56,40.16 297.07,40.66 297.07,43.84 302.4,49.17 v2(302.78,49.17)
UART_2_CCTS_DRTS: length 3.7
  BOTTOM w0.089: UH1.AN44 176.11,31.02 175.65,30.56 175.65,30.18 174.97,29.5 v1(174.51,29.5) 174.5,29.5 174.38,29.37 RC65.1
UART_2_CRXD_DTXD: length 27.1
  TOP w0.114: JWDB.3 177.93,23.74 177.17,22.98 v2(177.17,22.67)
  IN5 w0.097: v2(176.26,29.92) 175.86,29.53 175.86,29.35 176.25,28.95 176.25,28.77 176.1,28.62 175.97,28.62 175.12,29.47 174.98,29.47 174.85,29.34 174.85,29.2 175.69,28.35 175.69,28.21 175.56,28.08 175.42,28.08 174.54,28.96 174.4,28.96 174.27,28.82 174.27,28.68 175.15,27.8 175.15,27.67 175.01,27.53 174.87,27.53 173.96,28.44 173.83,28.44 173.69,28.31 173.69,28.17 174.6,27.26 174.6,27.12 173.71,26.23 173.71,25.97 173.61,25.87 173.06,25.87 172.96,25.77 172.96,25.58 173.06,25.48 173.61,25.48 173.71,25.39 173.71,25.19 173.61,25.1 173.06,25.1 172.96,25 172.96,24.81 173.06,24.71 173.61,24.71 173.71,24.61 173.71,23.83 174.12,23.42 176.41,23.42 v2(177.17,22.67)
  BOTTOM w0.089: UH1.AR45 176.72,30.39 v2(176.26,29.92)
  BOTTOM w0.114: RC62.1 175.65,29.31 v1(175.85,29.52) v2(176.26,29.92)
UART_2_CTXD_DRXD: length 28.8
  TOP w0.102: RC63.1 176.09,29.5 175.84,29.76 175.84,31.13 176.15,31.45 176.15,33.13 176.38,33.35 176.84,33.35 v3(176.94,33.46) v2(177.58,34.1)
  TOP w0.114: JWDB.2 178.38,24.54 v2(176.56,22.72)
  IN5 w0.097: v2(177.58,34.1) 177.6,34.1 177.99,33.71 177.99,31.97 177.37,31.35 174.09,31.35 173.35,30.61 173.35,26.94 172.73,26.33 172.73,24.11 173.62,23.22 176.06,23.22 v2(176.56,22.72)
  BOTTOM w0.114: UH1.AR39 v2(177.58,34.1)
UG_3V: length 11.5
  IN5 w1.016: 45.54,36.3 42.56,36.3 37.1,30.84
  BOTTOM w0.114: v2(36.21,30.08) v1(37.03,30.08)
  vias: v2(35.76,29.63) v2(46.49,36.68) v2(46.49,36.05)
UG_5V: length 9.8
  IN5 w1.016: 36.91,24.55 46.68,24.55
  vias: v1(47.13,22.88) v2(35.76,25.44) v2(36.37,25.44) v2(47.89,23.98) v2(47.89,23.35)
UG_+1VALWP: length 6.4
  TOP w0.114: v2(203.59,19.67) v3(203.03,19.67)
  IN5 w1.016: 209.18,17.51 205.18,17.51 203.91,18.78
  vias: v2(204.23,19.67) v2(210.2,18.97) v2(210.64,19.41)
USB2_COMP: length 4.4
  BOTTOM w0.102: UH1.AG3 173.13,51.51 172.86,51.78 172.86,52.26 172.81,52.3 172.81,53.38 172.66,53.53 172.66,53.88 172.41,54.13
  BOTTOM w0.305: RH109.1 171.58,55.04 172.41,54.21 172.41,54.13
USB3_A_TRX_DTX_N0: length 20.8
  TOP w0.089: UT1.A21 153.31,160.44 153.34,160.41 153.47,160.41 153.54,160.49 153.54,160.8 arc(153.55,160.87) 153.56,160.93 153.65,161.01 arc(153.65,161.02) 153.66,161.02
  TOP w0.114: 153.68,161.06 153.71,161.09 arc(153.77,161.2) 153.8,161.32 arc(153.81,161.36) 153.81,161.41 153.81,162.05 arc(153.81,162.05) 153.81,162.05 arc(153.83,162.14) 153.88,162.21 arc(153.96,162.34) 153.99,162.49 153.99,162.88 arc(154.04,163.05) v2(154.15,163.18)
  TOP w0.117: 153.66,161.02 153.66,161.03 153.68,161.06
  BOTTOM w0.114: v2(154.15,163.18) 154.11,163.22 arc(153.99,163.4) 153.94,163.61 153.94,163.88 arc(153.89,164.14) 153.75,164.36 arc(153.59,164.46) 153.4,164.5 151.06,164.5 arc(150.93,164.53) 150.81,164.6 150.71,164.71 arc(150.65,164.8) 150.63,164.91 150.63,165.34 arc(150.65,165.45) 150.71,165.54 150.82,165.65 arc(150.93,165.72) 151.05,165.75 153.92,165.75 arc(154.28,165.82) 154.58,166.02 154.58,166.02 154.66,166.1 arc(154.81,166.33) 154.87,166.6 154.87,166.63 arc(154.92,166.92) DT5.1 154.89,167.34 arc(154.85,167.4) 154.84,167.47 154.84,169.06 arc(154.85,169.18) 154.88,169.3 arc(154.94,169.45) 155.03,169.58 arc(155.05,169.61) 155.08,169.63 155.71,170.26 arc(155.86,170.5) 155.92,170.78 155.92,171.28 arc(155.97,171.53) 156.11,171.74 arc(156.3,171.87) 156.53,171.92 arc(156.72,171.96) 156.88,172.07 156.88,172.07 157.02,172.21 arc(157.12,172.34) 157.17,172.51 157.21,172.77 arc(157.22,172.81) JUSBC1.B10
USB3_A_TRX_DTX_N1: length 28.8
  TOP w0.089: 150.62,160.93 150.74,160.81 arc(150.77,160.76) 150.78,160.7 150.78,160.48 arc(150.76,160.36) 150.7,160.27 150.55,160.13 UT1.B15
  TOP w0.114: 150.57,161 150.49,161.08 arc(150.47,161.1) 150.45,161.13 arc(150.39,161.18) 150.37,161.26 arc(150.33,161.5) 150.19,161.7 149.8,162.09 arc(149.76,162.13) 149.71,162.16 arc(149.71,162.16) 149.71,162.16 arc(149.56,162.21) 149.4,162.23 148.95,162.23 arc(148.78,162.26) 148.63,162.34 arc(148.57,162.36) 148.52,162.39 arc(148.44,162.48) 148.38,162.59 arc(148.44,162.85) v2(148.61,163.06)
  TOP w0.117: 150.57,161 150.6,160.97 arc(150.62,160.95) 150.62,160.93
  BOTTOM w0.114: JUSBC1.A10 161,170.77 arc(161.01,170.7) 161.05,170.65 arc(161.12,170.56) 161.15,170.46 arc(161.16,170.35) 161.19,170.24 161.32,170 161.49,169.83 161.95,169.39 162.14,169.2 arc(162.22,169.11) 162.28,168.99 arc(162.32,168.88) 162.33,168.76 162.33,167.6 arc(162.25,167.25) DT9.1 arc(162.23,166.56) 162.27,166.1 arc(162.26,165.67) 162.34,165.25 arc(162.47,164.62) 162.51,163.98 162.51,163.06 162.49,162.91 arc(162.45,162.79) 162.37,162.7 arc(162.36,162.68) 162.34,162.67 162.33,162.66 162.28,162.61 161.98,162.28 161.84,162.14 arc(161.75,162.06) 161.63,162.01 arc(161.57,162) 161.49,161.99 158,161.99 arc(157.98,161.99) 157.96,161.99 arc(157.8,162.04) 157.66,162.13 arc(157.41,162.3) 157.11,162.36 148.72,162.36 arc(148.69,162.36) 148.66,162.36 arc(148.55,162.4) 148.45,162.47 148.44,162.48 arc(148.41,162.52) 148.4,162.57 148.4,162.76 arc(148.46,162.94) v2(148.61,163.06)
USB3_A_TRX_DTX_P0: length 20.8
  TOP w0.089: 153.38,161.11 153.15,160.87 arc(153.11,160.81) 153.09,160.74 153.09,160.49 arc(153.11,160.42) 153.15,160.35 153.26,160.24 arc(153.3,160.18) UT1.B21
  TOP w0.114: v2(153.54,163.19) 153.75,162.88 153.75,162.49 arc(153.74,162.43) 153.71,162.39 arc(153.6,162.23) 153.57,162.05 153.55,161.38 arc(153.51,161.22) 153.38,161.11
  BOTTOM w0.114: JUSBC1.B11 156.75,172.38 arc(156.75,172.34) 156.73,172.3 arc(156.64,172.21) 156.52,172.17 arc(156.2,172.1) 155.93,171.91 arc(155.74,171.62) 155.67,171.28 155.67,170.78 arc(155.64,170.59) 155.53,170.44 154.9,169.8 arc(154.87,169.77) 154.84,169.74 arc(154.72,169.57) 154.64,169.38 arc(154.61,169.22) 154.59,169.06 154.59,167.57 arc(154.54,167.34) DT4.1 arc(154.56,166.92) 154.62,166.63 154.62,166.6 arc(154.61,166.49) 154.57,166.39 arc(154.53,166.33) 154.49,166.28 154.4,166.19 154.4,166.19 arc(154.18,166.04) 153.92,165.99 151.05,165.99 arc(150.83,165.95) 150.65,165.83 150.54,165.72 arc(150.42,165.54) 150.38,165.34 150.38,164.91 arc(150.42,164.7) 150.54,164.53 arc(150.54,164.53) 150.55,164.52 150.64,164.43 arc(150.83,164.3) 151.06,164.26 153.4,164.26 arc(153.42,164.26) 153.43,164.25 arc(153.51,164.23) 153.57,164.19 arc(153.6,164.15) 153.63,164.12 arc(153.68,164) 153.7,163.88 153.7,163.61 arc(153.66,163.39) v2(153.54,163.19)
USB3_A_TRX_DTX_P1: length 29
  TOP w0.089: 150.27,160.93 arc(150.28,160.91) 150.29,160.89 arc(150.31,160.85) 150.32,160.81 150.32,160.73 arc(150.34,160.64) 150.38,160.55 arc(150.48,160.52) UT1.A15
  TOP w0.114: 150.27,160.93 150.23,160.97 arc(150.22,160.98) 150.2,161 arc(150.15,161.13) 150.13,161.26 arc(150.1,161.4) 150.02,161.52 149.62,161.92 arc(149.61,161.93) 149.59,161.94 arc(149.59,161.94) 149.59,161.94 arc(149.5,161.97) 149.4,161.98 148.95,161.98 arc(148.9,161.99) 148.86,161.99 arc(148.7,162.02) 148.56,162.09 arc(148.54,162.1) 148.51,162.12 arc(148.44,162.15) 148.38,162.19 arc(148.23,162.34) 148.15,162.53 arc(148.13,162.61) 148.13,162.68 148.13,162.8 arc(148.1,162.94) v2(148.03,163.06)
  BOTTOM w0.114: JUSBC1.A11 161.5,170.81 arc(161.48,170.72) 161.43,170.65 arc(161.4,170.61) 161.39,170.56 161.39,170.46 arc(161.42,170.31) 161.5,170.19 162.32,169.38 arc(162.51,169.09) 162.57,168.76 162.57,167.31 arc(162.61,167.13) DT8.1 arc(162.59,166.53) 162.51,166.08 arc(162.51,165.69) 162.57,165.31 arc(162.71,164.65) 162.76,163.98 162.76,163.03 arc(162.69,162.73) 162.5,162.48 162.46,162.44 162.16,162.11 162.02,161.96 arc(161.87,161.85) 161.7,161.78 arc(161.6,161.75) 161.49,161.75 158,161.75 arc(157.97,161.75) 157.94,161.75 arc(157.7,161.81) 157.49,161.96 arc(157.32,162.07) 157.11,162.11 148.72,162.11 arc(148.67,162.12) 148.63,162.12 arc(148.43,162.18) 148.26,162.3 148.26,162.3 arc(148.18,162.43) 148.15,162.57 148.15,162.76 arc(148.12,162.92) v2(148.03,163.06)
USB3_A_TTX_C_DRX_N0: length 19.5
  TOP w0.114: v2(154.81,163.79) 154.69,163.92 arc(154.56,164) 154.41,164.03 152.9,164.03 arc(152.72,164.07) 152.57,164.17 152.53,164.21 arc(152.41,164.39) 152.37,164.6 152.37,164.77 arc(152.5,165.08) 152.81,165.2 153.75,165.2 arc(153.9,165.27) 153.96,165.42 153.96,165.63 arc(153.95,165.71) 153.9,165.77 arc(153.84,165.81) 153.77,165.83 arc(153.77,165.83) 153.77,165.83 152.95,165.83 arc(152.58,165.98) 152.42,166.36 152.42,166.84 arc(152.4,166.94) 152.34,167.02 arc(152.21,167.11) 152.05,167.14 151.69,167.14 arc(151.64,167.13) 151.6,167.11 151.51,167.02 arc(151.44,166.91) 151.41,166.78 151.41,166.46 arc(151.37,166.24) 151.24,166.05 arc(151.18,165.96) 151.16,165.86 151.16,165.39 arc(151.19,165.25) CT42.1
  BOTTOM w0.114: JUSBC1.A3 157.5,170.88 arc(157.48,170.79) 157.43,170.71 arc(157.4,170.66) 157.38,170.6 157.38,170.56 arc(157.32,170.25) 157.15,169.98 157.02,169.85 arc(156.93,169.72) 156.9,169.56 156.9,169.32 arc(156.93,169.16) 157.01,169.03 DT3.1 157.02,168.84 arc(156.91,168.68) 156.87,168.49 156.87,167.09 arc(156.73,166.37) 156.32,165.76 156.09,165.53 arc(155.91,165.26) 155.85,164.94 155.86,164.94 155.86,164.62 arc(155.8,164.34) 155.65,164.11 155.62,164.08 arc(155.4,163.95) 155.14,163.91 155.08,163.91 arc(154.93,163.88) v2(154.81,163.79)
USB3_A_TTX_C_DRX_N1: length 24.8
  TOP w0.114: v2(161.1,172.07) 161.1,172.07 arc(161.2,171.91) 161.24,171.73 161.24,171.66 arc(161.29,171.43) 161.42,171.23 162.03,170.62 arc(162.2,170.37) 162.26,170.08 162.26,167.39 arc(162.22,167.23) 162.13,167.09 DT7.1 162.11,166.88 arc(162.22,166.71) 162.26,166.52 162.26,166.46 arc(162.23,166.34) 162.16,166.23 162.1,166.17 arc(161.94,166.06) 161.75,166.03 161.24,166.03 arc(160.85,165.95) 160.51,165.73 159.69,164.9 arc(159.53,164.79) 159.34,164.76 157.39,164.76 arc(157.2,164.79) 157.04,164.9 v4(156.31,165.63) 153.69,168.25 arc(153.41,168.44) 153.09,168.5 151.6,168.5 arc(151.31,168.45) 151.07,168.28 150.49,167.7 arc(150.32,167.45) 150.26,167.14 150.26,166.86 arc(150.23,166.72) 150.15,166.61 149.65,166.1 arc(149.55,166.04) 149.43,166.01 149.32,166.01 arc(149.13,165.98) 148.97,165.87 148.94,165.84 arc(148.83,165.68) 148.79,165.49 148.79,165.49 148.79,165.37 arc(148.78,165.27) 148.72,165.19 CT40.1
  BOTTOM w0.114: v2(161.1,172.07) 161.06,172.11 arc(160.83,172.45) JUSBC1.B3
USB3_A_TTX_C_DRX_P0: length 19.5
  TOP w0.114: CT41.1 150.8,165.23 arc(150.87,165.34) 150.9,165.47 150.9,165.86 arc(150.94,166.06) 151.05,166.24 arc(151.12,166.34) 151.14,166.46 151.14,166.76 arc(151.19,167.01) 151.33,167.22 151.41,167.29 arc(151.54,167.38) 151.69,167.41 152.05,167.41 arc(152.31,167.36) 152.53,167.21 arc(152.65,167.04) 152.69,166.84 152.69,166.36 arc(152.77,166.17) 152.95,166.09 153.77,166.09 arc(153.94,166.06) 154.09,165.96 arc(154.19,165.81) 154.23,165.63 154.23,165.42 arc(154.09,165.08) 153.75,164.94 152.81,164.94 arc(152.69,164.89) 152.64,164.77 152.64,164.6 arc(152.66,164.49) 152.72,164.39 152.77,164.34 arc(152.86,164.31) 152.96,164.3 154.62,164.3 arc(154.72,164.32) v2(154.81,164.38)
  BOTTOM w0.114: v2(154.81,164.38) 154.93,164.26 arc(155.03,164.2) 155.14,164.17 155.2,164.17 arc(155.33,164.2) 155.43,164.27 155.45,164.29 arc(155.55,164.44) 155.59,164.62 155.58,164.62 155.58,164.94 arc(155.67,165.36) 155.9,165.72 156.13,165.95 arc(156.48,166.47) 156.61,167.09 156.61,168.49 arc(156.56,168.72) 156.43,168.92 DT2.1 156.51,169.03 arc(156.6,169.16) 156.63,169.32 156.63,169.56 arc(156.68,169.82) 156.83,170.04 156.94,170.15 arc(157.07,170.35) 157.12,170.59 arc(157.11,170.64) 157.07,170.69 157.05,170.71 arc(157.01,170.77) 157,170.83 JUSBC1.A2
USB3_A_TTX_C_DRX_P1: length 24.8
  TOP w0.114: CT39.1 149.1,165.27 arc(149.07,165.31) 149.06,165.37 149.06,165.49 arc(149.08,165.58) 149.13,165.65 149.16,165.68 arc(149.23,165.73) 149.32,165.75 149.43,165.75 arc(149.65,165.79) 149.84,165.91 150.34,166.42 arc(150.47,166.62) 150.52,166.86 150.52,167.14 arc(150.56,167.34) 150.67,167.51 151.26,168.09 arc(151.41,168.2) 151.6,168.24 v4(152.24,168.24) 153.09,168.24 arc(153.31,168.19) 153.5,168.06 155.67,165.9 156.12,165.44 156.86,164.71 arc(157.1,164.55) 157.39,164.49 159.34,164.49 arc(159.63,164.55) 159.88,164.71 160.7,165.53 arc(160.95,165.7) 161.24,165.76 161.66,165.76 arc(161.98,165.81) 162.26,165.96 arc(162.27,165.97) 162.28,165.98 162.36,166.06 arc(162.48,166.24) 162.52,166.46 162.52,166.54 arc(162.57,166.77) DT6.1 arc(162.57,167.16) 162.52,167.4 162.52,170.08 arc(162.45,170.47) 162.22,170.81 161.61,171.42 arc(161.53,171.53) 161.51,171.66 161.51,171.73 arc(161.53,171.86) 161.61,171.97 v2(161.68,172.05)
  BOTTOM w0.114: v2(161.68,172.05) 161.51,172.21 arc(161.32,172.51) JUSBC1.B2
USB3_A_TTX_DRX_N0: length 5.1
  TOP w0.089: UT1.B19 152.52,160.25 arc(152.59,160.35) 152.62,160.48 152.62,160.99 arc(152.6,161.06) 152.56,161.12
  TOP w0.114: 152.56,161.12 152.56,161.85 arc(152.51,162.1) 152.37,162.31 152.35,162.33 v4(152.25,162.42) 151.98,162.7 151.97,162.71 arc(151.88,162.83) 151.86,162.98 151.86,163.14 arc(151.8,163.43) 151.63,163.68 151.59,163.72 151.33,163.98 151.18,164.13 arc(151.16,164.17) 151.14,164.23 151.14,164.25 arc(151.18,164.41) CT42.2
USB3_A_TTX_DRX_N1: length 5.8
  TOP w0.089: 151.25,160.93 151.25,160.46 arc(151.27,160.31) 151.34,160.18 151.34,160.17 arc(151.4,160.13) UT1.B17
  TOP w0.114: CT40.2 148.72,164.49 arc(148.77,164.41) 148.79,164.32 arc(148.83,164.15) 148.92,164.01 148.95,163.98 arc(149.09,163.89) 149.25,163.85 149.44,163.85 arc(149.61,163.82) 149.75,163.72 v4(149.85,163.63) 149.99,163.49 arc(150.04,163.4) 150.06,163.3 150.06,163.23 arc(150.11,162.99) 150.25,162.78 150.62,162.41 151.11,161.92 arc(151.21,161.77) 151.25,161.59 151.25,160.93
USB3_A_TTX_DRX_P0: length 5.1
  TOP w0.089: UT1.A19 152.39,160.49 arc(152.37,160.42) 152.3,160.4 arc(152.2,160.44) 152.16,160.54 152.16,160.74 arc(152.17,160.8) 152.2,160.85 arc(152.24,160.88) 152.26,160.93
  TOP w0.114: CT41.2 150.78,164.47 arc(150.85,164.36) 150.88,164.23 arc(150.91,164.07) 151,163.94 v4(151.23,163.7) 151.45,163.49 arc(151.55,163.33) 151.59,163.15 151.59,162.98 arc(151.64,162.73) 151.78,162.52 151.97,162.33 152.06,162.23 152.18,162.12 arc(152.27,161.99) 152.29,161.85 152.29,161.07 arc(152.29,161) 152.26,160.93
USB3_A_TTX_DRX_P1: length 5.8
  TOP w0.089: 151.56,160.93 151.65,160.83 arc(151.69,160.78) 151.7,160.71 151.7,160.55 arc(151.66,160.45) 151.56,160.41 arc(151.54,160.42) 151.51,160.43 arc(151.48,160.46) 151.47,160.5 UT1.A17
  TOP w0.114: 151.56,160.93 151.51,160.97 151.51,161.59 arc(151.46,161.87) 151.3,162.11 151.17,162.24 v4(150.98,162.43) 150.44,162.97 arc(150.36,163.09) 150.33,163.23 150.33,163.3 arc(150.29,163.5) 150.17,163.68 150.04,163.81 149.89,163.96 arc(149.71,164.08) 149.51,164.12 149.25,164.12 arc(149.19,164.13) 149.14,164.17 149.11,164.2 arc(149.07,164.25) 149.06,164.32 arc(149.07,164.37) 149.1,164.41 CT39.2
USB3_CC1: length 18.5
  TOP w0.114: UU7.11 297.9,40.67 v2(298.02,40.56) ; v2(312.05,43.1) 311.34,43.1 v1(309.87,44.56) 309.34,45.1 DU20.2 305.37,45.1 v2(304.31,44.03)
  IN1 w0.097: v2(298.02,40.56) 301.13,43.67 303.95,43.67 v2(304.31,44.03)
  BOTTOM w0.114: JUSBC2.A5 312.22,42.92 v2(312.05,43.1)
USB3_CC2: length 23.1
  TOP w0.114: v2(311.04,44.16) 311.04,44.28 v1(309.49,45.83) 308.29,47.03 DU20.3 v2(306.03,47.03) ; v2(298.4,41.67) UU7.13
  IN1 w0.097: v2(298.4,41.67) 298.69,41.67 301,43.99 303.63,43.99 306.03,46.39 v2(306.03,47.03) ; v2(313.69,41.68) 313.07,42.29 313.07,43.65 312.37,44.35 311.23,44.35 v2(311.04,44.16)
  BOTTOM w0.114: JUSBC2.B5 313.69,41.67 v2(313.69,41.68)
USB3_CRX_L_DTX_N1: length 19.1
  TOP w0.114: JUSB1.5 12.83,42.48 12.95,42.6 13.28,42.6 13.54,42.86 13.54,43.02 14.24,43.71 15.55,43.71 15.9,44.06 15.9,48.16 16.46,48.73 16.46,50.34 16.59,50.47 v4(16.59,51.05) 16.59,52.06 16.61,52.08 16.61,52.62 16.59,52.64 16.59,54.49 16.92,54.82 17.27,54.82 17.39,54.7 DU2.9 DU2.1 19.03,54.7 19.17,54.84 19.47,54.84 19.62,54.69 LU5.2
USB3_CRX_L_DTX_N2: length 7.6
  BOTTOM w0.114: LU8.2 308.56,46.19 308.62,46.25 308.97,46.25 309.11,46.12 DU12.4 DU12.7 310.83,46.12 310.94,46.23 311.17,46.23 311.19,46.21 311.73,46.21 311.74,46.23 311.94,46.23 312.65,45.52 313.12,45.52 313.54,45.1 313.54,44.57 313.77,44.34 313.99,44.34 314.16,44.17 JUSBC2.B10
USB3_CRX_L_DTX_N4: length 11.9
  TOP w0.114: JUSB2.5 307.07,72.85 306.91,72.69 306.41,72.69 305.75,72.03 305.04,72.03 v4(304.56,71.54) 304.02,71 304.02,68.12 304,68.1 304,67.43 304.02,67.41 304.02,67.24 303.56,66.78 303.42,66.78 303.33,66.86 DU5.9 DU5.1 301.85,66.86 301.7,66.72 301.32,66.72 301.23,66.81 LU2.2
USB3_CRX_L_DTX_N5: length 7.7
  BOTTOM w0.114: LU11.3 308.55,43.66 308.83,43.38 DU13.9 DU13.1 310.67,43.38 310.78,43.27 311.29,43.27 311.59,42.97 311.59,42.84 311.6,42.83 311.6,42.22 311.59,42.2 311.59,41.92 311.62,41.88 v4(311.62,41.3) 311.62,40.46 311.89,40.19 312.28,40.19 312.51,40.42 JUSBC2.A10
USB3_CRX_L_DTX_P1: length 19.1
  TOP w0.114: LU5.3 19.62,55.19 19.5,55.07 19.17,55.07 19.03,55.2 DU2.2 DU2.8 17.41,55.2 17.26,55.05 16.83,55.05 16.36,54.58 v4(16.36,52.35) 16.36,51.34 16.35,51.32 16.35,50.78 16.36,50.76 16.36,50.56 16.24,50.43 16.24,48.82 15.67,48.26 15.67,44.16 15.45,43.94 14.14,43.94 13.32,43.11 13.32,42.95 13.19,42.82 12.97,42.82 12.83,42.97 JUSB1.6
USB3_CRX_L_DTX_P2: length 7.6
  BOTTOM w0.114: LU8.3 308.62,46.69 308.84,46.48 308.97,46.48 309.12,46.62 DU12.5 DU12.6 310.83,46.62 310.99,46.45 v4(311.46,46.45) 312.04,46.45 312.74,45.75 313.21,45.75 313.77,45.19 313.77,44.66 313.87,44.56 313.98,44.56 314.1,44.67 JUSBC2.B11
USB3_CRX_L_DTX_P4: length 11.9
  TOP w0.114: LU2.3 301.17,66.31 301.32,66.47 301.7,66.47 301.8,66.36 DU5.2 DU5.8 303.31,66.36 303.49,66.54 303.64,66.54 304.24,67.14 v4(304.24,67.7) 304.24,70.91 304.51,71.18 304.54,71.18 304.92,71.56 304.92,71.59 305.13,71.8 305.85,71.8 306.51,72.46 306.91,72.46 306.91,72.46 306.94,72.46 307.07,72.33 JUSB2.6
USB3_CRX_L_DTX_P5: length 7.6
  BOTTOM w0.114: LU11.2 308.73,43.16 309.01,42.88 DU13.8 DU13.2 310.65,42.88 310.81,43.04 311.2,43.04 311.36,42.88 v4(311.36,42.56) 311.36,41.83 311.4,41.79 311.4,41.59 311.38,41.57 311.38,41.03 311.4,41.01 311.4,40.37 311.8,39.97 312.37,39.97 312.41,39.92 JUSBC2.A11
USB3_CTX_C_DRX_N1: length 1.5
  TOP w0.114: CU13.1 22.14,56.35 21.85,56.35 21.71,56.22 LU4.1
USB3_CTX_C_DRX_N2: length 9.1
  BOTTOM w0.114: CU30.1 301.18,41.13 302.78,41.13 303.16,41.51 303.16,43.58 304.34,44.76 306.34,44.76 306.47,44.62 LU7.1
USB3_CTX_C_DRX_N4: length 1.5
  TOP w0.114: LU1.1 299.04,65.35 298.92,65.24 298.65,65.24 CU5.1
USB3_CTX_C_DRX_N5: length 7.4
  BOTTOM w0.114: LU10.4 306.47,41.57 306.33,41.43 305.2,41.43 302.61,38.84 301.11,38.84 301.1,38.84 CU38.1
USB3_CTX_C_DRX_P1: length 1.5
  TOP w0.114: CU12.1 22.14,56.58 21.85,56.58 21.71,56.72 LU4.4
USB3_CTX_C_DRX_P2: length 9.1
  BOTTOM w0.114: LU7.4 306.47,45.12 306.34,44.99 304.25,44.99 302.94,43.68 302.94,41.61 302.69,41.36 301.14,41.36 CU31.1
USB3_CTX_C_DRX_P4: length 1.5
  TOP w0.114: LU1.4 299.04,64.85 298.87,65.02 298.57,65.02 CU4.1
USB3_CTX_C_DRX_P5: length 7.5
  BOTTOM w0.114: CU39.1 301.19,38.61 302.7,38.61 305.29,41.2 306.34,41.2 306.47,41.07 LU10.1
USB3_CTX_C_L_DRX_N1: length 15.8
  TOP w0.114: LU4.2 19.56,56.22 19.43,56.34 19.17,56.34 19.03,56.2 DU2.4 DU2.7 17.41,56.2 17.27,56.35 16.47,56.35 15.73,55.61 15.73,55.21 15.75,55.2 15.75,54.66 15.73,54.64 v4(15.73,53.49) 15.73,48.95 15.35,48.57 13.7,48.57 13.32,48.95 13.32,49.2 13.16,49.36 12.96,49.36 12.83,49.23 JUSB1.8
USB3_CTX_C_L_DRX_N2: length 5.1
  BOTTOM w0.114: LU7.2 308.52,44.62 308.66,44.76 308.94,44.76 309.08,44.62 DU12.1 DU12.9 310.83,44.62 310.87,44.66 311.19,44.66 311.58,44.27 311.61,44.27 311.72,44.16 312.37,44.16 312.6,43.92 JUSBC2.A3
USB3_CTX_C_L_DRX_N4: length 9.2
  TOP w0.114: LU1.2 301.1,65.35 301.22,65.23 301.61,65.23 301.74,65.36 DU5.4 DU5.7 303.51,65.36 303.64,65.24 304.18,65.24 304.31,65.37 v4(304.31,66.38) 304.31,66.62 305.13,67.44 305.9,67.44 306.65,66.7 306.88,66.7 307.07,66.89 JUSB2.8
USB3_CTX_C_L_DRX_N5: length 9.8
  BOTTOM w0.114: LU10.3 308.7,41.57 309.01,41.88 DU13.7 DU13.4 310.41,41.88 310.74,41.55 310.94,41.34 v4(310.94,40.16) 310.94,39.81 311.42,39.33 311.44,39.33 311.73,39.04 313.35,39.04 313.54,39.23 313.54,40.42 313.8,40.67 JUSBC2.B3
USB3_CTX_C_L_DRX_P1: length 15.8
  TOP w0.114: LU4.3 19.56,56.72 19.41,56.57 19.17,56.57 19.03,56.7 DU2.5 DU2.6 17.39,56.7 17.26,56.57 16.38,56.57 15.51,55.7 v4(15.51,54.93) 15.51,53.78 15.49,53.76 15.49,53.22 15.51,53.2 15.51,49.04 15.26,48.79 13.79,48.79 13.54,49.04 13.54,49.3 13.25,49.58 12.96,49.58 12.83,49.72 JUSB1.9
USB3_CTX_C_L_DRX_P2: length 5.1
  BOTTOM w0.114: LU7.3 308.61,45.12 308.75,44.98 308.94,44.98 309.08,45.12 DU12.2 DU12.8 310.83,45.12 311.06,44.89 311.31,44.89 v4(311.56,44.63) 311.82,44.38 312.47,44.38 312.51,44.42 JUSBC2.A2
USB3_CTX_C_L_DRX_P4: length 9.2
  TOP w0.114: JUSB2.9 307.07,66.35 306.94,66.48 306.55,66.48 305.81,67.22 305.22,67.22 304.56,66.55 304.56,66.12 304.53,66.09 304.53,65.28 304.26,65 v4(304.05,65) 303.65,65 303.51,64.86 DU5.6 DU5.5 301.78,64.86 301.64,65 301.32,65 301.17,64.85 LU1.3
USB3_CTX_C_L_DRX_P5: length 9.9
  BOTTOM w0.114: LU10.2 308.52,41.07 308.83,41.38 DU13.6 DU13.5 310.59,41.38 310.72,41.25 310.72,40.44 310.7,40.43 310.7,39.89 310.72,39.87 310.72,39.71 v4(311.46,38.97) 311.61,38.82 313.45,38.82 313.77,39.14 313.77,40.32 313.89,40.45 313.98,40.45 314.26,40.17 JUSBC2.B2
USB3_RUF1: length 17.9
  TOP w0.114: DU21.2 v2(299.61,35.66) ; v2(312.05,41.3) v1(311.47,41.3)
  IN4 w0.137: v2(312.05,41.3) 309.77,39.01 304.51,39.01 301.16,35.66 v2(299.61,35.66)
  BOTTOM w0.114: v2(312.05,41.3) 312.18,41.42 JUSBC2.A8
USB3_RUF2: length 24.8
  TOP w0.114: v2(299.61,33.73) DU21.3 v1(295.61,33.73)
  IN4 w0.137: v2(313.7,43.17) 313.36,43.17 312.88,42.7 312.88,39.33 312.31,38.76 304.64,38.76 v2(299.61,33.73)
  BOTTOM w0.114: JUSBC2.B8 v2(313.7,43.17)
USB3RN1: length 164.3
  TOP w0.114: v2(24.03,52.87) 23.75,53.14 23.54,53.14 21.83,54.86 21.7,54.86 21.54,54.69 LU5.1
  IN2 w0.104: v2(158.19,52.24) 157.81,52.62 157.81,52.98 157.3,53.49 154.85,53.49 153.3,55.05 79.96,55.05 73.31,61.7 71.46,61.7 68.04,65.11 65.34,65.11 61.21,60.98 58.56,60.98 57.77,61.78 56.63,61.78 56.34,61.49 47.58,61.49 43.01,56.92 41.36,56.92 34.43,49.99 34.43,47.16 31.81,44.54 29.7,44.54 28.14,46.09 28.14,47.78 23.41,52.51 23.41,52.98 23.58,53.14 23.76,53.14 v2(24.03,52.87)
  BOTTOM w0.089: UH1.B7 160.24,49.89 160.03,49.89 159.84,50.07 159.84,50.19 159.2,50.83 159.2,50.91 158.74,51.36 158.69,51.42 158.65,51.42
  BOTTOM w0.114: 158.65,51.42 158.56,51.42 158.19,51.78 v2(158.19,52.24)
USB3RN2: length 218.8
  IN4 w0.147: v2(159.02,50.25) 158.97,50.21 158.4,50.21 156.1,47.9 156.1,45.51 151.99,41.4 151.99,34.55 152.82,33.72 152.82,31.96 153.88,30.89 153.88,20.41 158.99,15.31 158.99,12 164.3,6.69 179.32,6.69 179.8,6.22 201.25,6.22 201.61,5.85 214.29,5.85 219.22,10.78 224.58,10.78 225.21,11.42 233.9,11.42 238.87,16.39 238.87,17.83 252.72,31.68 291.38,31.68 297.07,37.36 300.67,37.36 303.18,39.88 303.18,45.94 303.33,46.08 303.65,46.08 v2(303.78,45.95)
  BOTTOM w0.089: UH1.C8 161.01,49.04 160.67,49.38 160.3,49.38 160.26,49.35 160.01,49.35 159.88,49.48 159.88,49.52 159.35,50.05 159.22,50.05 v2(159.02,50.25)
  BOTTOM w0.114: LU8.1 306.49,46.19 306.34,46.35 304.78,46.35 304.69,46.25 304.08,46.25 v2(303.78,45.95)
USB3RN3: length 157.7
  IN1 w0.104: v2(159.22,49.15) 159.22,49.12 159.48,48.86 159.72,48.86 160.42,49.55 160.42,53.17 162.7,55.46 162.7,75.25 159.89,78.07 157.59,78.07 154.78,80.88 154.78,90.19 162.2,97.62 162.2,98.57 162.83,99.2 162.83,104.14 163.46,104.77 163.46,110.11 168.53,115.17 168.53,127.87 167.82,128.57 167.82,136.53 160.5,143.85 155.32,143.85 154.49,144.68 147.69,144.68 147.06,145.31 139.58,145.31 134.99,149.9 134.99,157.73 133.55,159.16 133.55,161.05 133.36,161.24 133.36,164.14 v2(133.04,164.46)
  BOTTOM w0.089: v2(159.22,49.15) 159.22,49.12 159.35,48.99 159.86,48.99 159.98,48.88 160.22,48.88 160.69,48.41 UH1.B10
  BOTTOM w0.114: CI38.1 132.62,165.58 132.62,165.46 132.78,165.3 v4(133.02,165.06) 133.2,164.88 133.21,164.87 133.21,164.63 v2(133.04,164.46)
USB3RN3_C: length 4.6
  BOTTOM w0.114: CI38.2 132.22,166.91 132.6,167.28 132.6,167.47 132.92,167.79 132.92,168.32 v4(133.31,168.71) 133.94,169.34 133.94,169.6 133.85,169.69 JCDRA.36
USB3RN4: length 213.9
  TOP w0.114: LU2.1 299.13,66.81 299,66.69 299,66.42 298.88,66.3 298.36,66.3 298.02,66.64 298.02,66.94 298.16,67.07 298.4,67.07 v2(298.55,66.93)
  IN4 w0.097: 160.29,43.02 160.31,43.02 160.31,43.02 160.31,43.05 163.27,46 163.27,46.47 163.14,46.6 162.36,46.6 162.06,46.9 v2(162.06,47.37)
  IN4 w0.147: 160.29,43.02 159.51,43.02 158.13,41.63 158.13,41.24 156.03,39.14 156.03,35.02 155.84,34.83 155.84,33.44 156.99,32.29 156.99,28.47 157.33,28.13 157.33,24.18 162.26,19.25 162.26,13.93 164.48,11.71 175.23,11.71 176.03,10.9 187.19,10.9 187.51,11.22 192.37,11.22 193.77,9.82 213.51,9.82 217.43,13.73 220.68,13.73 223.53,16.58 231.52,16.58 231.87,16.93 231.87,18.08 232.42,18.63 234.46,18.63 251.28,35.46 263.86,35.46 264.69,36.29 265.83,36.29 266.38,36.83 270.88,36.83 271.6,37.55 273.7,37.55 277.73,41.58 280.85,41.58 290.83,51.57 292.8,51.57 296.77,55.54 296.77,57.32 297.85,58.4 297.85,61.09 296.11,62.83 296.11,64.48 298.08,66.45 298.08,66.69 298.32,66.93 v2(298.55,66.93)
  BOTTOM w0.089: UH1.E11 v2(162.06,47.37)
USB3RN5: length 211
  IN4 w0.089: 158.65,47.03 158.66,47.05 158.73,47.05 158.93,47.24 160.31,47.24 161.7,45.86 162.09,45.86 162.23,45.99 162.23,46.21 v2(162.2,46.23)
  IN4 w0.147: 158.65,47.03 158.3,46.68 158.3,45.22 156.68,43.6 156.68,42.63 156.05,42 154.64,42 153.9,41.26 153.9,34.69 154.27,34.32 154.27,32.6 155.34,31.53 155.34,21.01 160.8,15.55 160.8,12.59 163.14,10.25 174.31,10.25 175.12,9.45 187.86,9.45 188.11,9.7 191.83,9.7 193.21,8.31 201.57,8.31 202.57,7.31 213.69,7.31 218.62,12.23 223.4,12.23 224.04,12.87 231.86,12.87 252.12,33.13 288.87,33.13 293.98,38.23 293.98,38.65 v2(294.17,38.84)
  BOTTOM w0.097: UH1.G13 162.8,46.6 162.59,46.6 162.23,46.23 v2(162.2,46.23)
  BOTTOM w0.114: v2(294.17,38.84) 293.83,38.84 293.7,38.72 293.7,38.44 293.83,38.31 297.81,38.31 299.58,40.08 302.46,40.08 305.76,43.39 306.27,43.39 306.54,43.66 LU11.4
USB3RP1: length 164.4
  TOP w0.114: LU5.4 21.62,55.19 21.73,55.08 21.92,55.08 23.64,53.36 23.94,53.36 v2(24.03,53.45)
  IN2 w0.104: v2(157.56,52.18) 157.62,52.24 157.62,52.9 157.22,53.3 154.77,53.3 153.22,54.85 79.88,54.85 73.23,61.51 71.38,61.51 67.96,64.92 65.42,64.92 61.29,60.79 58.48,60.79 57.69,61.59 56.71,61.59 56.42,61.3 47.66,61.3 43.09,56.73 41.44,56.73 34.62,49.91 34.62,47.08 31.89,44.35 29.62,44.35 27.95,46.01 27.95,47.7 23.22,52.43 23.22,53.06 23.5,53.33 23.91,53.33 v2(24.03,53.45)
  BOTTOM w0.089: UH1.A7 160.02,49.7 159.96,49.7 159.67,50 159.67,50.11 159.02,50.76 159.02,50.83 158.67,51.19 158.65,51.19
  BOTTOM w0.114: 158.65,51.19 158.46,51.19 157.96,51.69 157.96,51.83 157.62,52.18 v2(157.56,52.18)
USB3RP2: length 218.8
  IN4 w0.147: v2(159.02,49.71) 158.79,49.93 158.52,49.93 156.37,47.79 156.37,45.4 152.27,41.29 152.27,34.66 153.09,33.84 153.09,32.07 154.16,31 154.16,20.53 159.26,15.42 159.26,12.12 164.41,6.97 179.43,6.97 179.91,6.49 201.36,6.49 201.72,6.13 214.18,6.13 219.11,11.06 224.46,11.06 225.1,11.69 233.79,11.69 238.6,16.5 238.6,17.94 252.61,31.95 291.27,31.95 296.95,37.64 300.55,37.64 302.91,39.99 302.91,46.05 303.21,46.36 304.01,46.36 304.12,46.47 304.12,46.7 304,46.82 v2(303.8,46.82)
  BOTTOM w0.089: v2(159.02,49.71) 159.18,49.87 159.27,49.87 159.7,49.45 159.7,49.41 159.94,49.17 160.33,49.17 160.37,49.21 160.59,49.21 160.67,49.13 160.67,49.07 160.55,48.95 UH1.B8
  BOTTOM w0.114: v2(303.8,46.82) 303.8,46.7 304.02,46.48 304.59,46.48 304.69,46.57 306.34,46.57 306.46,46.69 LU8.4
USB3RP3: length 157.8
  IN1 w0.104: v2(133.62,164.46) 133.47,164.3 133.55,164.22 133.55,161.32 133.75,161.13 133.75,159.24 135.18,157.81 135.18,149.98 139.66,145.5 147.14,145.5 147.77,144.87 154.57,144.87 155.4,144.05 160.58,144.05 168.02,136.61 168.02,128.65 168.72,127.95 168.72,115.09 163.65,110.03 163.65,104.69 163.03,104.06 163.03,99.12 162.39,98.49 162.39,97.54 154.97,90.11 154.97,80.96 157.67,78.26 159.97,78.26 162.89,75.33 162.89,55.38 160.61,53.09 160.61,49.47 159.8,48.67 159.3,48.67 v2(159.22,48.58)
  BOTTOM w0.089: v2(159.22,48.58) 159.45,48.81 159.79,48.81 159.83,48.77 159.83,48.67 159.71,48.56 159.71,48.4 159.78,48.34 160.05,48.34 160.14,48.43 UH1.A9
  BOTTOM w0.114: v2(133.62,164.46) 133.44,164.64 133.44,164.96 133.38,165.02 133.38,165.04 133,165.42 132.98,165.42 132.84,165.56 132.84,165.74 CI39.1
USB3RP3_C: length 4.5
  BOTTOM w0.114: JCDRA.37 134.25,169.82 134.19,169.76 134.19,169.27 133.72,168.79 133.72,168.78 133.28,168.34 133.25,168.34 133.14,168.23 133.14,167.7 132.85,167.41 132.85,167.25 133.1,167 CI39.2
USB3RP4: length 213.9
  TOP w0.114: v2(298.31,67.46) 298.18,67.33 298.1,67.33 297.8,67.03 297.8,66.54 298.27,66.07 298.97,66.07 299.21,66.31 LU2.4
  IN4 w0.097: 160.31,42.78 160.36,42.78 160.5,42.92 160.5,42.97 163.46,45.93 163.46,46.54 163.22,46.78 162.44,46.78 162.25,46.98 162.25,47.04 162.54,47.33 162.72,47.33 v2(162.76,47.29)
  IN4 w0.147: v2(298.31,67.46) 298.31,67.31 297.81,66.81 297.81,66.56 295.84,64.59 295.84,62.71 297.58,60.98 297.58,58.51 296.5,57.44 296.5,55.65 292.69,51.84 290.72,51.84 280.73,41.86 277.62,41.86 273.59,37.83 271.49,37.83 270.77,37.11 266.26,37.11 265.72,36.56 264.58,36.56 263.74,35.73 251.17,35.73 234.34,18.9 232.31,18.9 231.6,18.19 231.6,17.04 231.41,16.85 223.41,16.85 220.56,14 217.31,14 213.4,10.09 193.88,10.09 192.48,11.49 187.4,11.49 187.08,11.17 176.15,11.17 175.34,11.98 164.6,11.98 162.53,14.04 162.53,19.37 157.6,24.3 157.6,28.25 157.26,28.59 157.26,32.41 156.12,33.55 156.12,34.72 156.31,34.91 156.31,39.03 157.43,40.14 157.43,40.2 157.43,40.21 157.44,40.21 157.45,40.21 157.45,40.22 158.37,41.14 158.37,41.54 159.61,42.78 160.31,42.78
  BOTTOM w0.089: v2(162.76,47.29) 162.76,47.53 UH1.G11
USB3RP5: length 211
  IN4 w0.089: 158.84,46.84 158.85,46.85 158.85,46.91 159,47.06 160.24,47.06 161.62,45.68 162.17,45.68 162.4,45.92 162.42,45.92 162.74,46.23 v2(162.77,46.23)
  IN4 w0.147: v2(293.19,38.89) 293.4,39.09 293.57,39.09 293.7,38.96 293.7,38.34 288.76,33.4 252,33.4 231.75,13.15 223.92,13.15 223.29,12.51 218.5,12.51 213.58,7.58 202.69,7.58 201.68,8.59 193.33,8.59 191.95,9.97 187.99,9.97 187.75,9.72 175.23,9.72 174.42,10.53 163.26,10.53 161.08,12.7 161.08,15.66 155.61,21.13 155.61,31.65 154.54,32.71 154.54,34.44 154.18,34.8 154.18,41.15 154.76,41.72 156.16,41.72 156.96,42.52 156.96,43.48 158.57,45.1 158.57,46.57 158.84,46.84
  BOTTOM w0.089: v2(162.77,46.23) 162.84,46.23 163.28,46.67 UH1.H13
  BOTTOM w0.114: v2(293.19,38.89) 293.48,38.6 293.48,38.35 293.74,38.09 297.9,38.09 299.67,39.86 302.55,39.86 305.85,43.16 LU11.1
USB3TN1: length 168.3
  TOP w0.114: v2(24.65,57.83) 24.65,56.79 24.13,56.27 23.64,56.27 CU13.2
  IN2 w0.104: v2(24.65,57.83) 24.48,57.66 24.48,57.29 22.3,55.12 22.3,52.68 26.19,48.8 26.19,47.2 29.45,43.94 32.56,43.94 41.1,52.48 42.86,52.48 49.53,59.15 60.45,59.15 65.15,63.84 68.29,63.84 71.05,61.09 73.07,61.09 79.71,54.44 153.05,54.44 156.18,51.32 156.75,51.32 v2(157.14,51.71)
  BOTTOM w0.089: UH1.C11 160.88,48.08 160.73,48.08 160.68,48.13 160.67,48.13 160.66,48.15 159.05,48.15 158.65,48.54 158.65,48.54
  BOTTOM w0.114: v2(157.14,51.71) 157.31,51.54 157.33,51.54 157.33,51.54 157.5,51.54 157.97,51.06 157.97,49.21 158.65,48.54 158.65,48.54
USB3TN2: length 200.6
  IN4 w0.147: v2(296.93,38.83) 296.8,38.96 296.63,38.96 290.07,32.4 252.42,32.4 232.16,12.15 224.63,12.15 223.99,11.51 218.92,11.51 213.99,6.58 202.16,6.58 201.8,6.94 180.1,6.94 179.62,7.42 164.77,7.42 160.07,12.12 160.07,15.25 154.61,20.71 154.61,31.23 153.54,32.3 153.54,34.02 153.18,34.39 153.18,41.56 156.9,45.29 156.9,47.19 157.68,47.97 v2(158.3,47.97)
  BOTTOM w0.089: 158.65,47.82 158.66,47.82 158.67,47.81 158.86,47.81 158.88,47.79 159.98,47.79 160.32,47.45 160.47,47.45 UH1.B12
  BOTTOM w0.114: v2(296.93,38.83) 297.31,38.83 297.34,38.8 297.71,38.8 298.53,39.63 298.53,40.03 299.48,40.98 299.66,40.98 CU30.2 ; 158.65,47.82 158.46,47.82 v2(158.3,47.97)
USB3TN3: length 182.8
  IN4 w0.147: v2(136.19,169.35) 136.33,169.21 136.33,168.89 136.74,168.47 138.44,168.47 139.82,167.1 140.92,167.1 144.38,163.64 147.07,163.64 147.96,164.53 151.7,164.53 152.85,165.68 156.31,165.68 157.05,164.93 167.15,164.93 168.74,163.35 172.3,163.35 176.38,159.27 176.38,155.12 177.69,153.81 177.69,146.79 170.11,139.22 170.11,102.15 171.22,101.05 171.22,92.36 169.01,90.15 165.7,90.15 162.82,87.27 162.82,82.62 160.67,80.48 157.11,80.48 154.36,77.74 154.36,68.2 153.43,67.27 153.43,50.52 153.96,50 154.6,50 154.73,49.87 154.73,49.87 v2(154.73,49.87)
  BOTTOM w0.076: UH1.C13 161.02,46.74 160.89,46.86 160.08,46.86 160.08,46.86 159.94,46.86 159.9,46.89 159.89,46.89 159.88,46.9
  BOTTOM w0.089: 159.88,46.9 159.88,46.91 158.89,46.91 158.74,46.75 158.7,46.75 158.66,46.71 158.65,46.71
  BOTTOM w0.114: JCDRA.42 136.25,169.86 136.32,169.79 136.32,169.48 v2(136.19,169.35) ; v2(154.73,49.87) 154.73,49.87 154.73,49.89 154.91,50.08 155.01,50.08 155.18,50.24 156.03,50.24 157.05,49.22 157.05,48.72 157.03,48.71 157.03,48.17 157.05,48.15 157.05,47.31 157.64,46.71 158.65,46.71
USB3TN4: length 212.4
  TOP w0.114: CU5.2 297.31,65.56 296.56,65.56 296.21,65.21 296.21,64.07 296.61,63.67 297.03,63.67 v2(297.19,63.5)
  IN4 w0.147: v2(159.17,46.48) 159.17,44.65 157.41,42.89 157.41,42.3 156.36,41.26 155.19,41.26 154.74,40.81 154.74,34.88 155,34.63 155,32.94 156.06,31.87 156.06,21.32 161.53,15.85 161.53,12.89 163.44,10.98 174.92,10.98 175.73,10.17 187.56,10.17 187.81,10.42 192.13,10.42 193.51,9.04 202.1,9.04 203,8.14 213.5,8.14 218.32,12.96 220.95,12.96 223.64,15.65 224.42,15.65 224.86,15.21 224.86,14.96 225.45,14.38 227.41,14.38 228.18,15.14 231.46,15.14 232.49,16.17 233.08,16.17 251.52,34.61 264.73,34.61 265.69,35.56 271.1,35.56 272.3,36.77 274.18,36.77 278.27,40.86 282.91,40.86 292.81,50.76 293.07,50.76 298.46,56.16 298.46,57.11 298.72,57.36 298.72,61.3 296.9,63.12 296.9,63.4 297,63.5 v2(297.19,63.5)
  BOTTOM w0.089: v2(159.17,46.48) 159.59,46.16 159.88,46.16 159.97,46.24 UH1.A14
USB3TN5: length 212.2
  IN4 w0.147: v2(297.45,36.62) 297.76,36.31 297.76,35.73 293.25,31.22 252.91,31.22 239.33,17.64 239.33,16.2 232.56,9.44 224.89,9.44 223.77,8.32 223.77,6.62 222.09,4.93 217.49,4.93 216.66,5.76 214.9,5.76 214.54,5.4 200.96,5.4 200.6,5.76 186,5.76 179.68,5.76 179.47,5.55 164.8,5.55 158.54,11.82 158.54,15.12 153.43,20.22 153.43,30.7 152.36,31.77 152.36,33.53 151.54,34.36 151.54,41.69 155.59,45.74 155.59,48.27 155.3,48.56 155.12,48.56 154.83,48.86 v2(154.83,49.05)
  BOTTOM w0.089: 158.65,45.99 158.71,45.99 158.76,45.94 160.23,45.94 160.34,46.04 160.42,46.04 160.47,46.09 160.47,46.14 160.52,46.19 160.67,46.19 UH1.B14
  BOTTOM w0.114: 158.65,45.99 v4(158,45.99) 157.68,45.99 156.59,47.07 156.59,48.11 156.19,48.51 155.15,48.51 154.83,48.83 v2(154.83,49.05) ; v2(297.45,36.62) 297.51,36.69 297.51,37.1 299.3,38.89 299.66,38.89 CU38.2
USB3TP1: length 168.4
  TOP w0.114: CU12.2 23.39,56.8 23.69,56.5 24.04,56.5 24.43,56.88 24.43,57.47 24.24,57.65 v2(24.07,57.83)
  IN2 w0.104: v2(157.14,51.12) 156.1,51.12 152.97,54.25 79.63,54.25 72.99,60.89 70.97,60.89 68.21,63.65 65.23,63.65 60.53,58.95 49.61,58.95 42.94,52.28 41.18,52.28 32.64,43.75 29.37,43.75 25.99,47.12 25.99,48.72 22.11,52.6 22.11,55.2 24.28,57.37 24.28,57.61 v2(24.07,57.83)
  BOTTOM w0.089: 158.65,48.24 158.7,48.24 158.97,47.97 160.22,47.97 160.29,47.91 160.29,47.74 160.4,47.63 160.61,47.63 160.67,47.69 160.67,47.79 UH1.B11
  BOTTOM w0.114: v2(157.14,51.12) 157.33,51.31 157.4,51.31 157.75,50.97 157.75,49.12 158.63,48.24 158.65,48.24
USB3TP2: length 200.6
  IN4 w0.147: v2(297.45,39.52) 297.16,39.23 296.92,39.23 296.52,39.23 289.96,32.68 252.31,32.68 232.05,12.42 224.52,12.42 223.88,11.78 218.81,11.78 213.88,6.85 202.28,6.85 201.92,7.22 180.21,7.22 179.73,7.69 164.88,7.69 160.35,12.23 160.35,15.36 154.88,20.83 154.88,31.34 153.82,32.41 153.82,34.14 153.45,34.5 153.45,41.45 157.18,45.17 157.18,47.08 157.8,47.7 158.01,47.7 158.3,47.4 v2(158.3,47.39)
  BOTTOM w0.089: 158.65,47.59 158.67,47.61 159.46,47.61 159.53,47.55 159.53,47.4 159.59,47.33 159.72,47.33 159.78,47.4 159.78,47.55 159.84,47.61 159.91,47.61 160.14,47.39 UH1.A12
  BOTTOM w0.114: v2(297.45,39.52) 297.28,39.36 297.28,39.18 297.43,39.03 297.61,39.03 298.3,39.72 298.3,40.12 299.38,41.2 299.39,41.2 CU31.2 ; 158.65,47.59 158.51,47.59 v2(158.3,47.39)
USB3TP3: length 182.8
  IN4 w0.147: v2(154.85,50.46) 154.66,50.27 154.07,50.27 153.7,50.64 153.7,67.15 154.64,68.08 154.64,77.62 157.22,80.2 160.79,80.2 163.09,82.51 163.09,87.15 165.81,89.88 169.12,89.88 171.49,92.25 171.49,101.16 170.38,102.27 170.38,139.1 177.96,146.68 177.96,153.92 176.65,155.23 176.65,159.38 172.41,163.62 168.85,163.62 167.27,165.21 157.16,165.21 156.42,165.95 152.73,165.95 151.59,164.81 147.84,164.81 146.95,163.92 144.49,163.92 141.04,167.37 139.93,167.37 138.56,168.74 136.86,168.74 136.6,169 136.6,169.18 v2(136.77,169.35)
  BOTTOM w0.076: 160.01,47.03 161.14,47.03 UH1.D13
  BOTTOM w0.089: 160.01,47.03 159.95,47.08 158.81,47.08 158.66,46.94 158.65,46.94
  BOTTOM w0.114: 158.65,46.94 157.74,46.94 157.27,47.4 v4(157.27,48.44) 157.27,49.32 156.13,50.46 v2(154.85,50.46) ; v2(136.77,169.35) 136.54,169.58 136.54,169.73 136.65,169.84 JCDRA.43
USB3TP4: length 212.2
  TOP w0.114: CU4.2 297.36,64.82 296.85,65.33 296.65,65.33 296.43,65.11 296.43,64.16 296.7,63.89 297.05,63.89 297.19,64.03 v2(297.45,64.03)
  IN4 w0.147: v2(297.45,64.03) 297.14,64.03 296.62,63.52 296.62,63.01 298.44,61.19 298.44,57.48 298.19,57.22 298.19,56.27 292.95,51.04 292.7,51.04 282.8,41.13 278.16,41.13 274.07,37.04 272.19,37.04 270.99,35.84 265.57,35.84 264.62,34.89 251.4,34.89 232.96,16.44 232.38,16.44 231.35,15.42 228.06,15.42 227.29,14.65 225.56,14.65 225.13,15.08 225.13,15.33 224.54,15.92 223.52,15.92 220.84,13.23 218.2,13.23 213.38,8.41 203.11,8.41 202.21,9.32 193.63,9.32 192.25,10.7 187.69,10.7 187.44,10.45 175.84,10.45 175.04,11.25 163.56,11.25 161.8,13 161.8,15.96 156.34,21.43 156.34,31.99 155.27,33.05 155.27,34.74 155.02,34.99 155.02,40.7 155.3,40.98 156.48,40.98 157.68,42.19 157.68,42.78 159.44,44.54 159.44,46.2 159.73,46.49 v2(159.73,46.52)
  BOTTOM w0.089: v2(159.73,46.52) 159.83,46.62 160.11,46.62 160.35,46.38 160.46,46.38 160.52,46.44 UH1.B13
USB3TP5: length 212.2
  IN4 w0.147: v2(154.83,48.28) 155.19,48.28 155.32,48.16 155.32,45.85 151.27,41.8 151.27,34.24 152.09,33.42 152.09,31.65 153.16,30.59 153.16,20.11 158.26,15 158.26,11.7 164.69,5.27 179.58,5.27 179.79,5.49 186,5.49 200.48,5.49 200.85,5.13 214.65,5.13 215.01,5.49 216.55,5.49 217.37,4.66 222.2,4.66 224.04,6.5 224.04,8.21 225,9.17 232.68,9.17 239.6,16.09 239.6,17.53 253.02,30.95 293.36,30.95 298.03,35.62 v2(298.03,36.62)
  BOTTOM w0.089: 158.65,45.76 160.31,45.76 160.42,45.87 160.76,45.87 160.95,45.97 UH1.C14
  BOTTOM w0.114: 158.65,45.76 158.28,45.76 158.26,45.74 157.6,45.74 156.37,46.98 156.37,48.02 156.1,48.28 v2(154.83,48.28) ; CU39.2 299.9,38.4 299.64,38.66 299.39,38.66 297.74,37.01 297.74,36.92 v2(298.03,36.62)
USB20_CAM_N7_R: length 7.9
  TOP w0.114: LV2.3 129.97,154.73 129.76,154.52 129.23,154.52 v4(129.05,154.7) 128.86,154.88 128.86,155.06 129.29,155.49 DV4.3 129,155.76 128.88,155.89 128.88,156.26 129.46,156.84 129.46,157.47 129.32,157.61 129.32,158.19 129.34,158.21 129.34,158.75 129.32,158.77 129.32,159.19 129.39,159.26 129.53,159.26 129.6,159.33 JEDP.19
USB20_CAM_P7_R: length 7.9
  TOP w0.114: LV2.2 129.97,154.23 129.91,154.3 129.11,154.3 128.64,154.76 128.64,155.15 128.29,155.49 DV4.2 128.5,155.76 128.65,155.92 128.65,156.35 129.24,156.93 129.24,157.38 129.1,157.51 v4(129.1,158.48) JEDP.20
USB20_N1: length 209.2
  TOP w0.114: v2(19.85,45.71) 19.88,45.74 UU1.2
  IN2 w0.104: v2(173.27,50.61) 173.14,50.47 172.27,50.47 171.46,49.66 171.46,47.42 171.25,47.2 167.33,47.2 167,46.87 160.76,46.87 159.9,46.01 156.17,46.01 154.06,43.91 152.02,43.91 149.16,41.05 147.91,41.05 146.32,39.46 146.32,38.12 144.86,36.67 142.94,36.67 142,35.73 142,31.09 139.76,28.86 126.62,28.86 126.46,28.7 114.39,28.7 110.02,24.32 103.12,24.32 95.42,24.32 95.14,24.6 91.98,24.6 91.77,24.81 78.53,24.81 75.07,28.27 75.07,44.19 74.18,45.08 74.18,49.35 76.09,51.25 76.09,53.57 74.2,55.46 54.8,55.46 50.9,51.56 41.05,51.56 33.02,43.53 32.96,43.47 32.96,43.22 32.63,42.89 32.29,42.89 31.84,43.33 28.68,43.33 25.23,46.78 20.35,46.78 19.85,46.29 v2(19.85,45.71)
  BOTTOM w0.089: UH1.AF5 172.7,50.61 v2(173.27,50.61)
USB20_N1_CONN: length 13.3
  BOTTOM w0.114: LU3.2 21.41,48.35 21.63,48.12 21.63,47.96 21.91,47.68 22.13,47.68 22.25,47.56 22.25,46.92 21.79,46.46 19.94,46.46 19.25,47.15 18.68,47.15 18.46,47.37 DU1.3 17.6,47.3 17.01,47.3 v4(16.48,46.77) 15.92,46.21 14.46,46.21 14.33,46.34 JUSB1.2
USB20_N2: length 204.7
  TOP w0.114: LU6.4 297.46,67.4 297.19,67.4 296.85,67.05 296.85,66.89 v2(297.14,66.59)
  IN2 w0.104: v2(171.08,49.72) 170.79,49.43 170.58,49.43 170.45,49.56 170.45,51.15 171.48,52.18 173.7,52.18 173.92,52.4 183.14,52.4 183.7,51.84 187.83,51.84 187.97,51.69 187.97,46.25 188.8,45.43 188.8,37.85 189.31,37.34 189.31,28.66 193.66,24.31 193.66,14.74 195.57,12.82 208.19,12.82 211.78,16.4 214.68,16.4 217.16,18.89 217.16,19.3 218.2,20.34 222.86,20.34 223.67,21.15 227.69,21.15 233.08,26.55 233.08,38.47 234.52,39.91 242.4,39.91 246.35,43.86 272.39,43.86 274.79,46.26 290.49,46.26 294.53,50.3 294.53,62.77 296.88,65.13 296.88,66.33 v2(297.14,66.59)
  BOTTOM w0.089: UH1.AD5 171.62,50.29 171.08,49.75 v2(171.08,49.72)
USB20_N2_CONN: length 10.6
  TOP w0.114: v2(303.16,70.34) 302.97,70.53 302.65,70.53 301.43,69.31 301.03,69.31 300.91,69.18 DU4.3 299.84,69.52 299.42,69.52 299.07,69.18 299.05,69.18 298.97,69.1 298.97,68.91 LU6.3
  IN1 w0.104: JUSB2.2 305.57,69.38 305.45,69.5 304.87,69.5 303.84,70.53 303.35,70.53 v2(303.16,70.34)
USB20_N3: length 162.8
  IN1 w0.104: v2(173.23,48.27) 173.1,48.14 172.92,48.14 172.8,48.26 172.8,51.08 173.81,52.09 173.81,54.12 171.77,56.16 168.5,56.16 166.26,58.4 166.26,64.43 164.1,66.59 164.1,75.83 164.04,75.89 160.47,79.46 159.97,79.46 158.66,79.46 156.17,81.95 156.17,89.61 163.6,97.04 163.6,97.99 164.23,98.62 164.23,102.07 165.04,102.89 165.04,103.72 167.59,106.27 167.59,112.26 169.93,114.59 169.93,128.45 169.22,129.15 169.22,137.11 161.82,144.52 161.82,145.11 161.27,145.66 161,145.66 160.95,145.7 160.02,145.7 159.57,145.25 157.04,145.25 156.21,146.08 152.99,146.08 152.25,146.81 150.65,146.81 149.22,148.24 143.34,148.24 142.7,147.6 142.13,147.6 140.86,148.87 140.86,149.59 139.29,151.16 138.19,151.16 136.4,152.94 136.4,158.34 135.93,158.81 135.93,162.29 134.91,163.31 134.91,164.91 134.35,165.47 134.35,165.65 v2(134.45,165.76)
  BOTTOM w0.089: UH1.AG8 172.72,48.79 v2(173.23,48.27)
  BOTTOM w0.114: LM1.1 134.5,166.2 134.29,165.98 134.29,165.93 v2(134.45,165.76)
USB20_N3_CONN: length 3.7
  BOTTOM w0.114: LM1.2 134.5,167.99 134.38,168.11 134.38,168.33 134.51,168.46 134.88,168.46 v4(135.12,168.69) 135.33,168.91 135.33,169.65 135.45,169.77 JCDRA.40
USB20_N4: length 160.5
  TOP w0.114: v2(266.11,44.68) 266.11,38.99 266.22,38.88 UE1.5
  IN2 w0.104: v2(266.11,44.68) 266.11,45.37 265.58,45.89 246.96,45.89 241.77,40.71 234.19,40.71 232.29,38.8 232.29,26.91 227.33,21.95 223.34,21.95 222.56,21.17 217.28,21.17 213.67,17.55 211.8,17.55 207.86,13.61 195.9,13.61 194.45,15.07 194.45,24.7 190.13,29.02 190.13,37.74 189.63,38.25 189.63,46.78 188.8,47.6 188.8,51.99 188.16,52.63 184.6,52.63 184,53.24 182.35,53.24 181.91,53.68 177.73,53.68 177.25,53.2 173.24,53.2 172.85,53.59 172.85,53.69 172.46,54.08 171.59,54.08 v2(171.52,54.15)
  BOTTOM w0.089: v2(171.52,54.15) 171.52,54.07 171.88,53.71 171.88,53.35 171.71,53.18 171.71,52.54 171.83,52.41 171.91,52.41 UH1.AE1
USB20_N5: length 193.1
  IN2 w0.104: v2(171.1,50.85) 171.37,50.57 171.65,50.57 172.49,51.41 173.2,51.41 173.87,52.08 180.88,52.08 181.88,51.09 181.88,51.04 182.17,50.75 184.67,50.75 185.02,50.4 185.02,47.57 188.35,44.24 188.35,37.32 188.74,36.94 188.74,28.62 193.25,24.11 193.25,14.57 195.41,12.41 208.36,12.41 211.95,15.99 215.06,15.99 218.97,19.9 223.14,19.9 223.98,20.74 227.06,20.74 228.22,19.58 233.22,19.58 233.7,20.06 233.7,38.51 234.69,39.5 242.61,39.5 245.92,42.82 283.62,42.82 286.06,45.25 294.01,45.25 299.59,50.82 299.93,50.82 v2(300.15,51.05)
  BOTTOM w0.089: UH1.AC2 171.14,51.63 171.14,50.9 v2(171.1,50.85)
  BOTTOM w0.114: v2(300.15,51.05) 300.33,50.87 300.61,50.87 300.75,51 JWLAN.5
USB20_N6: length 169.8
  TOP w0.114: DV2.3 131.16,155.81 131.02,155.95 131.02,156.26 130.44,156.85 v4(130.44,158.48) 130.44,159.07 130.6,159.23 JEDP.17 130.6,160.43 130.46,160.57 130.46,160.81 130.29,160.99 130.29,161.17 v2(130.49,161.38)
  IN1 w0.104: v2(172.25,53.5) 172.25,53.37 172.38,53.24 172.56,53.24 172.68,53.37 172.68,54.16 171.97,54.87 168.56,54.87 165.11,58.32 165.11,60.8 163.3,62.6 163.3,75.5 160.14,78.67 158.33,78.67 155.38,81.62 155.38,89.94 162.8,97.37 162.8,98.32 163.43,98.95 163.43,102.4 164.23,103.19 164.23,110.02 169.13,114.92 169.13,128.12 168.43,128.82 168.43,136.78 160.75,144.46 155.57,144.46 154.74,145.28 148.03,145.28 146.67,146.65 145.01,146.65 144.44,147.22 143.62,147.22 142.31,145.91 140.73,145.91 139.78,146.86 139.78,147.31 139.77,147.32 139.77,147.41 139.14,148.05 139.14,148.85 138.36,149.63 137.48,149.63 135.6,151.51 135.6,157.97 134.92,158.65 134.92,161.79 134.07,162.64 134.07,164.62 133.73,164.96 132.3,164.96 130.05,162.71 130.05,161.91 130.16,161.81 130.37,161.81 130.49,161.68 v2(130.49,161.38)
  BOTTOM w0.089: v2(172.25,53.5) 172.43,53.5 172.63,53.3 172.63,52.68 172.54,52.6 172.48,52.6 172.43,52.55 172.43,52.17 172.51,52.08 UH1.AF2
