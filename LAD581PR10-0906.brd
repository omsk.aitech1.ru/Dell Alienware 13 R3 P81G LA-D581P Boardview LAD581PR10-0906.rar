# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D26: length 50.8
  IN5 w0.089: 111.28,80.7 110.5,79.92 110.5,75.35
  IN5 w0.097: v2(112.34,86.71) 111.28,85.66 111.28,80.7 ; 110.5,75.35 110.5,69.52 104.28,63.29 104.28,53.55 104.18,53.45 103.77,53.45 103.68,53.36 103.68,53.16 103.77,53.07 104.18,53.07 104.28,52.97 104.28,52.78 104.18,52.68 103.77,52.68 103.68,52.59 103.68,52.39 103.77,52.3 104.18,52.3 104.28,52.2 104.28,51.98 103.69,51.39 103.69,47.63 v2(102.5,46.44)
  BOTTOM w0.076: v2(112.34,86.71) 112.01,87.04 CPU1.BC4
  BOTTOM w0.114: JDIMM1.79 101.53,47.41 v2(102.5,46.44)
DDR_A_D27: length 50.4
  IN5 w0.089: 110.99,80.65 110.21,79.87 110.21,75.38
  IN5 w0.097: v2(102.5,47.71) 103.38,48.59 103.38,53.75 103.47,53.85 103.87,53.85 103.96,53.95 103.96,54.14 103.87,54.24 103.47,54.24 103.38,54.33 103.38,54.53 103.47,54.62 103.87,54.62 103.96,54.72 103.96,54.91 103.87,55.01 103.47,55.01 103.38,55.1 103.38,55.3 103.47,55.39 103.87,55.39 103.96,55.49 103.96,55.68 103.87,55.78 103.47,55.78 103.38,55.88 103.38,56.1 103.47,56.2 103.88,56.2 103.98,56.29 103.98,56.49 103.88,56.58 103.47,56.58 103.38,56.68 103.38,62.82 110.21,69.64 110.21,75.38 ; v2(112.35,87.36) 110.99,85.99 110.99,80.65
  BOTTOM w0.076: CPU1.BC5 112.03,87.69 v2(112.35,87.36)
  BOTTOM w0.114: JDIMM1.83 102.53,47.74 v2(102.5,47.71)
DDR_A_D28: length 51.3
  IN5 w0.097: v2(99.35,45.17) 99.75,45.57 99.75,45.77 101.29,47.3 101.29,48.2 101.87,48.78 101.87,63.01 109,70.13 109,75.35 109.34,75.69 109.34,81.25 109.77,81.68 v2(109.77,83.49)
  BOTTOM w0.076: v2(109.77,83.49) 110.15,83.87 110.15,84.07 110.5,84.42 110.5,85.55 110.59,85.64 110.59,87.17 CPU1.BD5
  BOTTOM w0.114: JDIMM1.66 98.27,44.09 v2(99.35,45.17)
DDR_A_D29: length 51.2
  IN5 w0.097: v2(99.35,46.44) 99.35,46.33 99.48,46.2 99.77,46.2 100.99,47.43 100.99,48.38 101.03,48.42 101.03,48.6 100.85,48.77 100.85,48.95 100.98,49.08 101.16,49.08 101.36,48.87 101.49,48.87 101.58,48.96 101.58,63.13 108.7,70.26 108.7,75.35 109.16,75.8 109.16,81.32 109.59,81.76 109.59,82.78 v2(109.32,83.04)
  BOTTOM w0.076: CPU1.BD4 110.81,86.74 110.81,85.54 110.66,85.39 110.66,84.68 110.72,84.62 110.72,83.88 109.89,83.04 v2(109.32,83.04)
  BOTTOM w0.114: JDIMM1.71 99.53,48.61 99.77,48.37 99.77,46.85 v2(99.35,46.44)
DDR_A_D30: length 50.8
  IN5 w0.089: 111.58,80.74 110.8,79.96 110.8,75.35
  IN5 w0.097: 110.8,75.35 110.8,69.4 104.58,63.17 104.58,51.85 103.99,51.27 103.99,50.18 104.09,50.08 104.44,50.08 104.53,49.99 104.53,49.79 104.44,49.7 104.09,49.7 103.99,49.6 103.99,49.41 104.09,49.31 104.44,49.31 104.53,49.21 104.53,49.02 104.44,48.92 104.09,48.92 103.99,48.83 103.99,48.63 104.09,48.54 104.44,48.54 104.53,48.44 104.53,48.25 104.44,48.15 104.09,48.15 103.99,48.06 103.99,46.46 102.7,45.17 v2(102.5,45.17) ; v2(112.35,84.75) 111.58,83.98 111.58,80.74
  BOTTOM w0.076: v2(112.35,84.75) 112.01,85.09 CPU1.BC1
  BOTTOM w0.114: JDIMM1.80 101.78,43.27 102.05,43.54 102.05,44.72 v2(102.5,45.17)
DDR_A_D31: length 50.9
  IN5 w0.089: 111.1,75.35 111.1,80
  IN5 w0.097: 111.1,80 112.74,81.63 112.74,85.28 112.62,85.41 v2(112.34,85.41) ; 111.1,75.35 111.1,69.27 104.88,63.04 104.88,47.85 104.78,47.76 104.39,47.76 104.29,47.66 104.29,47.47 104.39,47.37 104.78,47.37 104.88,47.27 104.88,47.08 104.78,46.98 104.39,46.98 104.29,46.89 104.29,46.69 104.39,46.6 104.78,46.6 104.88,46.5 104.88,46.28 v2(102.5,43.9)
  BOTTOM w0.076: CPU1.BC2 112.01,85.74 v2(112.34,85.41)
  BOTTOM w0.114: v2(102.5,43.9) 102.78,43.62 JDIMM1.84
DDR_A_D32: length 52
  IN5 w0.097: v2(126.67,43.94) 126.92,43.94 127.18,44.2 127.65,44.2 127.74,44.3 127.74,44.49 127.65,44.59 127.18,44.59 127.08,44.68 127.08,44.87 127.18,44.97 127.65,44.97 127.77,45.09 127.77,45.32 127.67,45.42 127.27,45.42 127.18,45.51 127.18,45.71 127.27,45.8 127.67,45.8 127.77,45.9 127.77,46.47 127.65,46.59 127.65,46.95 127.73,47.04 127.73,47.89 127.83,47.99 128.03,47.99 128.13,48.08 128.13,48.27 128.03,48.37 127.83,48.37 127.73,48.47 127.73,48.66 127.83,48.76 128.03,48.76 128.13,48.85 128.13,50.26 127.73,50.65 127.73,54.7 127.64,54.79 127.26,54.79 127.16,54.89 127.16,55.08 127.26,55.18 127.64,55.18 127.73,55.28 127.73,56.15 131.19,59.6 131.19,75.35 127.63,78.9 127.63,80.74 v2(128.3,81.41)
  BOTTOM w0.076: v2(128.3,81.41) 128.73,81.83 128.73,85.07 CPU1.AB1
  BOTTOM w0.114: JDIMM1.174 127.28,43.33 v2(126.67,43.94)
DDR_A_D33: length 52.7
  IN5 w0.097: v2(126.67,46.48) 126.67,46.38 126.92,46.13 127.22,46.13 127.35,46.25 127.35,47.73 127.43,47.81 127.43,48.94 127.53,49.04 127.73,49.04 127.83,49.14 127.83,49.33 127.73,49.43 127.53,49.43 127.43,49.52 127.43,49.75 127.53,49.84 127.73,49.84 127.83,49.94 127.83,50.13 127.73,50.23 127.53,50.23 127.43,50.33 127.43,54.4 127.34,54.49 126.96,54.49 126.86,54.59 126.86,55.7 130.89,59.73 130.89,75.35 127.45,78.79 127.45,82.08 127.59,82.22 v2(127.79,82.22)
  BOTTOM w0.076: v2(127.79,82.22) 128.51,82.93 128.51,84.89 128.43,84.97 128.43,85.46 CPU1.AB2
  BOTTOM w0.114: JDIMM1.169 126.02,48.79 125.91,48.68 125.28,48.68 125.17,48.56 125.17,48.33 125.28,48.22 125.91,48.22 126.02,48.1 126.02,47.88 125.91,47.76 125.28,47.76 125.17,47.65 125.17,47.42 125.28,47.3 125.91,47.3 126.02,47.19 126.02,46.61 126.15,46.48 v2(126.67,46.48)
DDR_A_D34: length 51.9
  IN5 w0.097: v2(129.89,86.71) 129.91,86.71 130.26,86.36 130.26,84.75 130.03,84.52 129.74,84.52 129.32,84.1 129.32,82.13 130.02,81.43 130.02,80.52 130.54,79.99 130.54,78.27 133.28,75.53 133.28,58.73 131.93,57.38 131.93,54.49 130.22,52.78 130.22,48.14 130.43,47.93 130.43,43.27 130.3,43.14 129.83,43.14 129.68,43.29 129.68,43.8 129.83,43.96 v2(130.03,43.96)
  BOTTOM w0.076: CPU1.AA4 129.56,87.04 v2(129.89,86.71)
  BOTTOM w0.114: v2(130.03,43.96) 130.28,43.71 JDIMM1.186
DDR_A_D35: length 52.1
  IN5 w0.097: v2(129.88,87.27) 128.66,86.06 128.66,81.82 129.18,81.3 129.18,80.56 129.98,79.76 129.98,77.75 132.38,75.35 132.38,59.1 129.19,55.91 129.19,52.09 129.32,51.95 129.32,46.1 129.23,46 128.76,46 128.67,45.91 128.67,45.71 128.76,45.62 129.23,45.62 129.32,45.52 129.32,45.05 129.45,44.92 129.72,44.92 v2(130.03,45.23)
  BOTTOM w0.076: CPU1.AA5 129.46,87.69 v2(129.88,87.27)
  BOTTOM w0.114: v2(130.03,45.23) 129.28,44.48 JDIMM1.182
DDR_A_D36: length 52.4
  IN5 w0.097: v2(126.67,45.21) 126.26,45.62 126.26,55.95 130.28,59.97 130.28,75.35 127.08,78.56 127.08,83.22 v2(127.82,83.97)
  BOTTOM w0.076: v2(127.82,83.97) 128.18,84.32 128.18,84.7 128.1,84.78 128.1,87.08 CPU1.AB5
  BOTTOM w0.114: JDIMM1.170 126.28,43.32 125.17,44.43 125.17,45.49 125.34,45.66 126.22,45.66 v2(126.67,45.21)
DDR_A_D37: length 51.8
  IN5 w0.097: v2(127.82,83.36) 127.47,83.36 127.26,83.15 127.26,78.67 130.59,75.35 130.59,59.85 126.56,55.83 126.56,54.1 126.66,54 127.04,54 127.13,53.91 127.13,53.71 127.04,53.62 126.66,53.62 126.56,53.52 126.56,53.33 126.66,53.23 127.04,53.23 127.13,53.14 127.13,52.94 127.04,52.85 126.66,52.85 126.56,52.75 126.56,52.53 126.66,52.43 127.04,52.43 127.13,52.33 127.13,51.12 127,50.99 126.66,50.99 126.56,50.89 126.56,50.7 126.66,50.6 127.01,50.6 127.13,50.48 127.13,50.28 127.04,50.19 126.66,50.19 126.56,50.09 126.56,49.9 126.66,49.8 127.04,49.8 127.13,49.71 127.13,49.51 127.04,49.42 126.66,49.42 126.56,49.32 126.56,49.13 126.66,49.03 127.04,49.03 127.13,48.93 127.13,48.74 127.04,48.64 126.66,48.64 126.56,48.55 126.56,48.35 126.66,48.26 127.04,48.26 127.13,48.16 127.13,47.94 126.95,47.75 v2(126.67,47.75)
  BOTTOM w0.076: CPU1.AB4 128.42,86.74 128.42,85.9 128.26,85.75 128.26,84.86 128.34,84.79 128.34,83.88 v2(127.82,83.36)
  BOTTOM w0.114: JDIMM1.173 127.03,49.9 127.03,48.11 v2(126.67,47.75)
DDR_A_D38: length 51.7
  IN5 w0.097: v2(129.89,85.5) 128.85,84.46 128.85,81.96 129.45,81.36 129.45,80.55 130.17,79.84 130.17,77.98 132.68,75.47 132.68,58.98 129.87,56.17 129.87,55.93 130.27,55.53 130.27,55.33 130.17,55.23 129.62,55.23 129.49,55.1 129.49,54.91 129.62,54.79 130.17,54.79 130.27,54.69 130.27,54.5 130.17,54.4 129.59,54.4 129.49,54.31 129.49,54.11 129.59,54.02 130.01,54.02 130.11,53.92 130.11,53.73 130.01,53.64 129.75,53.64 129.62,53.51 129.62,46.62 129.75,46.5 v2(130.03,46.5)
  BOTTOM w0.076: v2(129.89,85.5) 129.66,85.74 CPU1.AA2
  BOTTOM w0.114: JDIMM1.183 129.53,48.84 129.41,48.73 129.1,48.73 128.98,48.61 128.98,48.38 129.1,48.27 129.41,48.27 129.53,48.15 129.53,47.93 129.41,47.81 129.1,47.81 128.98,47.7 128.98,47.47 129.1,47.35 129.41,47.35 129.53,47.24 129.53,46.53 129.65,46.4 129.93,46.4 v2(130.03,46.5)
DDR_A_D39: length 52.1
  IN5 w0.097: v2(130.03,47.77) 129.92,47.87 129.92,52.91 130.57,53.55 130.57,53.69 130.41,53.85 130.41,53.99 130.55,54.12 130.68,54.12 130.84,53.96 130.98,53.96 131.27,54.25 131.27,54.48 131.17,54.57 130.67,54.57 130.57,54.68 130.57,54.84 130.67,54.95 131.53,54.95 131.63,55.05 131.63,55.25 131.54,55.34 130.66,55.34 130.57,55.44 130.57,55.63 130.66,55.73 131.54,55.73 131.63,55.83 131.63,56.02 131.54,56.12 130.63,56.12 130.53,56.21 130.53,56.41 131.01,56.89 131.15,56.89 131.36,56.67 131.5,56.67 131.63,56.81 131.63,56.95 131.42,57.16 131.42,57.29 132.98,58.85 132.98,75.52 130.35,78.15 130.35,79.91 129.74,80.53 129.74,81.39 129.04,82.1 129.04,84.38 129.55,84.9 v2(129.89,84.9)
  BOTTOM w0.076: v2(129.89,84.9) 129.89,85.04 129.75,85.17 129.53,85.17 CPU1.AA1
  BOTTOM w0.114: v2(130.03,47.77) 130.03,47.69 130.27,47.45 130.65,47.45 130.78,47.58 130.78,48.24 130.65,48.37 129.93,48.37 129.82,48.48 129.82,48.71 129.93,48.82 130.4,48.82 130.53,48.95 JDIMM1.187
DDR_A_D40: length 50.9
  IN5 w0.097: v2(129.89,83.44) 129.51,83.06 129.51,82.31 130.29,81.52 130.29,80.5 130.73,80.07 130.73,78.64 134.01,75.35 134.01,58.43 132.67,57.08 132.67,54.19 130.95,52.48 130.95,48.45 131.16,48.24 131.16,44.22 131.36,44.02 v2(131.99,44.02)
  BOTTOM w0.076: v2(129.89,83.44) 130.61,84.17 130.61,85.2 130.61,85.85 130.61,86.5 130.61,87.08 CPU1.V5
  BOTTOM w0.114: JDIMM1.190 131.28,43.3 v2(131.99,44.02)
DDR_A_D41: length 50.5
  IN5 w0.097: v2(131.99,47.83) 131.89,47.83 131.76,47.96 131.76,48.49 131.55,48.69 131.55,48.92 131.65,49.01 132.08,49.01 132.17,49.11 132.17,49.3 132.08,49.4 131.65,49.4 131.55,49.5 131.55,49.69 131.65,49.79 132.08,49.79 132.17,49.88 132.17,50.08 132.08,50.17 131.65,50.17 131.55,50.27 131.55,50.49 131.65,50.59 132.08,50.59 132.17,50.69 132.17,50.88 132.08,50.98 131.65,50.98 131.55,51.07 131.55,52.23 133.6,54.28 133.6,54.56 133.73,54.69 134.01,54.69 134.1,54.78 134.1,54.94 134.01,55.03 133.48,55.03 133.38,55.14 133.38,55.31 133.48,55.42 134.03,55.42 134.12,55.51 134.12,55.71 134.03,55.8 133.36,55.8 133.26,55.9 133.26,56.09 133.36,56.19 134.03,56.19 134.12,56.29 134.12,56.48 134.03,56.58 133.46,56.58 133.32,56.71 133.32,56.89 134.61,58.18 134.61,75.35 131.1,78.86 131.1,80.22 130.69,80.63 130.69,81.89 v2(130.79,81.99)
  BOTTOM w0.076: v2(130.79,81.99) 130.94,82.14 130.94,85.46 CPU1.V2
  BOTTOM w0.114: JDIMM1.195 132.53,48.36 v2(131.99,47.83)
DDR_A_D42: length 50.6
  IN5 w0.097: v2(132.39,84.87) 132.39,84.94 132.2,85.14 131.97,85.14 131.85,85.01 131.85,82.24 133.91,80.18 133.91,78.45 137.01,75.35 137.01,53.81 136.63,53.43 136.49,53.43 136.38,53.54 136.25,53.54 136.11,53.4 136.11,53.27 136.22,53.16 136.22,53.02 136.08,52.89 135.95,52.89 135.84,52.99 135.7,52.99 135.57,52.86 135.57,52.72 135.67,52.61 135.67,52.48 135.54,52.34 135.4,52.34 135.29,52.45 135.16,52.45 135.02,52.31 135.02,52.17 135.13,52.07 135.13,51.93 135.08,51.89 135.08,50.15 135.18,50.05 135.49,50.05 135.59,49.95 135.59,49.77 135.49,49.66 135.18,49.66 135.08,49.57 135.08,49.34 135.18,49.25 135.43,49.25 135.53,49.14 135.53,48.96 135.43,48.86 135.18,48.86 135.08,48.76 135.08,48.57 135.18,48.47 135.43,48.47 135.53,48.37 135.53,48.19 135.43,48.09 135.18,48.09 135.08,47.99 135.08,47.66 135.21,47.54 135.44,47.54 v2(135.67,47.77)
  BOTTOM w0.076: v2(132.39,84.87) 132.18,85.09 CPU1.U1
  BOTTOM w0.114: JDIMM1.207 135.53,49.01 135.33,48.81 134.76,48.81 134.57,48.62 134.57,47.35 134.82,47.1 135.05,47.1 135.67,47.72 v2(135.67,47.77)
DDR_A_D43: length 50.9
  IN5 w0.097: v2(132.41,85.44) 132.41,85.58 132.23,85.76 131.79,85.76 131.66,85.63 131.66,82.16 133.72,80.1 133.72,78.33 136.71,75.35 136.71,54.42 134.27,51.98 134.27,50.91 134.4,50.78 134.66,50.78 134.78,50.66 134.78,47.29 134.91,47.16 134.95,47.16 135.08,47.03 135.08,46.72 134.91,46.55 134.91,46.41 135.16,46.16 135.34,46.16 v2(135.67,46.5)
  BOTTOM w0.076: CPU1.U2 132.11,85.74 v2(132.41,85.44)
  BOTTOM w0.114: v2(135.67,46.5) 135.67,46.45 135.24,46.02 134.57,46.02 134.25,46.34 134.25,48.81 134.53,49.09 JDIMM1.203
DDR_A_D44: length 50.3
  IN5 w0.089: 131.24,80.34 131.23,80.34 130.87,80.7 130.87,81.45 131,81.58 131.19,81.58 v2(131.24,81.54)
  IN5 w0.097: 131.24,80.34 131.28,80.3 131.28,78.98 134.91,75.35 134.91,58.04 134.76,57.89 134.76,57.73 134.91,57.57 134.91,57.47 134.82,57.37 134.23,57.37 134.13,57.27 134.13,57.09 134.23,56.99 134.82,56.99 134.91,56.89 134.91,56.7 134.82,56.6 134.52,56.6 134.42,56.5 134.42,56.31 134.52,56.22 134.82,56.22 134.91,56.12 134.91,55.93 134.82,55.83 134.52,55.83 134.42,55.73 134.42,55.54 134.52,55.44 134.82,55.44 134.91,55.35 134.91,55.17 134.78,55.04 134.58,55.04 134.45,54.91 134.45,54.71 132.47,52.73 132.47,49.38 132.57,49.28 132.89,49.28 132.99,49.19 132.99,48.99 132.89,48.9 132.57,48.9 132.47,48.8 132.47,48.72 132.38,48.62 132.16,48.62 132.06,48.52 132.06,48.34 132.16,48.24 132.38,48.24 132.47,48.14 132.47,46.46 132.35,46.33 132.16,46.33 131.99,46.5 v2(131.99,46.56)
  BOTTOM w0.076: v2(131.24,81.54) 131.22,81.55 CPU1.V1
  BOTTOM w0.114: v2(131.99,46.56) 131.53,47.03 JDIMM1.191
DDR_A_D45: length 50.9
  IN5 w0.097: v2(129.89,82.89) 129.82,82.89 129.69,82.76 129.69,82.38 130.5,81.57 130.5,80.55 130.91,80.15 130.91,78.75 134.31,75.35 134.31,58.3 132.96,56.96 132.96,54.98 133.06,54.88 133.2,54.88 133.3,54.79 133.3,54.59 133.2,54.5 133.06,54.5 132.96,54.4 132.96,54.07 131.25,52.36 131.25,48.57 131.46,48.36 131.46,45.16 131.61,45.01 131.81,45.01 131.99,45.2 v2(131.99,45.29)
  BOTTOM w0.076: v2(129.89,82.89) 130.78,83.77 130.78,85.27 130.78,86.44 131.22,86.89 CPU1.V4
  BOTTOM w0.114: JDIMM1.194 132.28,43.35 132.47,43.54 132.47,44.82 v2(131.99,45.29)
DDR_A_D46: length 50.6
  IN5 w0.097: v2(132.41,87.36) 131.29,86.25 131.29,82.01 133.35,79.95 133.35,78.1 136.11,75.35 136.11,54.67 133.67,52.23 133.67,50.4 134.18,49.88 134.18,46.63 134.27,46.54 134.27,45.36 v2(135.67,43.96)
  BOTTOM w0.076: CPU1.U5 132.08,87.69 v2(132.41,87.36)
  BOTTOM w0.114: v2(135.67,43.96) 135.77,43.85 JDIMM1.208
DDR_A_D47: length 50.1
  IN5 w0.097: v2(132.41,86.71) 131.48,85.78 131.48,82.09 133.54,80.02 133.54,78.22 136.41,75.35 136.41,54.55 133.97,52.11 133.97,50.52 134.48,50.01 134.48,46.75 134.57,46.67 134.57,46.33 v2(135.67,45.23)
  BOTTOM w0.076: v2(132.41,86.71) 132.08,87.04 CPU1.U4
  BOTTOM w0.114: JDIMM1.204 134.77,44.33 v2(135.67,45.23)
DDR_A_D48: length 49.7
  IN5 w0.097: v2(134.2,82.33) 134.12,82.4 133.69,82.4 133.48,82.2 133.48,81.39 138.34,76.54 138.34,53.13 138.06,52.85 138.06,52.69 138.24,52.5 138.24,52.32 138.09,52.17 137.94,52.17 137.66,52.45 137.53,52.45 137.39,52.31 137.39,52.17 137.68,51.89 137.68,51.75 137.54,51.61 137.4,51.61 137.12,51.9 136.98,51.9 136.84,51.76 136.84,51.63 137.11,51.36 137.11,51.18 136.96,51.04 136.96,48.61 137.06,48.51 137.27,48.51 137.36,48.41 137.36,48.25 137.24,48.13 137.06,48.13 136.96,48.03 136.96,46.69 137.09,46.56 v2(137.51,46.56)
  BOTTOM w0.076: CPU1.R2 133.46,85.46 133.46,84.9 133.52,84.84 133.52,84.2 133.76,83.96 133.76,83.33 134.2,82.89 v2(134.2,82.33)
  BOTTOM w0.114: v2(137.51,46.56) 136.53,47.55 JDIMM1.211
DDR_A_D49: length 50
  IN5 w0.097: v2(134.92,87.36) 134.07,86.51 134.07,83.69 139.83,77.93 139.83,51.79 139.44,51.39 139.44,48 140.01,47.43 140.01,45.08 v2(141.13,43.96)
  BOTTOM w0.076: CPU1.P5 134.59,87.69 v2(134.92,87.36)
  BOTTOM w0.114: v2(141.13,43.96) 140.77,43.6 JDIMM1.228
DDR_A_D50: length 50
  IN5 w0.097: v2(137.51,45.29) 137.51,45.23 137.24,44.96 137,44.96 136.62,45.34 136.62,50.37 136.12,50.87 136.12,51.47 138.04,53.38 138.04,76.57 133.3,81.31 v2(133.3,83.23)
  BOTTOM w0.076: v2(133.3,83.23) 133.29,83.23 133.29,85.73 133.44,85.88 133.44,86.74 CPU1.R4
  BOTTOM w0.114: JDIMM1.212 136.77,44.55 v2(137.51,45.29)
DDR_A_D51: length 49.8
  IN5 w0.097: v2(141.13,45.23) 140.31,46.05 140.31,47.55 139.74,48.13 139.74,50.55 140.31,51.13 140.31,77.87 134.26,83.93 134.26,86.05 v2(134.92,86.71)
  BOTTOM w0.076: CPU1.P4 134.59,87.04 v2(134.92,86.71)
  BOTTOM w0.114: JDIMM1.224 139.77,43.87 v2(141.13,45.23)
DDR_A_D52: length 50
  IN5 w0.097: v2(132.85,83.68) 132.85,81.5 137.74,76.61 137.74,53.51 135.81,51.58 135.81,50.76 136.32,50.25 136.32,45.21 v2(137.51,44.02)
  BOTTOM w0.076: CPU1.R5 133.13,87.08 133.13,84.42 132.85,84.14 v2(132.85,83.68)
  BOTTOM w0.114: v2(137.51,44.02) 137.77,43.76 JDIMM1.216
DDR_A_D53: length 49.6
  IN5 w0.097: v2(134.92,85.41) 134.84,85.5 134.57,85.5 134.44,85.37 134.44,84.19 140.64,78 140.64,50.66 140.54,50.57 140.18,50.57 140.04,50.42 140.04,48.25 140.61,47.68 140.61,46.62 140.74,46.5 v2(141.13,46.5)
  BOTTOM w0.076: v2(134.92,85.41) 134.92,85.59 134.77,85.74 CPU1.P2
  BOTTOM w0.114: JDIMM1.225 140.02,49.06 139.77,48.8 139.77,46.05 139.99,45.83 140.51,45.83 141.13,46.45 v2(141.13,46.5)
DDR_A_D54: length 50.3
  IN5 w0.097: v2(137.51,47.83) 137.68,47.67 138.04,47.67 138.24,47.86 138.24,48.69 138.11,48.82 137.36,48.82 137.26,48.91 137.26,49.11 137.36,49.2 138.14,49.2 138.24,49.3 138.24,49.49 138.14,49.59 137.36,49.59 137.26,49.69 137.26,49.88 137.36,49.98 138.14,49.98 138.24,50.07 138.24,50.27 138.14,50.36 137.36,50.36 137.26,50.46 137.26,50.66 137.36,50.76 138.09,50.76 138.24,50.91 138.24,51.89 138.64,52.29 138.64,76.59 133.74,81.49 133.74,81.7 133.96,81.92 v2(134.6,81.92)
  BOTTOM w0.076: CPU1.R1 133.74,84.39 134.02,84.11 134.02,83.45 135.12,82.36 135.12,82.05 134.99,81.92 v2(134.6,81.92)
  BOTTOM w0.114: JDIMM1.215 137.52,49 137.4,48.88 137.18,48.88 136.92,48.62 136.92,47.86 137.11,47.67 137.35,47.67 v2(137.51,47.83)
DDR_A_D55: length 49.6
  IN5 w0.097: v2(141.13,47.77) 140.94,47.96 140.94,48.21 140.84,48.3 140.43,48.3 140.33,48.4 140.33,48.59 140.43,48.69 140.84,48.69 140.94,48.79 140.94,49.01 140.84,49.11 140.43,49.11 140.33,49.2 140.33,49.4 140.43,49.49 140.84,49.49 140.94,49.59 140.94,49.78 140.84,49.88 140.43,49.88 140.33,49.98 140.33,50.17 140.43,50.27 140.84,50.27 140.94,50.36 140.94,78.15 134.63,84.46 134.63,84.64 134.76,84.77 v2(134.92,84.77)
  BOTTOM w0.076: v2(134.92,84.77) 134.92,84.94 134.77,85.09 CPU1.P1
  BOTTOM w0.114: JDIMM1.229 141.02,49.04 140.82,48.84 140.57,48.84 140.08,48.36 140.08,46.59 140.21,46.46 140.59,46.46 140.72,46.59 140.72,47.6 140.89,47.77 v2(141.13,47.77)
DDR_A_D56: length 50.7
  IN5 w0.097: v2(143.48,46.5) 142.4,46.5 142.27,46.62 142.27,50.35 142.69,50.77 142.69,51.6 142.27,52.02 142.27,68.07 142.49,68.29 142.49,79.14 139.28,82.35 138.9,82.35 137.26,84 136.85,84 v2(136.26,83.41)
  BOTTOM w0.076: v2(136.26,83.41) 136.26,84.02 136.01,84.28 136.01,84.53 135.81,84.73 135.81,86.59 CPU1.M4
  BOTTOM w0.114: v2(143.48,46.5) 142.02,47.95 JDIMM1.233
DDR_A_D57: length 50.4
  IN5 w0.097: v2(143.48,43.96) 143.48,43.67 143.23,43.41 141.92,43.41 141.67,43.67 141.67,50.6 142.09,51.02 142.09,51.36 141.67,51.77 141.67,68.42 141.85,68.6 141.85,78.94 141.27,79.52 141.27,79.68 138.96,81.98 138.75,81.98 138.17,82.56 137.74,82.56 137.61,82.44 v2(137.61,82.06)
  BOTTOM w0.076: CPU1.M1 136.38,84.96 136.38,84.53 136.95,83.96 136.95,83.69 137.61,83.03 v2(137.61,82.06)
  BOTTOM w0.114: v2(143.48,43.96) 142.77,43.25 JDIMM1.236
DDR_A_D58: length 50.9
  IN5 w0.097: v2(137.44,86.75) 137.73,86.75 143.12,81.36 143.23,81.36 144.59,80.01 144.59,53.57 145.27,52.88 145.27,50.71 145.37,50.62 145.84,50.62 145.94,50.52 145.94,50.33 145.84,50.23 145.37,50.23 145.27,50.14 145.27,47.4 146.17,46.5 v2(147.04,46.5)
  BOTTOM w0.076: v2(137.44,86.75) 137.15,87.04 CPU1.L4
  BOTTOM w0.114: JDIMM1.245 145.02,48.51 v2(147.04,46.5)
DDR_A_D59: length 51
  IN5 w0.097: v2(137.43,85.41) 137.59,85.57 138.6,85.57 144.29,79.88 144.29,53.44 144.97,52.76 144.97,47.27 145.86,46.38 145.86,45 145.99,44.87 146.69,44.87 v2(147.04,45.23)
  BOTTOM w0.076: v2(137.43,85.41) 137.1,85.74 CPU1.L2
  BOTTOM w0.114: JDIMM1.246 145.28,43.46 v2(147.04,45.23)
DDR_A_D60: length 51.2
  IN5 w0.097: v2(143.48,47.77) 143.08,48.17 143.08,49.09 142.98,49.18 142.67,49.18 142.57,49.28 142.57,49.47 142.67,49.57 143.38,49.57 143.48,49.67 143.48,49.86 143.38,49.96 142.71,49.96 142.59,50.07 142.59,50.25 142.69,50.35 143.35,50.35 143.48,50.48 143.48,50.66 143.38,50.75 143.09,50.75 142.99,50.85 142.99,51.73 142.57,52.15 142.57,67.86 142.79,68.09 142.79,79.26 139.52,82.54 138.98,82.54 136.83,84.69 136.35,84.69 135.81,84.16 v2(135.81,83.86)
  BOTTOM w0.076: v2(135.81,83.86) 135.81,84.42 135.64,84.59 135.64,87.08 CPU1.M5
  BOTTOM w0.114: v2(143.48,47.77) 143.09,48.16 143.09,48.98 143.02,49.04 JDIMM1.237
DDR_A_D61: length 50.8
  IN5 w0.097: v2(137.16,82.51) 137.4,82.75 138.24,82.75 138.83,82.17 139.04,82.17 142.19,79.01 142.19,68.52 141.97,68.3 141.97,51.9 142.39,51.48 142.39,50.9 141.97,50.48 141.97,45.07 142.1,44.94 143.19,44.94 v2(143.48,45.23)
  BOTTOM w0.076: v2(137.16,82.51) 137.16,83.1 136.66,83.6 136.66,83.94 136.18,84.43 136.18,84.6 135.97,84.8 135.97,85.46 CPU1.M2
  BOTTOM w0.114: v2(143.48,45.23) 141.77,43.52 JDIMM1.232
DDR_A_D62: length 50.8
  IN5 w0.097: v2(137.44,87.4) 137.44,87.33 143.19,81.57 143.45,81.57 144.89,80.13 144.89,53.69 145.57,53.01 145.57,51.04 145.7,50.92 146.02,50.92 146.24,50.71 146.24,49.93 146.11,49.81 145.67,49.81 145.57,49.71 145.57,49.55 145.67,49.45 146.14,49.45 146.24,49.35 146.24,49.16 146.14,49.06 145.67,49.06 145.57,48.97 145.57,48.77 145.67,48.68 146.14,48.68 146.24,48.58 146.24,48.36 146.14,48.26 145.67,48.26 145.57,48.16 145.57,47.97 145.67,47.87 146.22,47.87 146.33,47.77 v2(147.04,47.77)
  BOTTOM w0.076: v2(137.44,87.4) 137.15,87.69 CPU1.L5
  BOTTOM w0.114: JDIMM1.249 146.03,48.78 v2(147.04,47.77)
DDR_A_D63: length 50.1
  IN5 w0.097: v2(137.44,84.8) 138.03,85.39 138.36,85.39 143.99,79.76 143.99,53.32 144.67,52.63 144.67,47.15 145.56,46.26 145.56,44.08 145.69,43.96 v2(147.04,43.96)
  BOTTOM w0.076: CPU1.L1 137.15,85.09 v2(137.44,84.8)
  BOTTOM w0.114: JDIMM1.250 146.28,43.19 v2(147.04,43.96)
DDR_A_DQS0: length 58.7
  IN5 w0.089: 100.03,85.17 100.06,85.17 100.06,85.17 100.42,85.17 100.65,85.4 100.65,86.3 100.77,86.41 101.12,86.41 v2(101.29,86.24)
  IN5 w0.097: v2(84.4,46.12) 84.75,46.47 84.75,46.47 85,46.71 85,49.92 85.1,50.02 85.4,50.02 85.61,50.23 85.61,50.67 85.4,50.88 85.1,50.88 85,50.98 85,51.55 85.1,51.66 85.97,51.66 86.21,51.89 86.21,52.3 85.99,52.52 85.58,52.52 85.49,52.61 85.49,53.29 91.1,58.91 91.1,67.2 97.9,74 97.9,75.34 98.19,75.63 98.19,83.53 99.83,85.17 100.03,85.17
  BOTTOM w0.076: CPU1.BP5 104.07,87.46 103.72,87.81 103.29,87.81 103.07,87.59 102.08,87.59 101.9,87.41 101.67,87.41 101.24,86.98 101.24,86.29 v2(101.29,86.24)
  BOTTOM w0.114: v2(84.4,46.12) 84.62,46.34 84.81,46.34 85.25,46.78 85.25,48.17 84.91,48.51 84.91,48.98 85.02,49.09 JDIMM1.13
DDR_A_DQS1: length 56.5
  IN5 w0.089: 102.24,75.35 102.24,75.37 102.24,75.38 102.24,80.53 101.78,80.98 101.78,81.81 102.47,82.5 102.72,82.5 102.85,82.37 102.85,82.13 v2(102.75,82.03)
  IN5 w0.097: v2(89.52,44.85) 89.52,44.91 89.69,45.08 90,45.08 90.51,45.58 90.51,47.89 91.02,48.4 91.02,49 92.79,50.77 92.79,55.32 94.83,57.35 94.83,65.52 102.24,72.93 102.24,75.34 102.24,75.35
  BOTTOM w0.076: CPU1.BK3 106.57,86.09 106.57,85.62 106.93,85.25 106.93,84.79 104.08,81.94 103.15,81.94 103.06,82.03 v2(102.75,82.03)
  BOTTOM w0.114: v2(89.52,44.85) 89.34,45.04 89.03,45.04 88.91,44.91 88.91,43.94 89.33,43.52 89.86,43.52 90.12,43.27 90.12,42.63 90.27,42.48 JDIMM1.34
DDR_A_DQS2: length 52.7
  IN5 w0.089: 105.97,75.35 105.97,75.37 105.96,75.38 105.96,78.69 105.02,79.63 105.02,80.28 105.15,80.41 105.33,80.41 v2(105.56,80.18)
  IN5 w0.097: 105.97,75.35 105.97,71.39 98.56,63.98 98.56,54.29 97.83,53.55 97.83,50.53 95.83,48.53 95.83,46.49 95.6,46.25 95.15,46.25 v2(95.02,46.12)
  BOTTOM w0.076: v2(105.56,80.18) 105.82,80.43 106.05,80.43 109.3,83.67 109.3,83.83 109.32,83.83 109.35,83.86 109.35,84.52 109.1,84.76 109.08,84.76 109.05,84.8 109.05,85.87 109.21,86.03 109.21,86.27 CPU1.BF3
  BOTTOM w0.114: v2(95.02,46.12) 95.22,46.32 95.49,46.32 95.84,46.67 95.84,48 95.38,48.45 95.38,48.98 95.53,49.12 JDIMM1.55
DDR_A_DQS3: length 51.4
  IN5 w0.089: v2(110.42,81.28) 110.42,81.39 110.3,81.51 110.12,81.51 109.7,81.1 109.7,75.42 109.7,75.35
  IN5 w0.097: 109.7,75.35 109.7,75.3 109.7,75.3 109.7,75.24 109.69,75.23 109.69,69.84 102.57,62.72 102.57,48.49 101.98,47.9 101.98,45.8 101.25,45.07 100.9,45.07 v2(100.68,44.85)
  BOTTOM w0.076: v2(110.42,81.28) 110.42,81.41 110.76,81.75 111.31,81.75 111.55,81.99 111.55,86.05 111.73,86.23 111.73,86.27 CPU1.BC3
  BOTTOM w0.114: JDIMM1.76 100.78,42.52 100.65,42.64 100.65,43.24 100.27,43.63 100.27,44.96 100.4,45.09 100.55,45.09 100.68,44.96 v2(100.68,44.85)
DDR_A_DQS4: length 48.7
  IN5 w0.089: 131.69,75.35 131.69,75.37 127.98,79.08 127.98,79.41 128.55,79.98 128.69,80.1 v2(128.72,80.47)
  IN5 w0.097: v2(128.17,46.8) 128.3,46.67 128.48,46.67 128.63,46.82 128.63,50.47 128.24,50.86 128.24,55.94 131.69,59.38 131.69,75.35
  BOTTOM w0.076: CPU1.AB3 128.92,86.39 129,86.3 129,84.81 129.17,84.64 129.17,80.39 129.08,80.3 128.88,80.3 v2(128.72,80.47)
  BOTTOM w0.114: v2(128.17,46.8) 127.95,46.58 127.83,46.58 127.71,46.71 127.71,47.64 128.4,48.34 128.4,48.98 128.53,49.1 JDIMM1.179
DDR_A_DQS5: length 51.1
  IN5 w0.089: 135.41,75.35 131.84,78.92 131.84,79.99 132.14,80.29 v2(132.14,80.64)
  IN5 w0.097: v2(133.84,44.97) 133.65,45.16 133.63,45.18 133.28,45.18 132.98,45.47 132.98,46.51 133.22,46.76 133.4,46.76 133.5,46.85 133.5,47.07 133.39,47.17 133.2,47.17 132.98,47.4 132.98,48.2 133.19,48.41 133.35,48.41 133.5,48.55 133.5,49.59 133.34,49.74 133.18,49.74 132.98,49.95 132.98,52.51 135.42,54.96 135.42,75.34 135.41,75.35
  BOTTOM w0.076: CPU1.V3 131.42,86.39 131.52,86.3 131.52,84.07 132.58,83.01 132.58,80.83 132.39,80.64 v2(132.14,80.64)
  BOTTOM w0.114: JDIMM1.200 133.77,42.48 133.67,42.58 133.67,43.24 133.29,43.62 133.29,44.99 133.48,45.17 133.64,45.17 v2(133.84,44.97)
DDR_A_DQS6: length 50.4
  IN5 w0.089: v2(135.61,80.98) 135.94,80.98 136.06,81.1 136.4,81.1 139.33,78.18 139.33,77.46 139.33,77.46
  IN5 w0.097: v2(139.35,46.88) 139.35,46.8 139.21,46.66 138.98,46.66 138.63,46.32 138.26,46.32 138.1,46.48 138.1,46.85 138.23,46.98 138.65,46.98 138.93,47.27 138.93,51.6 139.33,52 139.33,77.46
  BOTTOM w0.076: v2(135.61,80.98) 135.74,80.85 135.89,80.85 136.07,81.02 136.07,81.68 134.66,83.09 134.66,83.92 134.03,84.55 134.03,86.2 134.12,86.29 134.12,86.38 134.05,86.46 133.81,86.46 CPU1.R3
  BOTTOM w0.114: JDIMM1.221 139.02,49.12 138.88,48.98 138.88,48.13 138.63,47.88 138.63,46.84 138.78,46.69 139.17,46.69 v2(139.35,46.88)
DDR_A_DQS7: length 51.1
  IN5 w0.089: 142.32,80.45 142.3,80.46 142.3,80.48 138.59,84.2 138.4,84.2 138.34,84.13 v2(138.34,83.86)
  IN5 w0.097: 142.32,80.45 142.33,80.45 143.3,79.47 143.3,53.02 143.98,52.35 143.98,45.58 144.43,45.13 144.85,45.13 v2(145.07,44.91)
  BOTTOM w0.076: v2(138.34,83.86) 138.27,83.92 137.92,83.92 137.78,83.78 137.47,83.78 136.64,84.61 136.64,84.71 136.54,84.81 136.54,86.09 CPU1.M3
  BOTTOM w0.114: v2(145.07,44.91) 144.85,45.13 144.59,45.13 144.35,44.89 144.35,43.68 144.16,43.49 144.16,42.57 144.28,42.45 JDIMM1.242
DDR_A_DQS#0: length 58.7
  IN5 w0.089: v2(101.62,86.72) 101.55,86.65 101.37,86.65 101.25,86.77 100.87,86.77 100.47,86.37 100.47,85.48 100.35,85.35 100.06,85.35 100.06,85.35 100.03,85.35
  IN5 w0.097: v2(84.4,46.76) 84.5,46.66 84.68,46.66 84.81,46.79 84.81,50 85.02,50.21 85.3,50.21 85.43,50.33 85.43,50.59 85.32,50.7 85.02,50.7 84.81,50.9 84.81,51.63 85.03,51.84 85.89,51.84 86.02,51.97 86.02,52.23 85.91,52.33 85.5,52.33 85.3,52.54 85.3,53.37 90.92,58.98 90.92,67.28 97.72,74.08 97.72,75.42 98,75.7 98,83.61 99.75,85.35 100.03,85.35
  BOTTOM w0.076: CPU1.BR5 103.42,87.19 103.42,87.08 103.52,86.98 103.82,86.98 103.91,87.07 103.91,87.25 103.82,87.34 103.82,87.43 103.62,87.62 103.38,87.62 103.18,87.42 102.69,87.42 102.64,87.37 102.17,87.37 101.99,87.19 101.76,87.19 101.58,87.01 101.5,86.93 101.5,86.78 101.55,86.72 v2(101.62,86.72)
  BOTTOM w0.114: v2(84.4,46.76) 84.58,46.58 84.71,46.58 85.01,46.89 85.01,48.06 84.67,48.4 84.67,48.98 84.53,49.12 JDIMM1.11
DDR_A_DQS#1: length 56.5
  IN5 w0.089: 102.05,75.35 102.05,75.35 102.05,75.37 102.06,75.38 102.06,80.46 101.6,80.91 101.6,81.88 102.4,82.68 102.8,82.68 102.99,82.48 v2(103.2,82.48)
  IN5 w0.097: 102.05,75.35 102.05,73.01 94.64,65.6 94.64,57.43 92.61,55.4 92.61,50.85 90.83,49.08 90.83,48.47 90.33,47.96 90.33,45.66 89.93,45.26 89.75,45.26 v2(89.52,45.49)
  BOTTOM w0.076: CPU1.BL3 106.24,86.39 106.31,86.32 106.37,86.25 106.37,85.57 106.76,85.19 106.76,84.92 103.94,82.1 103.29,82.1 103.2,82.2 v2(103.2,82.48)
  BOTTOM w0.114: JDIMM1.32 89.78,42.54 89.87,42.64 89.87,43.16 89.76,43.28 89.22,43.28 88.66,43.84 88.66,45.01 88.93,45.28 89.32,45.28 v2(89.52,45.49)
DDR_A_DQS#2: length 52.7
  IN5 w0.089: v2(105.56,80.81) 105.33,80.58 105.08,80.58 104.85,80.35 104.85,79.56 105.79,78.61 105.79,75.38 105.78,75.37 105.78,75.35
  IN5 w0.097: 105.78,75.35 105.78,75.34 105.78,71.47 98.38,64.06 98.38,54.36 97.64,53.63 97.64,50.6 95.65,48.61 95.65,46.56 95.52,46.44 95.34,46.44 v2(95.02,46.76)
  BOTTOM w0.076: v2(105.56,80.81) 105.77,80.6 105.99,80.6 109.13,83.74 109.13,84.43 108.88,84.67 108.88,85.94 109.03,86.09 109.03,86.5 108.95,86.57 108.69,86.57 108.59,86.48 CPU1.BG3
  BOTTOM w0.114: v2(95.02,46.76) 95.21,46.56 95.38,46.56 95.59,46.77 95.59,47.9 95.14,48.35 95.14,48.98 95.02,49.1 JDIMM1.53
DDR_A_DQS#3: length 51.5
  IN5 w0.089: 109.51,75.35 109.51,75.35 109.51,75.38 109.52,75.39 109.52,75.42 109.52,75.43 109.52,81.17 110.27,81.91 v2(110.42,81.91)
  IN5 w0.097: v2(100.68,45.49) 100.92,45.25 101.17,45.25 101.8,45.88 101.8,47.98 102.38,48.57 102.38,62.8 109.51,69.92 109.51,75.35
  BOTTOM w0.076: CPU1.BD3 111.21,86.49 111.42,86.49 111.51,86.39 111.51,86.27 111.39,86.14 111.39,82.06 111.24,81.91 v2(110.42,81.91)
  BOTTOM w0.114: v2(100.68,45.49) 100.53,45.33 100.29,45.33 100.02,45.06 100.02,43.53 100.41,43.14 100.41,42.63 100.27,42.5 JDIMM1.74
DDR_A_DQS#4: length 49.2
  IN5 w0.089: 131.88,75.35 131.88,75.36 131.87,75.37 131.87,75.42 131.87,75.43 131.87,75.45 128.15,79.16 128.15,79.34 128.67,79.85 128.8,79.97 v2(129.17,79.94)
  IN5 w0.097: 131.88,75.35 131.87,75.34 131.87,59.31 128.43,55.86 128.43,50.94 128.82,50.54 128.82,46.75 128.52,46.44 128.44,46.44 v2(128.17,46.16)
  BOTTOM w0.076: v2(129.17,79.94) 129.17,80.08 129.39,80.3 129.39,84.73 129.17,84.95 129.17,86.11 CPU1.AA3
  BOTTOM w0.114: v2(128.17,46.16) 127.99,46.34 127.73,46.34 127.46,46.61 127.46,47.74 128.16,48.44 128.16,48.92 128.02,49.05 JDIMM1.177
DDR_A_DQS#5: length 51.1
  IN5 w0.089: v2(132.59,80.19) 132.28,80.19 132.02,79.92 132.02,79 135.48,75.53 135.49,75.53 135.53,75.49 135.54,75.49 135.61,75.43 135.61,75.35
  IN5 w0.097: v2(133.84,45.61) 133.59,45.36 133.35,45.36 133.17,45.55 133.17,46.44 133.3,46.57 133.47,46.57 133.68,46.78 133.68,47.15 133.47,47.36 133.28,47.36 133.16,47.48 133.16,48.12 133.26,48.22 133.43,48.22 133.68,48.47 133.68,49.67 133.42,49.93 133.26,49.93 133.16,50.03 133.16,52.44 135.61,54.88 135.61,75.35
  BOTTOM w0.076: v2(132.59,80.19) 132.59,80.53 132.8,80.74 132.8,83.1 131.73,84.16 131.73,84.87 131.68,84.93 131.68,86.11 CPU1.U3
  BOTTOM w0.114: v2(133.84,45.61) 133.65,45.42 133.37,45.42 133.05,45.09 133.05,43.52 133.43,43.14 133.43,42.63 133.28,42.48 JDIMM1.198
DDR_A_DQS#6: length 50.3
  IN5 w0.089: v2(136.06,80.53) 136.03,80.56 136.03,80.82 136.14,80.92 136.33,80.92 139.15,78.1 139.15,77.28 139.15,77.27
  IN5 w0.097: v2(139.35,46.24) 139.35,46.33 139.21,46.47 139.06,46.47 138.71,46.13 138.19,46.13 137.92,46.4 137.92,46.93 138.15,47.17 138.57,47.17 138.75,47.35 138.75,51.68 139.15,52.08 139.15,77.27
  BOTTOM w0.076: v2(136.06,80.53) 136.06,80.71 136.28,80.93 136.28,81.77 134.88,83.18 134.88,84.01 134.19,84.69 134.19,86.11 CPU1.P3
  BOTTOM w0.114: JDIMM1.219 138.52,49.09 138.63,48.98 138.63,48.23 138.39,47.98 138.39,46.73 138.68,46.44 139.15,46.44 v2(139.35,46.24)
DDR_A_DQS#7: length 50.9
  IN5 w0.089: v2(137.89,84.31) 138.26,84.31 138.33,84.37 138.66,84.37 142.44,80.6 142.44,80.6 142.45,80.58
  IN5 w0.097: 142.45,80.58 143.49,79.55 143.49,53.1 144.16,52.42 144.16,45.66 144.51,45.32 144.84,45.32 v2(145.07,45.54)
  BOTTOM w0.076: CPU1.L3 136.71,86.11 136.71,84.95 136.86,84.8 136.86,84.7 137.56,84 137.69,84 137.89,84.2 v2(137.89,84.31)
  BOTTOM w0.114: v2(145.07,45.54) 144.91,45.39 144.49,45.39 144.49,45.38 144.49,45.37 144.1,44.99 144.1,43.78 143.91,43.59 143.91,42.58 143.77,42.44 JDIMM1.240
DDR_A_MA0: length 53.1
  IN5 w0.145: v2(122.79,80.73) 122.5,80.73 122.35,80.57 122.35,79.64 122.47,79.51 122.47,77.08 123.67,75.89 123.67,71.19 122.41,69.93 122.41,66.04 117.77,61.39 117.77,44.4 118,44.18 118.57,44.18 118.74,44.35 118.74,44.75 119.19,45.2 v2(119.19,45.35)
  BOTTOM w0.076: v2(122.79,80.73) 123.83,80.73 123.96,80.86 123.96,86.11 CPU1.AH3
  BOTTOM w0.178: v2(119.19,45.35) 117.77,43.94 JDIMM1.144
DDR_A_MA1: length 49.5
  IN5 w0.145: v2(117.77,82.41) 118.07,82.41 119.42,81.05 119.42,71.34 119.26,71.17 119.26,66.92 114.91,62.57 114.91,57.8 114.76,57.65 114.42,57.65 114.27,57.5 114.27,57.2 114.42,57.05 114.76,57.05 114.91,56.9 114.91,56.62 114.76,56.47 114.42,56.47 114.27,56.32 114.27,56.03 114.42,55.88 114.76,55.88 114.91,55.73 114.91,55.43 114.76,55.28 114.42,55.28 114.27,55.13 114.27,54.83 114.42,54.68 114.76,54.68 114.91,54.53 114.91,54.23 114.76,54.08 114.42,54.08 114.27,53.93 114.27,53.63 114.42,53.48 114.76,53.48 114.91,53.33 114.91,53.05 114.8,52.94 114.39,52.94 114.27,52.81 114.27,52.56 114.61,52.21 114.61,51.82 114.27,51.48 114.27,47.88 v2(114.37,47.77)
  BOTTOM w0.076: v2(117.77,82.41) 118.33,82.96 118.33,84.71 118.21,84.84 118.21,85.7 118.36,85.85 118.36,86.74 CPU1.AP4
  BOTTOM w0.178: JDIMM1.133 115.02,48.42 v2(114.37,47.77)
DDR_A_MA2: length 53
  IN5 w0.145: 119.9,81.23 119.9,76.05 120.74,75.21 120.74,71.37 120.17,70.79 120.17,66.54 115.82,62.2 115.82,52.67 115.52,52.37 115.52,52.01 115.82,51.71 115.82,50.71 115.67,50.57 115.43,50.57 115.28,50.42 115.28,50.12 115.43,49.97 115.67,49.97 115.82,49.82 115.82,49.54 115.67,49.39 115.43,49.39 115.28,49.24 115.28,48.94 115.43,48.79 115.67,48.79 115.8,48.66 115.8,48.48 115.42,48.1 115.42,46.46 115.27,46.31 114.95,46.31 114.8,46.17 114.8,45.87 114.81,45.86 114.81,45 114.93,44.87 115.39,44.87 115.52,45 115.52,45.35 115.65,45.48 v2(115.95,45.48)
  IN5 w0.15: v2(119.88,86.71) 119.88,86.41 119.88,81.24 119.9,81.23
  BOTTOM w0.076: v2(119.88,86.71) 119.56,87.04 CPU1.AN4
  BOTTOM w0.178: v2(115.95,45.48) 115,44.54 115,43.35 114.77,43.13 JDIMM1.132
DDR_A_MA3: length 49.2
  IN5 w0.145: v2(114.37,46.5) 114.83,46.95 114.83,50.7 115.24,51.11 115.24,51.64 115.06,51.82 115.06,52.56 115.37,52.86 115.37,62.39 119.71,66.73 119.71,70.98 120.28,71.55 120.28,74.94 119.66,75.56 119.66,81.15 v2(117.77,83.04)
  BOTTOM w0.076: v2(117.77,83.04) 118.15,83.42 118.15,83.92 118.04,84.03 118.04,85.84 118.1,85.91 118.1,87.14 CPU1.AP5
  BOTTOM w0.178: JDIMM1.131 114.53,48.6 113.8,47.87 113.8,47.08 v2(114.37,46.5)
DDR_A_MA4: length 52.9
  IN5 w0.145: v2(117.77,81.01) 117.38,80.62 117.38,79.59 118.4,78.56 118.4,71.58 118.35,71.52 118.35,67.29 113.81,62.76 113.81,62.58 113.99,62.4 113.99,62.17 113.87,62.04 113.48,62.04 113.36,61.91 113.36,61.68 113.51,61.53 113.86,61.53 114.01,61.38 114.01,61.08 113.86,60.93 113.51,60.93 113.36,60.78 113.36,43.24 113.68,42.92 114.88,42.92 115.01,43.05 115.01,43.86 114.86,44.01 v2(114.38,44.01)
  BOTTOM w0.076: v2(117.77,81.01) 118.2,81.44 118.2,82.36 118.53,82.69 118.53,84.81 118.37,84.97 118.37,85.46 CPU1.AP2
  BOTTOM w0.178: JDIMM1.128 113.77,43.4 v2(114.38,44.01)
DDR_A_MA5: length 50.7
  IN5 w0.145: 118.84,80.38 v2(117.81,80.38) ; v2(114.38,45.23) 114.25,45.1 113.94,45.1 113.81,45.22 113.81,57.94 113.96,58.09 114.31,58.09 114.46,58.24 114.46,58.54 114.31,58.69 113.96,58.69 113.81,58.84 113.81,59.22 113.94,59.35 114.31,59.35 114.46,59.5 114.46,59.76 114.33,59.89 113.96,59.89 113.81,60.04 113.81,60.34 113.96,60.49 114.31,60.49 114.46,60.64 114.46,62.76 118.8,67.1 118.8,71.36 118.97,71.52 118.97,80.25
  IN5 w0.15: 118.97,80.25 118.84,80.38
  BOTTOM w0.076: v2(117.81,80.38) 117.86,80.38 118.45,80.97 118.45,82.15 118.74,82.43 118.74,85 CPU1.AP1
  BOTTOM w0.178: v2(114.38,45.23) 113.76,45.23 113.27,44.74 JDIMM1.126
DDR_A_MA6: length 54.4
  IN5 w0.145: v2(116.64,79.63) 117,79.63 117.95,78.68 117.95,71.74 117.89,71.68 117.89,67.48 112.9,62.49 112.9,55.03 112.75,54.88 112.37,54.88 112.22,54.73 112.22,54.43 112.37,54.28 112.75,54.28 112.9,54.13 112.9,53.86 112.75,53.71 112.61,53.71 112.46,53.56 112.46,53.26 112.61,53.11 112.75,53.11 112.9,52.96 112.9,50.75 112.75,50.6 112.61,50.6 112.46,50.45 112.46,50.15 112.61,50 112.75,50 112.9,49.85 112.9,49.55 112.75,49.4 112.61,49.4 112.46,49.25 112.46,48.95 112.61,48.8 112.75,48.8 112.9,48.65 112.9,48.35 112.75,48.2 112.64,48.2 112.49,48.05 112.49,47.75 112.64,47.6 112.75,47.6 112.9,47.45 112.9,47.15 112.75,47 112.68,47 112.53,46.85 112.53,46.55 112.68,46.4 112.75,46.4 112.9,46.25 112.9,45.97 112.77,45.84 112.5,45.84 112.05,46.29 v2(112.05,46.42)
  BOTTOM w0.076: v2(116.64,79.63) 116.88,79.39 117.92,79.39 118.76,80.23 118.76,81.95 118.97,82.16 118.97,84.76 118.93,84.79 118.93,86.11 CPU1.AP3
  BOTTOM w0.178: JDIMM1.127 113.53,48.5 113.31,48.29 113.31,47.37 112.36,46.42 v2(112.05,46.42)
DDR_A_MA7: length 54.8
  IN5 w0.145: v2(112.05,45.07) 111.95,44.97 111.68,44.97 111.55,45.1 111.55,53.25 111.07,53.73 111.07,56.89 110.92,57.04 110.31,57.04 110.16,57.19 110.16,57.49 110.31,57.64 110.92,57.64 111.07,57.79 111.07,58.09 110.95,58.21 110.31,58.21 110.16,58.36 110.16,58.66 110.31,58.81 110.92,58.81 111.07,58.96 111.07,59.26 110.94,59.39 110.31,59.39 110.16,59.54 110.16,59.84 110.33,60.01 110.92,60.01 111.07,60.16 111.07,60.46 110.92,60.61 110.33,60.61 110.18,60.76 110.18,61.06 110.33,61.21 110.92,61.21 111.07,61.36 111.07,61.95 111.55,62.43 116.98,67.86 116.98,72.01 117.04,72.07 117.04,77.59 116.91,77.72 v2(116.64,77.72)
  BOTTOM w0.076: v2(116.64,77.72) 117.16,77.72 119.39,79.95 CPU1.AN1
  BOTTOM w0.178: v2(112.05,45.07) 112.4,45.07 112.59,44.88 112.59,43.29 112.27,42.97 JDIMM1.122
DDR_A_MA8: length 55.4
  IN5 w0.145: v2(116.64,78.36) 116.82,78.53 117.37,78.53 117.49,78.4 117.49,71.9 117.44,71.85 117.44,67.67 112.01,62.24 111.86,62.09 111.86,61.93 111.99,61.8 112.31,61.8 112.41,61.7 112.41,61.45 112.28,61.32 111.67,61.32 111.53,61.19 111.53,60.99 111.66,60.86 112.3,60.86 112.45,60.71 112.45,60.41 112.3,60.26 111.68,60.26 111.53,60.11 111.53,59.81 111.68,59.66 112.3,59.66 112.45,59.51 112.45,59.21 112.3,59.06 111.68,59.06 111.53,58.91 111.53,58.63 111.68,58.48 112.3,58.48 112.45,58.33 112.45,58.04 112.3,57.89 111.68,57.89 111.53,57.74 111.53,57.44 111.68,57.29 112.3,57.29 112.45,57.14 112.45,56.84 112.3,56.69 111.68,56.69 111.53,56.54 111.53,56.24 111.68,56.09 112.3,56.09 112.45,55.94 112.45,55.64 112.3,55.49 111.66,55.49 111.53,55.36 111.53,54.9 111.76,54.66 111.76,54.39 111.53,54.16 111.53,53.92 112.01,53.44 112.01,47.84 v2(112.06,47.78)
  BOTTOM w0.076: v2(116.64,78.36) 117.35,78.36 119.17,80.18 119.17,84.79 119.11,84.85 119.11,86.11 CPU1.AN3
  BOTTOM w0.178: v2(112.06,47.78) 112.59,47.78 112.83,48.02 112.83,48.55 113.02,48.74 JDIMM1.125
DDR_A_MA9: length 49.8
  IN5 w0.145: v2(117.32,86.71) 116.25,85.64 116.25,75.52 116.07,75.35 116.07,68.24 109.19,61.35 109.19,56.88 110.16,55.91 110.16,53.35 110.64,52.88 110.64,46.34 110.51,46.21 110.26,46.21 v2(110.18,46.29)
  BOTTOM w0.076: CPU1.AT4 116.99,87.04 v2(117.32,86.71)
  BOTTOM w0.178: v2(110.18,46.29) 111.26,47.38 111.26,48.04 112.02,48.8 JDIMM1.121
DDR_A_MA10: length 52.2
  IN5 w0.089: 125.23,75.35 125.23,75.67 124.68,76.23 124.17,76.23 123.6,76.8 123.6,82.44 123.47,82.57 v2(122.79,82.57)
  IN5 w0.145: v2(119.19,43.83) 119.26,43.75 119.51,43.75 119.64,43.88 119.64,56.48 122.53,59.37 122.53,61.48 122.4,61.6 122.13,61.6 122,61.73 122,61.91 122.13,62.04 122.54,62.04 122.66,62.17 122.66,62.35 122.54,62.47 121.66,62.47 121.51,62.62 121.51,62.92 121.66,63.07 122.59,63.07 122.71,63.2 122.71,64.12 123.98,65.39 123.98,69.28 125.23,70.54 125.23,75.35
  BOTTOM w0.076: v2(122.79,82.57) 123.39,83.17 123.39,85.44 CPU1.AH2
  BOTTOM w0.178: v2(119.19,43.83) 120.28,42.74 JDIMM1.146
DDR_A_MA11: length 54.9
  IN5 w0.145: v2(116.64,76.45) 116.64,75.41 116.53,75.29 116.53,68.05 111.1,62.61 109.71,61.23 109.71,57 110.13,56.59 110.49,56.59 110.62,56.46 110.62,53.54 111.1,53.06 111.1,46.15 110.61,45.66 110.61,42.55 110.88,42.27 112.47,42.27 112.66,42.46 112.66,43.67 112.45,43.88 v2(112.07,43.88)
  BOTTOM w0.076: v2(116.64,76.45) 119.68,79.49 119.68,85.44 CPU1.AN2
  BOTTOM w0.178: v2(112.07,43.88) 111.77,43.59 JDIMM1.120
DDR_A_MA12: length 53.4
  IN5 w0.145: v2(114.94,84.07) 115.69,84.07 115.87,83.9 115.87,75.6 115.62,75.35 115.62,68.42 108.74,61.54 108.74,56.63 109.71,55.65 109.71,55.32 109.56,55.17 108.82,55.17 108.67,55.02 108.67,54.72 108.82,54.57 109.56,54.57 109.71,54.42 109.71,54.15 109.56,54 108.83,54 108.67,53.84 108.67,53.55 108.83,53.4 109.56,53.4 109.71,53.25 109.71,52.99 109.58,52.86 109.37,52.86 109.23,52.71 109.23,52.41 109.42,52.21 109.42,50.84 109.55,50.72 110.06,50.72 110.19,50.59 110.19,50.34 110.06,50.21 109.49,50.21 109.31,50.03 109.31,49.75 109.46,49.61 110.04,49.61 110.19,49.46 110.19,49.16 110.04,49.01 109.93,49.01 109.77,48.84 109.77,47.74 109.93,47.57 110.11,47.57 v2(110.18,47.64)
  BOTTOM w0.076: CPU1.AU4 115.69,86.59 115.69,84.82 v2(114.94,84.07)
  BOTTOM w0.178: v2(110.18,47.64) 111.53,48.99 JDIMM1.119
DDR_A_MA13: length 57.1
  IN5 w0.145: v2(123.94,43.06) 123.94,42.09 124.14,41.89 124.64,41.89 124.79,42.04 124.79,42.33 124.94,42.48 126.04,42.48 126.19,42.63 126.19,42.91 126.04,43.06 124.6,43.06 124.47,43.19 124.47,43.48 124.62,43.63 125.32,43.63 125.51,43.81 125.51,54.71 125.36,54.86 124.78,54.86 124.66,54.98 124.66,55.23 124.81,55.38 125.27,55.38 125.51,55.61 125.51,56.27 129.53,60.29 129.53,75.35
  IN5 w0.15: 129.53,75.35 125.72,79.16 125.72,81.24 125.59,81.36 v2(125.3,81.36)
  BOTTOM w0.076: v2(125.3,81.36) 126.47,82.53 126.47,86.11 CPU1.AE3
  BOTTOM w0.178: JDIMM1.158 123.28,42.55 123.79,43.06 v2(123.94,43.06)
DDR_A_PAR: length 55.9
  IN5 w0.089: 124.22,75.63 123.24,76.61 123.24,79.64 v2(122.77,80.11)
  IN5 w0.145: 124.22,75.63 124.22,70.95 122.97,69.7 122.97,65.81 119.16,61.99 119.16,61.78 119.37,61.57 119.37,61.36 119.15,61.15 118.94,61.15 118.73,61.36 118.52,61.36 118.32,61.16 118.32,60.7 118.47,60.55 119.24,60.55 119.39,60.4 119.39,60.1 119.24,59.95 118.47,59.95 118.32,59.8 118.32,59.5 118.47,59.35 119.24,59.35 119.39,59.2 119.39,58.9 119.24,58.76 118.47,58.76 118.32,58.61 118.32,58.31 118.47,58.16 119.24,58.16 119.39,58.01 119.39,57.71 119.24,57.56 118.47,57.56 118.32,57.41 118.32,47.91 118.47,47.76 118.61,47.76 118.76,47.61 118.76,47.31 118.61,47.16 118.47,47.16 118.32,47.01 118.32,46.53 118.45,46.4 118.71,46.4 v2(119.19,46.87)
  BOTTOM w0.076: CPU1.AG3 124.12,86.09 124.12,80.2 124.04,80.11 v2(122.77,80.11)
  BOTTOM w0.178: JDIMM1.143 117.53,48.53 v2(119.19,46.87)
DDR_A_RAS#: length 51.7
  IN5 w0.089: v2(124.86,87.24) 123.95,86.33 123.95,77.54 126.14,75.35
  IN5 w0.145: 126.14,75.35 126.14,70.16 124.89,68.91 124.89,64.98 123.62,63.71 123.62,59.17 120.55,56.1 120.55,45.07 120.68,44.94 121.08,44.94 v2(121.24,45.1)
  BOTTOM w0.076: CPU1.AH4 123.99,87.35 124.75,87.35 v2(124.86,87.24)
  BOTTOM w0.178: v2(121.24,45.1) 121.99,44.35 121.99,43.35 121.77,43.14 JDIMM1.152
DDR_A_WE#: length 55.9
  IN5 w0.089: 126.6,75.35 124.13,77.81 124.13,86.26 124.51,86.64 v2(124.86,86.64)
  IN5 w0.145: 126.6,75.35 126.6,69.97 125.34,68.72 125.34,64.79 124.08,63.52 124.08,63.19 124.23,63.04 124.92,63.04 125.04,62.91 125.04,62.65 124.89,62.51 124.29,62.51 124.08,62.29 124.08,61.99 124.23,61.84 124.85,61.84 124.98,61.71 124.98,61.45 124.79,61.26 124.22,61.26 124.08,61.12 124.08,60.79 124.23,60.64 124.85,60.64 124.98,60.51 124.98,60.31 124.83,60.16 124.34,60.16 124.08,59.89 124.08,58.98 121.58,56.49 121.58,55.91 121.43,55.76 121.15,55.76 121,55.61 121,55.31 121.15,55.16 121.58,55.16 121.73,55.01 121.73,54.73 121.58,54.58 121.15,54.58 121,54.43 121,54.13 121.15,53.98 121.58,53.98 121.73,53.83 121.73,53.53 121.58,53.38 121.15,53.38 121,53.23 121,52.93 121.15,52.78 121.58,52.78 121.73,52.63 121.73,52.34 121.58,52.19 121.15,52.19 121,52.04 121,51.74 121.15,51.59 121.58,51.59 121.73,51.44 121.73,50.69 121.58,50.54 121.15,50.54 121,50.39 121,50.09 121.15,49.94 121.58,49.94 121.73,49.79 121.73,49.52 121.58,49.37 121.15,49.37 121,49.22 121,48.92 121.15,48.77 121.6,48.77 121.73,48.64 121.73,48.46 121.41,48.14 v2(121.24,48.14)
  BOTTOM w0.076: v2(124.86,86.64) 124.54,86.64 124.42,86.76 CPU1.AG4
  BOTTOM w0.178: v2(121.24,48.14) 121.53,48.43 JDIMM1.151
DDR_B_ACT#: length 69.4
  IN1 w0.089: 113.57,75.35 113.57,75.71 115.16,77.3 115.16,79.72 116.2,80.75 116.2,89.6 v2(116.57,89.97)
  IN1 w0.145: 113.57,75.35 113.57,69.86 107.15,63.44 107.15,54.36 105.36,52.56 105.36,33.31 106.37,32.3 v2(106.99,32.3)
  BOTTOM w0.076: v2(116.57,89.97) CPU1.AT9
  BOTTOM w0.178: v2(106.99,32.3) 108.22,32.3 109.81,30.71 109.81,30.21 110.28,29.74 JDIMM2.114
DDR_B_ALERT#: length 68.1
  IN1 w0.089: 115.61,75.35 115.61,75.56 116.1,76.04 116.74,76.04 117.24,76.54 117.24,83.6 117.95,84.31 117.95,88.55 118.21,88.81 118.21,89.78 v2(118.4,89.97)
  IN1 w0.145: v2(110.05,32.2) 109,33.25 109,35.4 108.06,36.34 108.06,37.22 108.18,37.35 108.18,42.42 107.38,43.22 107.38,51.72 109.18,53.52 109.18,62.59 115.61,69.02 115.61,75.35
  BOTTOM w0.076: v2(118.4,89.97) CPU1.AR8
  BOTTOM w0.178: v2(110.05,32.2) 110.78,31.48 JDIMM2.116
DDR_B_BG0: length 66.5
  IN1 w0.089: 115.05,75.35 115.05,75.82 116.04,76.81 116.04,79.64 116.89,80.49 116.89,83.5 117.77,84.38 117.77,88.63 117.94,88.8 117.94,89.76 117.73,89.98 v2(117.5,89.98)
  IN1 w0.145: v2(108.45,34.84) 108.13,35.16 107.91,35.16 107.82,35.08 107.6,35.08 107.38,35.3 107.38,35.51 107.47,35.6 107.47,35.82 107.27,36.02 107,36.02 106.88,36.14 106.88,36.47 107,36.59 107.14,36.59 107.27,36.72 107.27,37.01 107.14,37.14 107.03,37.14 106.88,37.3 106.88,37.61 107.03,37.76 107.11,37.76 107.31,37.95 107.31,42.5 106.82,42.99 106.82,51.95 108.62,53.75 108.62,62.82 115.05,69.25 115.05,75.35
  BOTTOM w0.076: v2(117.5,89.98) 117.82,90.3 CPU1.AR9
  BOTTOM w0.178: JDIMM2.115 110.53,36.04 109.42,34.93 108.53,34.93 v2(108.45,34.84)
DDR_B_BG1: length 66.9
  IN1 w0.089: v2(117.36,88.61) 116.67,87.92 116.67,80.62 115.77,79.71 115.77,76.86 114.59,75.68 114.59,75.35
  IN1 w0.145: 114.59,75.35 114.59,69.44 108.16,63.01 108.16,53.94 106.37,52.14 106.37,42.8 106.81,42.36 106.81,38.23 106.42,37.83 106.42,35.61 v2(108.46,33.57)
  BOTTOM w0.076: CPU1.AR7 117.75,89 v2(117.36,88.61)
  BOTTOM w0.178: v2(108.46,33.57) 107.75,34.28 107.75,35.12 108.04,35.41 109.18,35.41 110.03,36.26 JDIMM2.113
DDR_B_BS0: length 70
  IN1 w0.089: 125.76,75.35 125.76,77.11 124.55,78.32 124.55,85.22 124.14,85.63 124.14,89.04 124.31,89.2 124.31,89.93 124.18,90.05 123.97,90.05 v2(123.89,89.97)
  IN1 w0.145: 125.76,75.35 125.76,65.91 119.8,59.95 119.8,49.08 119.62,48.89 119.62,44.23 119.8,44.04 119.8,43.63 119.62,43.44 119.62,43.03 119.8,42.84 119.8,42.43 119.56,42.19 119.56,41.91 119.54,41.89 119.54,41.57 119.8,41.31 119.8,41.03 119.61,40.84 119.61,37.77 119.84,37.54 119.84,31.56 120.02,31.38 120.02,29.92 120.14,29.79 121.19,29.79 121.32,29.92 v2(121.32,31.03)
  BOTTOM w0.076: v2(123.89,89.97) 123.85,89.73 123.67,89.61 CPU1.AH8
  BOTTOM w0.178: JDIMM2.150 121.28,29.93 121.49,30.14 121.49,30.85 v2(121.32,31.03)
DDR_B_BS1: length 70.3
  IN1 w0.089: 124.85,75.35 124.85,77.01 124.67,77.19 124.55,77.19 124.42,77.06 124.29,77.06 124.15,77.2 124.15,77.38 124.29,77.52 124.29,77.64 124.15,77.77 124.15,85.11 123.79,85.48 123.79,88.23 123.69,88.33 123.69,88.46 123.79,88.56 123.79,88.81 123.72,88.88 123.53,88.88 123.41,88.75 123.26,88.75 123.16,88.85 123.16,89 123.47,89.3 123.47,90.16 123.34,90.28 123.1,90.28 122.97,90.16 v2(122.97,89.94)
  IN1 w0.145: v2(118.81,35.6) 118.77,35.6 118.63,35.74 118.63,36.66 118.83,36.87 118.83,37.26 118.63,37.47 118.63,37.7 118.57,37.76 118.57,41.41 118.19,41.8 118.19,48.71 118.75,49.28 118.75,50.66 118.89,50.8 118.89,54.25 118.89,54.25 118.89,60.44 124.85,66.4 124.85,75.35
  BOTTOM w0.076: v2(122.97,89.94) 122.97,90.12 123.2,90.35 123.38,90.35 CPU1.AH9
  BOTTOM w0.178: JDIMM2.145 120.03,36.2 119.69,35.87 119.51,35.87 119.18,36.2 119.18,37.95 119.05,38.08 118.24,38.08 118.11,37.95 118.11,37.65 118.29,37.47 118.39,37.47 118.57,37.29 118.57,36.94 118.39,36.76 118.29,36.76 118.11,36.58 118.11,35.34 118.31,35.15 118.49,35.15 118.81,35.46 v2(118.81,35.6)
DDR_B_CAS#: length 71.6
  IN1 w0.089: v2(125.72,89.98) 125.33,89.6 125.33,89.18 125.65,88.86 125.65,85.56 126.52,84.69 126.52,80.26 128.24,78.54 128.24,75.35
  IN1 w0.145: 128.24,75.35 128.24,64.88 122.68,59.33 122.68,40.96 122.98,40.67 122.98,39.39 122.54,38.95 122.54,37.66 122.33,37.46 122.33,35.15 122.62,34.86 122.62,34.55 122.33,34.26 122.33,33.95 122.62,33.66 122.62,33.35 122.33,33.06 122.33,32.75 122.62,32.46 122.62,32.15 122.33,31.86 122.33,31.58 122.48,31.43 122.54,31.43 122.69,31.28 122.69,30.98 122.54,30.83 122.48,30.83 122.33,30.68 122.33,30.38 122.47,30.25 123.34,30.25 123.47,30.38 123.47,31.31 v2(123.94,31.79)
  BOTTOM w0.076: v2(125.72,89.98) CPU1.AF8
  BOTTOM w0.178: JDIMM2.156 122.78,30.72 123.85,31.79 v2(123.94,31.79)
DDR_B_D0: length 74.3
  IN1 w0.097: 100.55,91.45 98.01,88.91 98.01,77.13 91.51,70.64 91.51,60.73 91.51,60.48 83.1,52.07 83.1,50.1 82.76,49.76 82.76,48.65 82.63,48.52 82.63,43.43 82.73,43.34 83.2,43.34 83.29,43.24 83.29,43.05 83.2,42.95 82.7,42.95 82.6,42.86 82.6,42.66 82.7,42.57 83.2,42.57 83.29,42.47 83.29,42.28 83.2,42.18 82.7,42.18 82.6,42.08 82.6,41.89 82.7,41.79 83.2,41.79 83.29,41.7 83.29,41.5 83.2,41.41 82.7,41.41 82.6,41.31 82.6,40.97 82.43,40.79 82.01,40.37 82.01,38.34 82.15,38.2 82.51,38.2 82.61,38.1 82.61,37.91 82.51,37.81 82.15,37.81 82.05,37.72 82.05,37.52 82.15,37.43 82.51,37.43 82.61,37.33 82.61,37.14 82.51,37.04 82.15,37.04 82.05,36.94 82.05,36.75 82.15,36.65 82.51,36.65 82.61,36.56 82.61,36.36 82.51,36.27 82.15,36.27 82.05,36.17 82.05,35.63 v2(82.39,35.29)
  IN1 w0.099: v2(100.93,91.43) 100.92,91.45 100.55,91.45
  BOTTOM w0.076: CPU1.BT11 102.1,91.54 101.94,91.38 101,91.38 100.94,91.43 v2(100.93,91.43)
  BOTTOM w0.114: v2(82.39,35.29) 82.53,35.43 JDIMM2.3
