# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_DTX_P13: length 91.2
  IN5 w0.089: 164.35,28.24 164.36,28.25 164.36,29.42 163.72,30.06 163.72,33.3 162.88,34.14 162.88,35.42 162.69,35.62 162.5,35.62 162.4,35.51 v2(162.4,35.28)
  IN5 w0.104: v2(225.63,19.54) 225.39,19.54 225.3,19.63 223.15,19.63 222.87,19.36 222.87,16.02 220.53,13.67 218.98,13.67 213.73,8.42 203.96,8.42 203.74,8.65 193.56,8.65 188.76,13.44 185.83,13.44 185.76,13.51 176.49,13.51 174.93,15.07 169.92,15.07 167.37,17.62 167.37,18.6 166.07,19.9 166.07,24.79 164.35,26.51 164.35,28.24
  BOTTOM w0.089: v2(162.4,35.28) 162.4,35.41 162.18,35.62 UH1.E35
  BOTTOM w0.114: v2(225.63,19.54) 225.82,19.73 226.11,19.73 226.2,19.65 JSSD2.7
PCIE_PRX_DTX_P14: length 88.2
  IN1 w0.089: 167.93,28.24 167.93,28.27 167.92,28.27 167.92,28.36 167.92,28.36 167.92,28.52 166.88,29.56 166.88,32.67 165.81,33.74 163.65,33.74 162.98,34.41 162.63,34.41 v2(162.45,34.6)
  IN1 w0.104: 167.93,28.24 167.93,27.04 169.42,25.56 182.81,25.56 184.66,23.7 184.66,23.04 186.66,21.05 187.98,21.05 195.53,13.5 202.71,13.5 203.86,14.65 208.9,14.65 212.26,18.01 214.17,18.01 216.07,19.91 219.15,19.91 219.97,20.73 226.73,20.73 228,19.46 228.68,19.46 229.7,18.44 229.7,18.03 v2(229.78,17.95)
  BOTTOM w0.089: UH1.E37 162.02,34.49 162.02,34.48 162.13,34.38 162.31,34.38 162.45,34.52 v2(162.45,34.6)
  BOTTOM w0.114: v2(229.78,17.95) 229.69,17.85 229.69,17.04 229.3,16.65 JSSD2.19
PCIE_PRX_DTX_P15: length 83
  IN1 w0.089: 167.23,28.24 167.23,28.26 167.22,28.27 167.22,28.32 167.22,28.32 167.22,28.65 163.9,31.98 163.9,32.43 163.9,33 163.14,33.76 162.73,33.76 162.41,33.44 v2(162.23,33.44)
  IN1 w0.104: v2(223.42,18.04) 223.47,18.04 223.68,17.83 223.68,17.7 223.59,17.61 222.93,17.61 222.24,18.3 216.61,18.3 215.67,17.36 213.47,17.36 210.16,14.05 204.12,14.05 202.97,12.9 195.28,12.9 187.74,20.44 186.37,20.44 184.06,22.75 184.06,23.38 182.49,24.95 171.46,24.95 170.97,24.46 169.65,24.46 167.23,26.88 167.23,28.24
  BOTTOM w0.089: v2(162.23,33.44) 162.23,33.38 161.85,33 UH1.E41
  BOTTOM w0.114: v2(223.42,18.04) 223.42,16.76 224.97,15.22 224.97,14.24 225.45,13.76 225.96,13.76 226.06,13.65 JSSD2.31
PCIE_PRX_DTX_P16: length 92.9
  IN1 w0.089: v2(162.22,32.45) 162.78,31.89 162.78,31.76 164.19,30.34 164.83,30.34 166.12,29.05 166.12,28.27 166.13,28.27 166.13,28.24
  IN1 w0.104: v2(230.37,17.93) 230.56,17.93 230.88,17.62 230.88,17.44 230.44,17.01 228.52,17.01 228.3,17.23 224.7,17.23 224.48,17.01 222.49,17.01 221.82,17.68 216.9,17.68 215.97,16.76 213.86,16.76 210.54,13.44 204.37,13.44 203.22,12.3 195.03,12.3 187.49,19.84 186.12,19.84 183.75,22.21 181.76,22.21 179.62,24.35 175.94,24.35 175.39,23.79 169.47,23.79 166.13,27.13 166.13,28.24
  BOTTOM w0.089: v2(162.22,32.45) 162.04,32.45 161.83,32.24 UH1.E42
  BOTTOM w0.114: v2(230.37,17.93) 230.56,17.93 230.85,17.64 230.85,13.33 229.28,11.75 228.4,10.87 228.05,10.87 227.78,11.15 JSSD2.41
PCIE_PTX_DRX_N5: length 147.6
  IN4 w0.097: v2(162.25,41.69) 162.2,41.69 161.86,42.02 161.86,42.49 162.22,42.85 162.8,42.85 163.96,44.01 163.96,47.02 162.96,48.02 161.14,48.02 159.97,49.19 159.97,50.59 159.21,51.35 159.21,52.66 159.23,52.69 159.23,52.86 159.2,52.9 159.2,52.93 159.19,52.94
  IN4 w0.147: v2(192.91,145.62) 192.91,145.7 192.6,146.01 190.08,146.01 189.04,144.97 178.62,144.97 178.05,144.4 177.02,144.4 171.21,138.6 171.21,102.58 172.22,101.57 172.22,91.73 169.26,88.78 166.43,88.78 164.18,86.52 164.18,82.57 161.09,79.48 157.58,79.48 155.36,77.26 155.36,54.84 156.82,53.38 158.8,53.38 159.12,53.06 159.12,53.01 159.19,52.94
  BOTTOM w0.089: v2(162.25,41.69) 161.74,42.2 UH1.D22
  BOTTOM w0.114: CL4.2 195.27,149.51 195.01,149.51 194.58,149.08 194.58,148.61 193.28,147.31 192.71,147.31 192.16,146.77 192.16,146.04 192.45,145.76 192.77,145.76 v2(192.91,145.62)
PCIE_PTX_DRX_N5_C: length 2.2
  BOTTOM w0.114: CL4.1 196.74,149.43 197.61,149.43 197.74,149.57 UL1.36
PCIE_PTX_DRX_N6: length 185.7
  TOP w0.114: v2(295.08,56.98) 295.26,56.8 295.48,56.8 CN24.2
  IN4 w0.147: v2(159.94,42.29) 159.92,42.26 159.92,41.76 159.9,41.75 159.9,41.4 159.62,41.12 159.21,41.12 157.94,39.85 157.94,36.3 157.98,36.26 157.98,34.02 157.65,33.7 157.65,33.04 157.99,32.71 157.99,28.89 158.33,28.55 158.33,24.6 163.99,18.93 163.99,15.57 166.84,12.72 175.63,12.72 176.45,11.9 180.56,11.9 181.15,12.49 183.53,12.49 183.93,12.09 184.6,12.09 185,12.49 192.51,12.49 194.18,10.82 213.05,10.82 215.67,13.43 215.67,14.14 218.23,16.7 219.58,16.7 220.46,17.59 227.88,17.59 228.92,18.63 230.51,18.63 231.55,19.67 234.08,19.67 251.71,37.3 265.43,37.3 265.96,37.83 270.47,37.83 271.19,38.55 273.28,38.55 277.31,42.58 279.56,42.58 293.64,56.67 294.78,56.67 295.08,56.96 v2(295.08,56.98)
  BOTTOM w0.114: UH1.B22 160.45,42 160.23,42 v2(159.94,42.29)
PCIE_PTX_DRX_N6_C: length 6.1
  TOP w0.114: v2(297.49,56.98) 297.31,56.8 297.05,56.8 CN24.1
  BOTTOM w0.114: v2(297.49,56.98) 297.66,56.81 298.1,56.81 300.15,58.86 300.83,58.86 300.97,59 JWLAN.29
PCIE_PTX_DRX_N9: length 2.4
  TOP w0.114: CH210.1 223.13,33.43 222.85,33.43 v2(222.66,33.62)
  BOTTOM w0.114: v2(222.66,33.62) 222.83,33.44 223.06,33.44 223.16,33.55 JSSD1.47
PCIE_PTX_DRX_N9_C: length 105.2
  TOP w0.114: v2(225.08,33.6) 224.89,33.42 224.38,33.42 CH210.2
  IN5 w0.089: 169.25,28.24 169.25,28.27 169.24,28.27 169.24,28.72 168.01,29.96 168.01,37.9 165.9,40.01 161.52,40.01 159.37,37.86 159.1,37.86 v2(158.95,38.01)
  IN5 w0.104: v2(225.08,33.6) 224.94,33.46 224.45,33.46 223.47,32.48 223.47,31.41 218.07,26.01 218.07,20.83 216.5,19.25 216.5,18.59 209.98,12.07 204.41,12.07 204.18,11.85 194.99,11.85 188.76,18.08 184.91,18.08 183.69,16.85 181.37,16.85 179.91,18.31 178,18.31 176.25,20.06 172.77,20.06 171.88,20.96 169.92,20.96 169.42,21.45 169.42,27.88 169.25,28.06 169.25,28.24
  BOTTOM w0.089: v2(158.95,38.01) 158.98,37.98 159.65,37.98 159.81,37.82 160.08,37.82 160.22,37.95 160.71,37.95 161.02,37.64 UH1.C31
PCIE_PTX_DRX_N10: length 2.5
  TOP w0.114: CH212.1 223.18,36.42 222.83,36.42 v2(222.64,36.62)
  BOTTOM w0.114: v2(222.64,36.62) 222.82,36.44 223,36.44 223.12,36.55 JSSD1.35
PCIE_PTX_DRX_N10_C: length 113.1
  TOP w0.114: v2(225.27,36.52) 225.13,36.38 224.44,36.38 CH212.2
  IN5 w0.089: 167.62,28.24 167.62,28.27 167.63,28.27 167.63,28.57 166.91,29.28 166.91,38.23 166.5,38.65 161.19,38.65 160.18,37.64 160.18,37.03 159.69,36.54 158.89,36.54 v2(158.8,36.43)
  IN5 w0.104: 167.62,28.24 167.62,26.65 168.48,25.79 168.48,20.97 169.39,20.05 171.5,20.05 172.32,19.22 173.57,19.22 173.91,18.88 176.31,18.88 178.07,17.12 179.67,17.12 180.74,16.05 184.03,16.05 185.27,17.29 188.43,17.29 194.66,11.05 204.51,11.05 204.74,11.28 213.12,11.28 214.77,12.94 214.77,15.44 219.79,20.46 219.79,26.6 220.14,26.95 220.42,26.95 225.68,32.21 225.68,34.59 226.33,35.24 226.33,36.08 225.89,36.52 v2(225.27,36.52)
  BOTTOM w0.089: UH1.C32 161.07,37.05 160.84,36.81 160.47,36.81 160.23,36.57 158.94,36.57 v2(158.8,36.43)
PCIE_PTX_DRX_N11: length 2.9
  TOP w0.114: CH203.2 223.45,39.39 222.82,39.39 v2(222.63,39.59)
  BOTTOM w0.114: JSSD1.23 223.13,39.55 222.99,39.41 222.81,39.41 v2(222.63,39.59)
PCIE_PTX_DRX_N11_C: length 125.5
  TOP w0.114: v2(227.16,39.87) 227.2,39.9 227.42,39.9 227.55,39.78 227.55,39.54 227.4,39.39 225.69,39.39 225.58,39.28 224.52,39.28 224.4,39.41 CH203.1
  IN5 w0.089: v2(159.62,35.97) 159.53,35.97 159.32,35.76 159.32,35.54 159.41,35.45 159.91,35.45 160.75,34.61 160.75,30.74 162.53,28.96 162.53,28.27 162.53,28.27 162.53,28.24
  IN5 w0.104: v2(227.16,39.87) 227.3,40 227.47,40 227.57,39.9 227.57,39.78 227.76,39.59 227.76,37.92 229.49,36.19 229.49,31.33 226.33,28.16 226.33,24.33 226.78,23.87 226.78,14.65 224.54,12.41 219.15,12.41 214.15,7.41 203.43,7.41 203.21,7.63 193.14,7.63 188.34,12.43 184.93,12.43 184.61,12.11 183.94,12.11 183.75,12.3 181.63,12.3 180.9,11.57 176.31,11.57 173.9,13.98 169.34,13.98 166.24,17.08 165.41,17.08 165.06,17.43 165.06,24.37 162.53,26.9 162.53,28.24
  BOTTOM w0.089: UH1.C33 161.02,36.57 160.89,36.57 160.81,36.49 160.81,36.43 160.59,36.21 159.59,36.21 159.55,36.18 159.55,36.03 v2(159.62,35.97)
PCIE_PTX_DRX_N12: length 3
  TOP w0.114: v2(222.56,42.59) 222.78,42.37 223.46,42.37 CH209.2
  BOTTOM w0.114: v2(222.56,42.59) 222.73,42.42 222.98,42.42 223.11,42.55 JSSD1.11
PCIE_PTX_DRX_N12_C: length 128.8
  TOP w0.114: CH209.1 224.74,42.4 226.53,42.4 v2(226.72,42.59)
  IN5 w0.089: 161.74,28.24 161.74,28.27 161.75,28.27 161.75,28.99 160.22,30.52 160.22,33.99 159.75,34.46 159.64,34.46 159.04,35.06 158.85,35.06 158.66,34.87 v2(158.66,34.66)
  IN5 w0.104: 161.74,28.24 161.74,26.57 163.14,25.16 163.14,18.49 163.65,17.98 163.65,16.97 167.44,13.19 173.57,13.19 175.98,10.78 183.11,10.78 187.12,6.76 200.89,6.76 201.04,6.62 214.48,6.62 219.38,11.52 224.78,11.52 227.59,14.33 227.59,24.31 227.12,24.78 227.12,27.82 230.29,30.98 230.29,39.59 227.29,42.59 v2(226.72,42.59)
  BOTTOM w0.089: UH1.B35 160.53,35.8 160.53,35.67 160.3,35.44 159.87,35.44 159.35,34.92 158.93,34.92 v2(158.66,34.66)
PCIE_PTX_DRX_N13: length 4.7
  TOP w0.114: CH206.2 226.53,19.01 225.69,19.01 225.38,18.69 225.38,18.18 v2(225.2,18)
  BOTTOM w0.114: v2(225.2,18) 225.37,18.18 225.37,18.39 225.64,18.65 JSSD2.11
PCIE_PTX_DRX_N13_C: length 103.3
  TOP w0.114: CH206.1 227.83,19.01 228.18,19.01 228.34,19.16 228.34,20.01 v2(228.17,20.18)
  IN5 w0.104: v2(228.17,20.18) 228.4,19.95 228.4,19.13 228.02,18.74 228.02,14.18 224.75,10.91 219.43,10.91 214.73,6.21 200.87,6.21 200.72,6.35 186.95,6.35 182.94,10.37 175.82,10.37 173.4,12.78 167.15,12.78 162.39,17.54 162.39,23.54 158.3,27.62 158.3,33.24 158.6,33.53 v2(158.64,33.53)
  BOTTOM w0.076: 160.32,35.03 160.64,35.03 160.97,35.35 UH1.C36
  BOTTOM w0.089: 158.65,33.76 158.65,33.82 158.83,34 158.83,34.05 159.1,34.33 159.26,34.33 160.01,35.08 160.26,35.08 160.3,35.05 160.3,35.05 160.32,35.03
  BOTTOM w0.114: 158.65,33.76 158.64,33.75 v2(158.64,33.53)
PCIE_PTX_DRX_N14: length 2.6
  TOP w0.114: v2(225.78,15.68) 225.95,15.52 226.53,15.52 CH204.2
  BOTTOM w0.114: v2(225.78,15.68) 225.93,15.54 226.14,15.54 226.26,15.65 JSSD2.23
PCIE_PTX_DRX_N14_C: length 88.1
  TOP w0.114: CH204.1 227.47,15.54 227.6,15.42 229.2,15.42 229.42,15.64 229.42,15.93 v2(229.2,16.15)
  IN1 w0.089: v2(161.2,33.57) 161.2,33.56 161.38,33.56 161.51,33.69 161.51,33.87 161.38,34 161.06,34 160.73,33.67 160.73,32.62 163.5,29.86 164.62,29.86 165.53,28.95 165.53,28.24
  IN1 w0.104: v2(229.2,16.15) 229.39,15.95 229.39,15.83 229.2,15.63 228.16,15.63 227.16,16.63 224.96,16.63 224.74,16.41 216.49,16.41 216.23,16.16 214.11,16.16 210.79,12.84 204.62,12.84 203.47,11.69 194.78,11.69 187.24,19.24 185.87,19.24 183.5,21.6 176.93,21.6 175.34,23.19 169.64,23.19 169.56,23.19 169.22,23.19 165.53,26.88 165.53,28.24
  BOTTOM w0.114: v2(161.2,33.57) 161.2,33.65 UH1.B38
PCIE_PTX_DRX_N15: length 6.5
  BOTTOM w0.114: JSSD2.35 226.11,12.65 225.97,12.51 224.97,12.51 224.09,13.38 224.09,13.41 223.71,13.79 223.69,13.79 v4(222.69,14.79) 222.38,15.1 221.78,15.1 CH214.1
PCIE_PTX_DRX_N15_C: length 77.9
  IN1 w0.089: v2(159.27,33.62) 159.77,33.62 160.05,33.34 160.05,32.41 161.13,31.33 161.13,29.99 162.87,28.24
  IN1 w0.104: 162.87,28.24 163.19,27.92 163.36,27.92 168.95,22.33 173.15,22.33 174.68,20.8 183.18,20.8 185.54,18.44 186.91,18.44 194.48,10.87 203.78,10.87 204.84,11.94 213.81,11.94 215.67,13.8 215.67,14.34 216.93,15.59 219.51,15.59 220.05,15.06 220.05,14.65 v2(219.84,14.44)
  BOTTOM w0.089: v2(159.27,33.62) 159.33,33.56 160.46,33.56 UH1.B39
  BOTTOM w0.114: CH214.2 220.85,15.11 220.27,15.11 220.02,14.85 220.02,14.62 v2(219.84,14.44)
PCIE_PTX_DRX_N16: length 7.8
  BOTTOM w0.114: CH216.1 221.8,13.91 222.05,13.91 223.03,12.94 223.03,12.51 223.56,11.97 v4(223.76,11.77) 224.49,11.04 224.52,11.04 224.98,10.58 224.98,10.22 225.76,9.45 225.92,9.45 226.12,9.65 JSSD2.47
PCIE_PTX_DRX_N16_C: length 77.1
  IN1 w0.089: 162.29,28.24 162.14,28.39 162.13,28.39 162.09,28.43 162.08,28.43 160.67,29.84 160.67,30.44 159.24,31.87 159.24,32.2 159.45,32.41 v2(159.53,32.41)
  IN1 w0.104: 162.29,28.24 169.03,21.51 173.4,21.51 175.15,19.75 179.62,19.75 182.06,17.31 185.46,17.31 187.5,15.26 189.51,15.26 194.31,10.47 203.94,10.47 204.97,11.49 214.07,11.49 216.36,13.78 216.36,14.3 217.21,15.15 218.15,15.15 218.39,14.91 218.39,14.63 218.58,14.44 v2(218.67,14.44)
  BOTTOM w0.089: UH1.A41 160.14,32.92 160.08,32.97 160.03,32.97 160.01,32.99 159.47,32.99 159.29,32.81 159.29,32.54 159.42,32.41 v2(159.53,32.41)
  BOTTOM w0.114: v2(218.67,14.44) 218.48,14.44 218.35,14.31 218.35,14.16 218.63,13.88 220.8,13.88 CH216.2
PCIE_PTX_DRX_P5: length 147.6
  IN4 w0.097: 159.02,52.77 159.02,51.27 159.78,50.51 159.78,49.12 161.07,47.83 162.88,47.83 163.77,46.94 163.77,44.09 162.72,43.04 162.15,43.04 161.68,42.57 v2(161.68,41.69)
  IN4 w0.147: v2(192.91,146.28) 189.96,146.28 188.93,145.25 178.51,145.25 177.94,144.68 176.9,144.68 170.94,138.71 170.94,102.46 171.94,101.45 171.94,91.85 169.15,89.05 166.32,89.05 163.91,86.64 163.91,82.69 160.97,79.75 157.47,79.75 155.09,77.37 155.09,54.73 156.7,53.11 158.69,53.11 159.02,52.77
  BOTTOM w0.089: UH1.C22 161.13,42.17 161.42,41.88 161.55,41.88 161.68,41.75 v2(161.68,41.69)
  BOTTOM w0.114: CL3.2 195.69,149.04 195.69,149.16 195.56,149.28 195.1,149.28 194.8,148.98 194.8,148.52 193.37,147.09 192.8,147.09 192.38,146.67 192.38,146.14 192.54,145.98 192.76,145.98 192.91,146.13 v2(192.91,146.28)
PCIE_PTX_DRX_P5_C: length 2.1
  BOTTOM w0.114: UL1.35 196.73,149.17 CL3.1
PCIE_PTX_DRX_P6: length 185.7
  TOP w0.114: v2(295.08,56.39) 295.26,56.58 295.47,56.58 CN23.2
  IN4 w0.147: v2(159.52,41.92) 159.67,41.78 159.67,41.5 159.52,41.35 159.11,41.35 157.7,39.94 157.7,34.14 157.38,33.81 157.38,32.93 157.71,32.6 157.71,28.77 158.05,28.43 158.05,24.48 163.72,18.82 163.72,15.45 166.73,12.44 175.52,12.44 176.33,11.63 180.67,11.63 181.26,12.22 183.41,12.22 183.82,11.81 184.71,11.81 185.12,12.22 192.4,12.22 194.07,10.54 213.17,10.54 215.94,13.31 215.94,14.02 218.34,16.43 219.69,16.43 220.57,17.31 227.99,17.31 229.04,18.35 230.63,18.35 231.66,19.39 234.19,19.39 251.83,37.03 265.54,37.03 266.07,37.56 270.58,37.56 271.3,38.28 273.4,38.28 277.43,42.31 279.67,42.31 293.76,56.39 v2(295.08,56.39)
  BOTTOM w0.114: UH1.A23 160.14,41.79 160.01,41.91 159.53,41.91 v2(159.52,41.92)
PCIE_PTX_DRX_P6_C: length 6.2
  TOP w0.114: CN23.1 297.06,56.58 297.31,56.58 v2(297.49,56.39)
  BOTTOM w0.114: v2(297.49,56.39) 297.68,56.58 298.19,56.58 300.25,58.64 300.89,58.64 301.03,58.5 JWLAN.27
PCIE_PTX_DRX_P9: length 2.4
  TOP w0.114: v2(222.66,33.03) 222.83,33.2 223.07,33.2 CH211.1
  BOTTOM w0.114: JSSD1.49 223.16,33.05 222.99,33.22 222.85,33.22 v2(222.66,33.03)
PCIE_PTX_DRX_P9_C: length 105.3
  TOP w0.114: v2(225.08,33.02) 224.92,33.18 224.41,33.18 CH211.2
  IN5 w0.089: 169.06,28.24 169.06,28.27 169.06,28.27 169.06,28.65 167.83,29.89 167.83,37.82 165.82,39.83 161.59,39.83 159.44,37.68 159.21,37.68 159.09,37.55 v2(159.09,37.46)
  IN5 w0.104: 169.06,28.24 169.06,27.98 169.23,27.8 169.23,21.37 169.84,20.76 171.8,20.76 172.69,19.87 176.17,19.87 177.92,18.12 179.83,18.12 181.29,16.66 183.77,16.66 184.99,17.89 188.68,17.89 194.91,11.66 204.26,11.66 204.49,11.88 210.06,11.88 216.69,18.51 216.69,19.17 218.27,20.75 218.27,25.93 223.66,31.33 223.66,32.4 224.53,33.27 224.9,33.27 225.08,33.09 v2(225.08,33.02)
  BOTTOM w0.089: UH1.B31 160.63,37.53 160.72,37.62 160.72,37.69 160.64,37.78 160.3,37.78 160.16,37.64 159.74,37.64 159.58,37.8 159.26,37.8 159.09,37.63 v2(159.09,37.46)
PCIE_PTX_DRX_P10: length 2.5
  TOP w0.114: CH213.1 223.1,36.2 222.8,36.2 v2(222.64,36.03)
  BOTTOM w0.114: JSSD1.37 223.21,36.05 223.06,36.19 222.8,36.19 v2(222.64,36.03)
PCIE_PTX_DRX_P10_C: length 113.1
  TOP w0.114: v2(225.27,35.85) 225.27,35.97 225.08,36.16 224.44,36.16 CH213.2
  IN5 w0.089: 167.81,28.24 167.81,28.27 167.81,28.27 167.81,28.64 167.09,29.35 167.09,38.31 166.57,38.82 161.11,38.82 160,37.71 160,37.1 159.61,36.71 159.02,36.71 158.77,36.95 158.77,36.99 v2(158.74,37.01)
  IN5 w0.104: 167.81,28.24 167.81,26.73 168.67,25.87 168.67,21.05 169.47,20.24 171.58,20.24 172.4,19.42 173.65,19.42 173.99,19.07 176.39,19.07 178.15,17.31 179.75,17.31 180.82,16.24 183.95,16.24 185.19,17.48 188.51,17.48 194.74,11.25 204.43,11.25 204.66,11.47 213.04,11.47 214.58,13.02 214.58,15.52 219.59,20.54 219.59,26.68 220.06,27.14 220.34,27.14 225.49,32.29 225.49,34.67 226.14,35.32 226.14,36 225.81,36.33 225.62,36.33 225.44,36.16 225.38,36.16 225.27,36.05 v2(225.27,35.85)
  BOTTOM w0.089: UH1.B32 160.77,37.1 160.77,37.24 160.71,37.29 160.53,37.29 160.4,37.17 160.4,36.99 160.16,36.75 158.97,36.75 158.74,36.98 v2(158.74,37.01)
PCIE_PTX_DRX_P11: length 2.8
  TOP w0.114: v2(222.63,39.01) 222.79,39.17 223.45,39.17 CH202.2
  BOTTOM w0.114: v2(222.63,39.01) 222.8,39.18 223.03,39.18 223.17,39.05 JSSD1.25
PCIE_PTX_DRX_P11_C: length 125.4
  TOP w0.114: v2(227.95,39.94) 227.77,39.75 227.77,39.45 227.49,39.17 225.79,39.17 225.67,39.06 224.64,39.06 CH202.1
  IN5 w0.089: 162.34,28.24 162.34,28.27 162.35,28.27 162.35,28.89 160.57,30.66 160.57,34.53 159.84,35.27 159.34,35.27 159.14,35.46 159.14,35.68 158.93,35.88 v2(158.82,35.88)
  IN5 w0.104: v2(227.95,39.94) 227.95,38 229.69,36.27 229.69,31.25 226.52,28.08 226.52,24.41 226.98,23.95 226.98,14.57 224.62,12.21 219.23,12.21 214.23,7.22 203.35,7.22 203.13,7.44 193.06,7.44 188.26,12.24 185.01,12.24 184.69,11.91 183.86,11.91 183.67,12.11 181.71,12.11 180.98,11.38 176.23,11.38 173.82,13.79 169.26,13.79 166.16,16.89 165.33,16.89 164.87,17.35 164.87,24.29 162.34,26.82 162.34,28.24
  BOTTOM w0.089: v2(158.82,35.88) 158.87,35.88 159.38,36.39 160.41,36.39 UH1.B33
PCIE_PTX_DRX_P12: length 3
  TOP w0.114: v2(222.56,42.01) 222.71,42.15 223.47,42.15 CH208.2
  BOTTOM w0.114: v2(222.56,42.01) 222.75,42.2 222.95,42.2 223.1,42.05 JSSD1.13
PCIE_PTX_DRX_P12_C: length 128.8
  TOP w0.114: v2(226.85,41.77) 226.95,41.87 226.95,42.05 226.83,42.18 224.79,42.18 CH208.1
  IN5 w0.089: 161.93,28.24 161.93,28.27 161.93,28.27 161.93,29.06 160.4,30.59 160.4,34.06 159.82,34.64 159.72,34.64 159.12,35.24 158.78,35.24 v2(158.65,35.36)
  IN5 w0.104: 161.93,28.24 161.93,26.65 163.34,25.24 163.34,18.57 163.84,18.06 163.84,17.05 167.52,13.38 173.65,13.38 176.06,10.97 183.19,10.97 187.2,6.95 200.97,6.95 201.12,6.81 214.4,6.81 219.3,11.71 224.7,11.71 227.39,14.41 227.39,24.23 226.93,24.7 226.93,27.9 230.09,31.06 230.09,39.51 227.26,42.35 227.02,42.35 226.73,42.06 226.73,41.88 v2(226.85,41.77)
  BOTTOM w0.089: UH1.A35 160.18,35.97 160.29,35.97 160.35,35.9 160.35,35.74 160.22,35.62 159.79,35.62 159.28,35.1 158.92,35.1 v2(158.65,35.36)
PCIE_PTX_DRX_P13: length 4.1
  TOP w0.114: v2(225.78,18) 225.6,18.18 225.6,18.6 225.79,18.79 226.53,18.79 CH207.2
  BOTTOM w0.114: JSSD2.13 226.31,18.15 226.04,18.43 225.73,18.43 225.6,18.29 225.6,18.18 225.77,18 v2(225.78,18)
PCIE_PTX_DRX_P13_C: length 104
  TOP w0.114: v2(228.83,20.18) 228.56,19.91 228.56,19.07 228.28,18.79 227.83,18.79 CH207.1
  IN5 w0.104: v2(158.06,33.53) 158.11,33.48 158.11,27.54 162.19,23.46 162.19,17.46 167.07,12.59 173.32,12.59 175.74,10.17 182.86,10.17 186.87,6.16 200.64,6.16 200.79,6.02 214.81,6.02 219.51,10.72 224.83,10.72 228.21,14.1 228.21,18.66 228.6,19.05 228.6,19.95 v2(228.83,20.18)
  BOTTOM w0.089: 158.65,34.12 159.03,34.5 159.18,34.5 159.94,35.26 160.33,35.26 160.37,35.22 160.49,35.22 UH1.B36
  BOTTOM w0.114: 158.65,34.12 v2(158.06,33.53)
PCIE_PTX_DRX_P14: length 2.6
  TOP w0.114: CH205.2 226.53,15.29 225.98,15.29 v2(225.78,15.1)
  BOTTOM w0.114: JSSD2.25 226.27,15.15 226.14,15.28 225.96,15.28 v2(225.78,15.1)
PCIE_PTX_DRX_P14_C: length 88.1
  TOP w0.114: CH205.1 227.73,15.19 229.29,15.19 229.64,15.54 229.64,16.01 v2(229.78,16.15)
  IN1 w0.089: 165.33,28.24 165.33,28.89 164.55,29.68 163.42,29.68 160.56,32.55 160.56,33.75 160.99,34.18 161.39,34.18 161.51,34.3 v2(161.51,34.37)
  IN1 w0.104: 165.33,28.24 165.33,26.8 169.14,23 169.64,23 175.26,23 176.85,21.41 183.42,21.41 185.79,19.05 187.16,19.05 194.7,11.5 203.55,11.5 204.7,12.65 210.87,12.65 214.19,15.96 216.31,15.96 216.57,16.22 224.82,16.22 225.04,16.43 227.08,16.43 228.08,15.44 229.28,15.44 229.59,15.75 229.59,15.95 v2(229.78,16.15)
  BOTTOM w0.114: UH1.C38 161.44,34.3 v2(161.51,34.37)
PCIE_PTX_DRX_P15: length 6.5
  BOTTOM w0.114: CH215.1 221.78,14.87 222.25,14.87 222.7,14.43 222.73,14.43 v4(223.73,13.43) 224.87,12.28 225.93,12.28 226.06,12.15 JSSD2.37
PCIE_PTX_DRX_P15_C: length 77.8
  IN1 w0.089: v2(159.65,34.04) 159.65,33.98 160.22,33.41 160.22,32.48 161.3,31.4 161.3,30.06 162.93,28.43 162.95,28.43 162.98,28.39 162.99,28.39 163.14,28.24
  IN1 w0.104: 163.14,28.24 163.27,28.12 163.44,28.12 169.03,22.53 173.23,22.53 174.76,20.99 183.26,20.99 185.62,18.64 186.99,18.64 194.56,11.07 203.7,11.07 204.76,12.13 213.73,12.13 215.48,13.88 215.48,14.42 216.85,15.79 219.59,15.79 220.25,15.14 220.25,14.62 v2(220.42,14.44)
  BOTTOM w0.089: v2(159.65,34.04) 159.65,34.29 159.81,34.44 160.05,34.44 160.43,34.06 160.43,33.89 160.34,33.8 UH1.A39
  BOTTOM w0.114: v2(220.42,14.44) 220.24,14.62 220.24,14.76 220.34,14.85 220.37,14.88 220.83,14.88 CH215.2
PCIE_PTX_DRX_P16: length 7.7
  BOTTOM w0.114: JSSD2.49 226.16,9.15 226.08,9.23 225.66,9.23 224.76,10.13 224.76,10.46 v4(224.54,10.68) 223.81,11.41 223.78,11.41 223.4,11.79 223.4,11.82 222.8,12.41 222.8,12.84 221.96,13.69 221.78,13.69 CH217.1
PCIE_PTX_DRX_P16_C: length 77.1
  IN1 w0.089: v2(158.94,32.41) 159.06,32.29 159.06,31.8 160.49,30.37 160.49,29.77 162.02,28.24
  IN1 w0.104: v2(217.97,14.44) 218.2,14.67 218.2,14.83 218.07,14.96 217.29,14.96 216.55,14.22 216.55,13.7 214.15,11.3 205.05,11.3 204.02,10.27 194.23,10.27 189.43,15.07 187.42,15.07 185.38,17.12 181.98,17.12 179.54,19.55 175.07,19.55 173.32,21.31 168.95,21.31 162.02,28.24
  BOTTOM w0.089: v2(158.94,32.41) 159.11,32.58 159.11,32.88 159.4,33.17 160.07,33.17 UH1.A40
  BOTTOM w0.114: CH217.2 220.87,13.66 218.54,13.66 218.13,14.07 218.13,14.28 v2(217.97,14.44)
PCIE_RBIAS: length 12.7
  TOP w0.089: v2(151.46,154.54) UT1.N16
  TOP w0.114: v1(156.95,148.2) RT3.1 v2(156.1,147.53)
  IN3 w0.124: v2(156.1,147.53) 155.65,147.98 153.81,147.98 152.73,149.06 152.73,149.88 153.37,150.52 153.37,152.23 152.92,152.68 152.54,152.68 152.16,153.06 152.16,153.83 v2(151.46,154.54)
PCIE_WAKE#: length 256.9
  TOP w0.089: RH4.1 182.94,46.51 v2(182.94,45.96)
  TOP w0.114: UE5.64 100.17,19.74 99.83,19.4 99.27,19.4 98.97,19.1 98.97,17.52 98.38,16.92 v2(98.38,14.69)
  IN1 w0.097: v2(195.54,155.96) 194.29,154.71 194.29,152.65 190.45,148.8 180.8,148.8 172.58,140.58 172.58,130.54 173.28,129.84 173.28,112.78 172.38,111.88 172.38,93.26 167.79,88.67 167.79,78.96 169.03,77.72 169.03,74.41 169.88,73.56 169.88,68.44 174.7,63.62 175.21,63.62 181.88,56.95 181.88,54.63 182.23,54.28 182.23,53.19 183.53,51.9 183.53,50.57 184.18,49.92 184.18,48.11 182.94,46.87 v2(182.94,45.96)
  IN2 w0.097: v2(98.38,14.69) 98.65,14.42 102.63,14.42 102.96,14.76 106.4,14.76 107.08,15.43 113.03,15.43 115.7,18.1 116.43,18.1 117.64,19.31 122.46,19.31 123.44,20.29 138.45,20.29 138.78,20.62 142.66,20.62 144.22,22.19 147.84,22.19 149.88,24.22 150.91,24.22 152.47,25.78 153.34,25.78 156.18,28.62 166.82,28.62 167.2,29 169.28,29 169.5,28.78 170.12,28.78 170.48,29.15 171.44,29.15 171.76,29.47 171.76,30.98 172.54,31.76 172.54,37.93 172.84,38.23 173.96,38.23 174.76,39.03 175.94,39.03 176.68,39.78 178.56,39.78 179.01,40.23 179.01,40.93 178.9,41.04 178.9,43.09 179.48,43.67 179.48,44.26 181.64,46.42 182.51,46.42 182.94,45.99 v2(182.94,45.96)
  BOTTOM w0.114: UL1.3 199.92,151.88 199.92,152.29 199.43,152.78 199.43,153.29 RL1.2 198.53,154.19 198.53,155.21 198.01,155.73 197.5,155.73 197.27,155.96 v2(195.54,155.96)
PCIECOMP: length 7.9
  BOTTOM w0.229: UH1.C17 160.79,44.67 159.9,44.67 159.59,44.99
  BOTTOM w0.381: RH193.1 157.5,41.67 v1(156.86,42.32) 156.86,44.03 157.93,45.1 159.47,45.1 159.59,44.99
PCIECOMP#: length 4.3
  BOTTOM w0.203: UH1.B18 159.71,44.35 159.57,44.49 159.16,44.49 159.14,44.51
  BOTTOM w0.381: 159.14,44.51 158.97,44.34 158.25,44.34 v1(157.93,44.02) RH193.2
PCIRST#: length 590
  TOP w0.089: v2(179.34,33.39) 179.35,33.39 179.35,33.38 179.68,33.38 RH199.1 179.5,34.8 UH3.4
  TOP w0.114: RT1.1 161.49,162.14 162.45,163.09 162.45,164.17 164.73,166.46 v2(164.73,166.9) ; v2(93.8,9.49) 93.49,9.17 93.49,5.73 UE5.13 93.47,4.15 CE34.1 ; v2(73.48,63.99) 73.38,64.1 66.88,64.1 v1(65.9,65.07) 65.29,65.68 65.29,67.26 65.22,67.34 RC355.2
  IN1 w0.089: 183.55,52.37 183.55,52.37 183.91,52 183.91,50.82 184.56,50.18 ; 182.79,54.84 182.62,54.66 182.62,53.3 182.79,53.12
  IN1 w0.097: 183.55,52.37 182.79,53.12 ; 182.79,54.84 182.79,57.31 182.18,57.92 182.18,60.19 179.93,62.44 177.06,62.44 175.41,64.1 174.9,64.1 170.88,68.11 170.88,75.92 170.17,76.63 170.17,77.26 169.13,78.3 169.13,83.9 169.54,84.3 169.54,86.08 169.04,86.57 169.04,89.24 172.86,93.06 172.86,111.68 173.76,112.58 173.76,130.03 173.05,130.74 173.05,140.3 179.08,146.33 186.58,146.33 188.58,148.33 191.43,148.33 194.77,151.66 194.77,153.19 196.1,154.52 196.99,154.52 v2(197.63,155.15) 197.63,157.25 199.4,159.03 199.4,159.85 198.07,161.19 176.14,161.19 173.76,163.57 169.78,163.57 167.97,165.38 166.26,165.38 v2(164.73,166.9) ; 184.56,50.18 184.56,43.15 184.29,42.88 184.29,37.61 183.59,36.92 180.65,36.92 179.35,35.62 179.35,33.39 v2(179.34,33.39)
  IN2 w0.089: 184.56,30.02 181.94,30.02 181.69,30.27 181.69,33.7 181.24,34.14 180.06,34.14 179.35,33.44 179.35,33.39
  IN2 w0.097: 184.56,30.02 184.97,30.02 184.99,29.99 185.06,29.99 191.72,23.33 191.72,13.99 194.7,11.01 208.94,11.01 212.53,14.6 215.68,14.6 216.79,15.7 220.76,15.7 221.59,16.53 226.91,16.53 228.17,15.26 235.02,15.26 235.96,16.2 v2(236.82,16.2) 236.82,17.5 237.19,17.87 v2(237.19,31.47) ; 96.92,9.49 v2(93.8,9.49) 85.31,9.49 83.68,11.12 73.94,11.12 73.48,11.58 73.48,11.96 v2(73.42,12.03)
  IN2 w0.104: 96.92,9.49 97.48,8.92 103.58,8.92 104.27,8.23 113.35,8.23 115.29,10.17 115.29,11.78 116.38,12.88 117.71,12.88 118.91,14.07 138,14.07 139,15.08 143.5,15.08 145.72,17.3 148.41,17.3 151.27,20.15 156.54,20.15 158.7,22.31 167.21,22.31 168.04,23.14 174.94,23.14 176.86,25.06 176.86,28.49 177.43,29.06 177.43,29.8 178.07,30.44 178.07,31.84 179.35,33.12 179.35,33.39 v2(179.34,33.39)
  IN4 w0.137: v2(73.48,63.99) 78.24,59.24 78.24,48.65 76.6,47.01 76.6,36.52 74.63,34.55 74.63,19.44 72.02,16.84 72.02,14.69 73.04,13.68 73.04,13.42 73.42,13.04 v2(73.42,12.03) ; v2(237.19,31.47) 237.58,31.47 249.08,42.97 267,42.97 285.95,61.93 v2(290.26,61.93)
  BOTTOM w0.114: v2(237.19,31.47) 235.86,32.8 JSSD1.50 ; v2(197.63,155.15) 197.97,154.81 197.97,153.67 198.93,152.7 199.13,152.7 199.49,152.34 UL1.2 ; JWLAN.44 291.09,62.75 v2(290.26,61.93) ; v2(236.82,16.2) 236.82,13.8 236.53,13.51 236.53,9.54 235.88,8.9 JSSD2.50
PD_EE_CLK: length 22.6
  IN5 w0.097: v2(136.21,143.19) 136.21,144.89 135.56,145.54 128.66,145.54 126.96,147.25 125.43,147.25 124.65,146.47 124.14,146.47 v2(123.78,146.84)
  BOTTOM w0.076: 124.05,147.36 124.55,147.87 UT4.A3
  BOTTOM w0.114: v2(136.21,143.19) 136.95,143.19 137.09,143.05 137.09,142.01 137.21,141.88 v1(137.24,141.88) 139.87,141.88 RT101.2 ; 124.05,147.36 124.05,147.34 123.9,147.19 123.9,146.96 v2(123.78,146.84)
PD_EE_CS_N: length 19.7
  IN5 w0.097: v2(133.4,146.52) 133.4,146.3 133.15,146.05 128.82,146.05 127.2,147.66 123.9,147.66 v2(123.2,146.96)
  BOTTOM w0.076: UT4.B3 124.3,148.83 124.3,147.96 124.31,147.96
  BOTTOM w0.114: v2(133.4,146.52) v1(135.73,148.85) 136.41,149.53 RT100.2 ; 124.31,147.96 123.56,147.22 123.46,147.22 v2(123.2,146.96)
PD_EE_DI: length 22.1
  IN1 w0.097: v2(124.37,146.88) 124.91,146.34 125.7,146.34 130.56,141.47 134.49,141.47 v2(134.84,141.82)
  BOTTOM w0.076: 124.39,147.36 124.8,147.77 124.8,148.83 UT4.B4
  BOTTOM w0.114: v2(124.37,146.88) 124.37,147.34 124.39,147.36 ; RT98.2 141.25,142.01 140.79,141.55 135.45,141.55 v1(135.36,141.63) 135.17,141.82 v2(134.84,141.82)
PD_EE_DO: length 18.7
  TOP w0.114: v1(138.17,148.69) 138.25,148.77 v2(138.25,149.19) 138.91,149.85 RT99.2
  IN5 w0.097: v2(124.84,147.24) 125.05,147.45 127.04,147.45 128.72,145.77 134.84,145.77 v2(138.25,149.19)
  BOTTOM w0.089: 124.96,147.36 125.05,147.45 UT4.A4
  BOTTOM w0.114: 124.96,147.36 v2(124.84,147.24)
PD_IRQ#: length 193
  TOP w0.114: v2(91.11,19.32) 91.47,19.69 UE5.89
  IN5 w0.097: v2(126.39,146.84) 127.2,146.02 127.2,143.26 126.46,142.51 113.25,142.51 111.12,144.64 97.56,144.64 96.72,143.79 94.53,143.79 94.32,144 92.66,144 92.13,143.47 87.61,143.47 86.86,142.72 86.86,141.83 85.93,140.9 85.93,91.92 84.49,90.47 84.49,60.88 78.67,55.06 78.67,49.52 76.17,47.03 76.17,23.27 77.1,22.35 87.71,22.35 88.76,21.3 89.22,21.3 91.11,19.42 v2(91.11,19.32)
  BOTTOM w0.076: UT4.B6 125.8,148.83 125.8,148.28 125.93,148.16
  BOTTOM w0.089: 125.93,147.36 v1(125.93,147.37)
  BOTTOM w0.114: 125.93,148.16 v1(125.93,147.37) ; RT107.2 v2(126.39,146.84) 125.93,147.3 125.93,147.36
PD_RESET: length 198.7
  TOP w0.114: UE10.8 v2(123.71,10.89)
  IN2 w0.097: v2(133.22,147.09) 133.45,147.09 134.84,145.71 134.84,142.7 136.05,141.49 151.11,141.49 154.34,138.26 155.7,138.26 157.19,136.76 157.19,134.16 160.87,130.48 160.87,121 158.32,118.45 158.32,115.47 153.38,110.52 153.38,79.83 155.6,77.61 155.6,72.26 157.4,70.46 157.4,69.02 155.78,67.4 155.78,63.98 v2(154.65,62.85)
  IN3 w0.124: v2(154.65,62.85) 154.65,60.77 152.57,58.69 152.57,50.73 151.68,49.84 151.68,33.84 153.14,32.38 153.14,25.46 149.34,21.65 146.23,21.65 145.33,20.76 123.17,20.76 122.5,20.09 v2(121.25,20.09)
  BOTTOM w0.114: v2(123.71,10.89) 122.9,10.89 122.52,11.28 122.52,16.37 121.25,17.64 v2(121.25,20.09) ; v2(133.22,147.09) 133.31,147.18 v1(133.31,147.98) 133.31,149 RT109.1
PD_UART: length 4.8
  TOP w0.114: RT62.1 123.04,150.85 v2(122.95,150.94) 122.84,150.94 122.63,150.74 122.63,149.53 123.01,149.15 v1(123.37,149.15)
  BOTTOM w0.076: UT4.E2 123.95,150.58 123.7,150.83 123.06,150.83 v2(122.95,150.94)
  BOTTOM w0.127: UT4.F2 UT4.E2
PECI_KB9012: length 2.2
  TOP w0.114: RE76.1 85.64,11.34 UE5.118
PEG_CRX_GTX_C_N8: length 2.3
  BOTTOM w0.114: UM8.4 105.09,146.64 105.23,146.51 105.23,146.33 105.45,146.1 105.45,145.64 105.48,145.61 105.48,145.21 CM66.2
PEG_CRX_GTX_C_N9: length 2.4
  BOTTOM w0.114: UM8.8 103.09,146.66 103.23,146.52 103.23,146.45 102.89,146.11 102.89,145.25 102.89,145.24 102.89,145.23 CM65.2
PEG_CRX_GTX_C_N10: length 4.2
  BOTTOM w0.114: UM8.6 104.09,146.51 104.23,146.37 v4(104.23,145.46) 104.23,144.33 104.21,144.32 104.21,143.79 104.23,143.78 104.23,143.26 CM62.2
PEG_CRX_GTX_C_N11: length 4.4
  BOTTOM w0.114: CM69.2 106.84,143.27 106.84,143.63 106.82,143.64 106.82,144.16 106.84,144.18 v4(106.84,145.16) 106.84,145.49 106.23,146.1 106.23,146.37 106.09,146.51 UM8.2
PEG_CRX_GTX_C_P8: length 2.3
  BOTTOM w0.114: CM63.2 105.7,145.26 v4(105.7,145.91) 105.7,146.17 105.55,146.32 105.45,146.42 105.45,146.52 105.59,146.66 UM8.3
PEG_CRX_GTX_C_P9: length 2.4
  BOTTOM w0.114: CM64.2 103.12,145.25 103.12,146.01 103.45,146.35 103.45,146.51 103.59,146.64 UM8.7
PEG_CRX_GTX_C_P10: length 4.2
  BOTTOM w0.114: CM68.2 104.45,143.27 v4(104.45,144.06) 104.45,145.19 104.47,145.2 104.47,145.73 104.45,145.74 104.45,146.37 104.59,146.51 UM8.5
PEG_CRX_GTX_C_P11: length 4.4
  BOTTOM w0.114: CM67.2 107.07,143.27 v4(107.07,143.9) 107.07,144.89 107.08,144.9 107.08,145.57 106.45,146.19 106.45,146.37 106.59,146.51 UM8.1
PEG_CRX_GTX_N0: length 45.1
  TOP w0.114: CG9.1 176.42,96.16 176.32,96.07 176.32,95.88 176.26,95.82 175.75,95.82 174.36,94.42 172.45,94.42 170.93,92.89 166.71,92.89 166.48,93.12 166.48,93.22 166.53,93.27 166.53,93.36 166.61,93.43 v2(166.73,93.43)
  IN4 w0.089: v2(140.53,91.39) 140.53,91.35 140.71,91.16 140.78,91.16 141.35,90.59 142.56,90.59 143.07,90.08 143.07,88.3 144.01,87.36 144.13,87.36
  IN4 w0.147: v2(166.73,93.43) 166.57,93.59 166.57,93.86 166.29,94.15 163.53,94.15 160.1,90.72 155.22,90.72 151.86,87.36 144.13,87.36
  BOTTOM w0.076: v2(140.53,91.39) 140.53,91.31 CPU1.E10
PEG_CRX_GTX_N0_C: length 5.3
  TOP w0.089: 179.08,95.99 179.11,95.99 179.13,95.97 180.79,95.97 181.19,96.37 181.19,96.64 181.07,96.77 180.87,96.77 v2(180.85,96.75)
  TOP w0.114: 179.08,95.99 178.56,95.99 178.49,95.92 177.59,95.92 CG9.2
  BOTTOM w0.114: v2(180.85,96.75) 181.1,97 UG9.BH26
PEG_CRX_GTX_N1: length 42.3
  TOP w0.114: CG16.1 176.76,97.31 176.63,97.18 176.04,97.18 175.15,96.29 173.12,96.29 171.71,94.89 168,94.89 168,94.89 167.95,94.89 167.85,94.89 167.75,94.99 167.75,94.99 167.7,95.04 167.7,95.22 v2(167.85,95.37)
  IN4 w0.089: 144.49,88.9 144.46,88.9 144.44,88.92 143.78,88.92 143.27,89.43 143.27,90.13 142.64,90.77 141.53,90.77 141.3,91 141.3,91.26 141.19,91.37 v2(141.19,91.37)
  IN4 w0.147: v2(167.85,95.37) 167.78,95.3 167.78,94.97 167.49,94.68 163.31,94.68 159.91,91.27 154.19,91.27 151.81,88.9 144.49,88.9
  BOTTOM w0.076: v2(141.19,91.37) 140.86,91.7 CPU1.E11
PEG_CRX_GTX_N1_C: length 7.3
  TOP w0.089: 179.08,97.24 179.11,97.24 179.14,97.2 179.35,97.2 179.58,97.43 182.05,97.43 182.21,97.6 183,97.6 183.37,97.23 183.37,96.99 183.39,96.97 183.39,96.96 v2(183.5,96.85)
  TOP w0.114: 179.08,97.24 177.48,97.24 CG16.2
  BOTTOM w0.114: UG9.BE26 v2(183.5,96.85)
PEG_CRX_GTX_N2: length 42.6
  TOP w0.114: CG25.1 176.59,98.4 173.07,98.4 171.97,97.3 167.92,97.3 167.73,97.3 167.45,97.02 167.45,96.85 v2(167.25,96.65)
  IN4 w0.089: v2(140.54,92.16) 140.54,92.27 140.71,92.44 140.91,92.44 141.57,91.78 142.64,91.78 143.03,91.39 143.03,91.01 144.09,89.95 144.69,89.95 144.72,89.92 144.73,89.92 144.74,89.91
  IN4 w0.147: v2(167.25,96.65) 167.38,96.78 167.38,96.96 167.25,97.08 164.32,97.08 159.48,92.24 153.83,92.24 151.48,89.89 144.77,89.89 144.74,89.91
  BOTTOM w0.089: v2(140.54,92.16) 140.54,92.23 CPU1.E12
PEG_CRX_GTX_N2_C: length 5.7
  TOP w0.089: v2(181.5,98.15) 181.57,98.15 181.62,98.1 181.62,97.92 181.5,97.79 180.31,97.79 180.05,98.06 179.13,98.06 179.11,98.08 179.08,98.08
  TOP w0.114: CG25.2 177.47,98.7 177.66,98.7 177.78,98.58 177.78,98.34 178.04,98.08 v4(178.88,98.08) 179.08,98.08
  BOTTOM w0.114: UG9.BG27 v2(181.5,98.15)
PEG_CRX_GTX_N3: length 41.8
  TOP w0.114: v2(165.15,97.85) 165.34,98.03 165.34,98.3 165.59,98.56 167.48,98.56 167.62,98.42 170.29,98.42 171.48,99.61 176.59,99.61 CG27.1
  IN4 w0.089: 145.44,91.12 145.42,91.12 145.39,91.15 144.54,91.15 144.29,91.4 143.78,91.4 142.85,92.33 141.61,92.33 141.37,92.57 141.37,92.77 v2(141.19,92.95)
  IN4 w0.147: 145.44,91.12 145.47,91.08 148.28,91.08 148.47,90.89 151.27,90.89 153.44,93.06 158.96,93.06 164.23,98.34 165.17,98.34 165.3,98.21 165.3,97.99 v2(165.15,97.85)
  BOTTOM w0.076: CPU1.E13 140.86,93.27 v2(141.19,92.95)
PEG_CRX_GTX_N3_C: length 5.5
  TOP w0.089: 179.08,99.3 179.11,99.3 179.13,99.27 179.91,99.27 180.71,98.47 180.99,98.47 181.06,98.47 181.19,98.6 181.19,98.75 181.06,98.87 v2(180.89,98.87)
  TOP w0.114: CG27.2 177.34,99.72 177.47,99.59 177.54,99.59 177.68,99.45 177.68,99.45 177.71,99.41 178.52,99.41 178.66,99.28 179.07,99.28 179.08,99.3
  BOTTOM w0.114: v2(180.89,98.87) 181.1,99.09 UG9.BH29
PEG_CRX_GTX_N4: length 42.7
  TOP w0.114: CG29.1 176.76,101.03 176.63,100.9 171.55,100.9 169.8,99.15 168.24,99.15 v2(168.07,99.32)
  IN4 w0.089: 145.31,92.15 145.3,92.14 145.29,92.14 145.26,92.11 143.95,92.11 143.51,92.55 143.51,92.94 142.9,93.55 141.76,93.55 141.24,94.07 140.73,94.07 140.53,94.27 v2(140.53,94.5)
  IN4 w0.147: 145.31,92.15 145.34,92.18 150.77,92.18 153.01,94.42 158.73,94.42 164.38,100.06 167.51,100.06 167.84,99.73 167.84,99.53 167.89,99.48 167.89,99.42 167.99,99.32 v2(168.07,99.32)
  BOTTOM w0.076: CPU1.E14 140.53,94.46 v2(140.53,94.5)
PEG_CRX_GTX_N4_C: length 7.7
  TOP w0.089: 179.08,100.14 179.11,100.14 179.13,100.11 180.26,100.11 180.86,99.52 182.1,99.52 182.28,99.7 183.01,99.7 183.28,99.43 183.28,99.17 v2(183.5,98.95)
  TOP w0.114: 179.08,100.14 178.98,100.14 v4(178.37,100.74) 178.09,101.02 177.38,101.02 CG29.2
  BOTTOM w0.114: UG9.BE29 v2(183.5,98.95)
PEG_CRX_GTX_N5: length 41.2
  TOP w0.114: v2(165.98,100.5) 166.19,100.7 166.19,100.95 166.52,101.28 169.92,101.28 170.73,102.09 175.88,102.09 175.88,102.09 176.59,102.08 176.62,102.08 176.76,102.22 CG31.1
  IN4 w0.089: v2(141.19,94.52) 141.31,94.52 141.48,94.36 141.48,94.21 141.75,93.94 143.14,93.94 143.71,93.37 144.56,93.37 144.59,93.34 144.61,93.34
  IN4 w0.147: 144.61,93.34 151.18,93.34 153.24,95.4 158.61,95.4 163.89,100.69 164.66,100.69 164.9,100.94 165.98,100.94 166.11,100.81 166.11,100.63 v2(165.98,100.5)
  BOTTOM w0.076: v2(141.19,94.52) CPU1.E15
PEG_CRX_GTX_N5_C: length 6.6
  TOP w0.089: v2(181.31,100.42) 181.55,100.18 181.55,100.02 181.4,99.88 181.21,99.88 180.58,100.51 180.58,100.78 180.56,100.8 180.56,100.81 180.52,100.85 180.52,100.87 180.51,100.88
  TOP w0.114: CG31.2 177.59,102.01 v4(178.59,102.01) 179.38,102.01 180.51,100.88
  BOTTOM w0.114: UG9.BG30 181.78,99.95 v2(181.31,100.42)
PEG_CRX_GTX_N6: length 41.7
  TOP w0.114: v2(168.32,102.96) 168.22,102.96 168.06,103.12 168.06,103.34 168.19,103.47 169.77,103.47 170.13,103.1 176.49,103.1 176.49,103.1 176.63,103.1 176.76,102.98 CG33.1
  IN4 w0.089: 143.47,94.86 143.45,94.86 143.42,94.89 141.49,94.89 140.92,95.46 140.66,95.46 140.54,95.34 v2(140.54,95.31)
  IN4 w0.147: 143.47,94.86 151.56,94.86 153.47,96.78 155.7,96.78 156.97,98.05 158.24,98.05 161.71,101.52 164.31,101.52 164.99,102.2 167.82,102.2 168.11,102.49 168.11,102.75 v2(168.32,102.96)
  BOTTOM w0.089: CPU1.E16 140.54,95.38 v2(140.54,95.31)
PEG_CRX_GTX_N6_C: length 6.2
  TOP w0.114: CG33.2 177.34,103.01 177.47,103.14 177.6,103.14 177.68,103.23 177.68,103.23 177.71,103.26 179.92,103.26 181.12,102.07 181.12,101.12 180.98,100.98 v2(180.9,100.98)
  BOTTOM w0.114: v2(180.9,100.98) 181.1,101.18 UG9.BH32
PEG_CRX_GTX_N7: length 42.8
  TOP w0.114: v2(166.43,102.98) 166.5,103.05 166.5,103.76 167.27,104.53 176.59,104.53 176.59,104.53 176.62,104.53 CG36.1
  IN4 w0.097: 143.75,96.24 143.69,96.24 142.75,95.3 141.75,95.3 141.49,95.55 141.49,95.97 141.37,96.1 v2(141.19,96.1)
  IN4 w0.147: v2(166.43,102.98) 166.54,103.09 166.54,103.51 166.42,103.64 165.29,103.64 164.17,102.51 162.38,102.51 161.96,102.94 160.85,102.94 158.07,100.16 157.68,100.16 155.14,97.62 153.12,97.62 151.74,96.24 149.68,96.24 149.16,95.72 147.78,95.72 147.25,96.24 143.75,96.24
  BOTTOM w0.076: v2(141.19,96.1) CPU1.E17
PEG_CRX_GTX_N7_C: length 8.2
  TOP w0.114: v2(183.5,101.05) 183.28,101.27 183.28,101.52 182.22,102.58 181.96,102.58 v4(181.32,103.22) 180.26,104.28 178.85,104.28 178.46,104.67 CG36.2
  BOTTOM w0.114: UG9.BE32 v2(183.5,101.05)
PEG_CRX_GTX_N8: length 118.9
  IN4 w0.089: v2(140.54,96.89) 141.08,96.89 141.39,96.58 142.67,96.58 143.94,97.85 144.45,97.85 145.04,98.44 145.04,100.16 145.76,100.88 147.78,100.88 147.83,100.83 147.84,100.83
  IN4 w0.147: 147.84,100.83 148.06,100.83 154.38,107.15 154.45,107.15 157.05,109.75 158.06,109.75 158.89,110.58 158.89,110.96 163,115.06 163,136.38 158.11,141.27 150.88,141.27 150.29,141.86 145.08,141.86 144.58,141.36 141.27,141.36 140.74,141.88 135.85,141.88 134.14,143.59 132.27,143.59 130.82,142.14 118.58,142.14 117.75,142.96 111.72,142.96 110.19,144.49 106.06,144.49 105.31,143.74 v2(105.31,142.87)
  BOTTOM w0.076: v2(140.54,96.89) 140.54,96.95 CPU1.F18
  BOTTOM w0.114: v2(105.31,142.87) 105.49,143.04 105.49,143.26 105.47,143.28 105.47,143.82 105.49,143.84 105.49,144.26 CM66.1
PEG_CRX_GTX_N9: length 117.9
  IN4 w0.089: 147.65,102.38 147.63,102.37 147.63,102.3 147.47,102.13 145.3,102.13 144.48,101.31 144.48,98.64 144.23,98.39 143.72,98.39 142.45,97.12 141.68,97.12 141.45,97.34 141.45,97.43 141.55,97.52 141.55,97.61 141.64,97.69 141.82,97.69 v2(141.84,97.67)
  IN4 w0.147: 147.65,102.38 148.16,102.89 148.16,103.34 157.2,112.38 158.79,112.38 161.49,115.09 161.49,121.72 161.79,122.01 161.79,122.71 161.67,122.84 161.19,122.84 160.88,123.15 160.88,123.82 161.19,124.12 161.67,124.12 161.79,124.25 161.79,124.73 161.67,124.86 161.19,124.86 160.88,125.17 160.88,136.98 157.81,140.04 150.26,140.04 149.51,140.78 145.54,140.78 144.92,140.17 140.9,140.17 140.35,140.72 132.51,140.72 132.18,141.06 117.87,141.06 117.26,141.67 109.78,141.67 109.31,142.14 103.43,142.14 103.21,142.14 102.92,142.42 102.92,142.93 102.85,142.99 102.6,142.99 102.48,143.11 v2(102.48,143.35)
  BOTTOM w0.076: CPU1.D19 141.51,98 v2(141.84,97.67)
  BOTTOM w0.114: v2(102.48,143.35) 102.61,143.35 102.82,143.57 102.82,144.32 CM65.1
PEG_CRX_GTX_N10: length 114.5
  IN4 w0.089: 146.32,103.1 146.25,103.04 146.25,102.96 146.01,102.72 144.23,102.72 143.71,102.2 143.71,98.64 143.16,98.08 141.55,98.08 140.98,98.65 140.73,98.65 v2(140.55,98.46)
  IN4 w0.147: v2(103.93,140.58) 103.96,140.61 103.96,141.22 104.31,141.57 109.04,141.57 109.49,141.12 117.03,141.12 117.7,140.45 131.91,140.45 132.33,140.02 140.03,140.02 140.52,139.53 145.04,139.53 145.74,140.23 148.99,140.23 149.73,139.49 157.61,139.49 160.35,136.75 160.35,118.08 160.8,117.63 160.8,115.72 158.89,113.82 157.3,113.82 149.24,105.75 147.37,105.75 146.32,104.7 146.32,103.1
  BOTTOM w0.076: v2(140.55,98.46) 140.21,98.8 CPU1.F20
  BOTTOM w0.114: v2(103.93,140.58) 104.18,140.83 104.18,142.32 CM62.1
PEG_CRX_GTX_N11: length 114.3
  IN4 w0.089: 143.03,100.4 143.06,100.37 143.06,100.21 143.09,100.18 143.09,99.16 142.57,98.64 141.74,98.64 141.49,98.89 141.49,99.04 141.55,99.1 141.55,99.2 141.63,99.28 141.81,99.28 v2(141.84,99.25)
  IN4 w0.147: v2(106.44,140.8) 106.93,140.31 106.93,140.03 107.22,139.74 108.11,139.74 108.42,140.04 109.07,140.04 109.22,139.9 109.22,139.59 109.53,139.28 110.2,139.28 110.51,139.59 110.51,139.9 110.65,140.04 111.1,140.04 111.24,139.9 111.24,139.59 111.55,139.28 112.22,139.28 112.53,139.59 112.53,139.9 112.68,140.04 113.12,140.04 113.27,139.9 113.27,139.59 113.57,139.28 114.24,139.28 114.55,139.59 114.55,139.9 114.7,140.04 116.58,140.04 117.26,139.37 131.36,139.37 131.79,138.94 139.59,138.94 140.08,138.45 145.49,138.45 146.19,139.16 148.55,139.16 149.29,138.41 157.15,138.41 159.27,136.3 159.27,117.57 156.14,114.44 155.93,114.44 155.73,114.64 155.32,114.64 154.82,114.13 154.82,113.73 155.02,113.53 155.02,113.32 153.2,111.5 152.99,111.5 152.54,111.95 152.13,111.95 151.63,111.45 151.63,111.04 152.08,110.59 152.08,110.38 151.77,110.07 151.56,110.07 151.08,110.56 150.67,110.56 150.17,110.05 150.17,109.65 150.65,109.16 150.65,108.95 150.07,108.37 147.22,108.37 146.55,107.69 146.55,107.67 146.09,107.21 144.79,107.21 143.03,105.45 143.03,100.4
  BOTTOM w0.076: CPU1.D21 141.51,99.51 141.77,99.25 v2(141.84,99.25)
  BOTTOM w0.114: v2(106.44,140.8) 106.48,140.8 106.76,141.08 106.76,142.35 CM69.1
PEG_CRX_GTX_P0: length 45.1
  TOP w0.114: CG8.1 175.85,95.59 174.45,94.19 172.54,94.19 171.02,92.67 166.62,92.67 166.26,93.03 166.26,93.32 v2(166.14,93.43)
  IN4 w0.089: v2(140.54,90.59) 140.5,90.59 140.41,90.68 140.41,90.86 140.54,90.99 140.7,90.99 141.28,90.41 142.49,90.41 142.89,90.01 142.89,88.23 144.03,87.08
  IN4 w0.147: 144.03,87.08 151.97,87.08 155.34,90.45 160.22,90.45 163.64,93.87 166.17,93.87 166.3,93.75 166.3,93.52 166.22,93.43 v2(166.14,93.43)
  BOTTOM w0.076: CPU1.F10 140.21,90.91 v2(140.54,90.59)
PEG_CRX_GTX_P0_C: length 5.3
  TOP w0.089: v2(181.5,96.85) 181.37,96.72 181.37,96.3 180.86,95.79 v4(179.58,95.79) 179.13,95.79 179.11,95.77 179.08,95.77
  TOP w0.114: 179.08,95.77 178.62,95.77 178.57,95.71 177.47,95.71 CG8.2
  BOTTOM w0.114: UG9.BG26 v2(181.5,96.85)
PEG_CRX_GTX_P1: length 42.2
  TOP w0.114: v2(167.26,95.4) 167.48,95.18 167.48,94.95 167.53,94.9 167.53,94.89 167.76,94.66 167.76,94.66 168.09,94.66 171.81,94.66 173.21,96.07 175.24,96.07 176.13,96.96 176.6,96.96 CG10.1
  IN4 w0.089: 144.49,89.14 144.48,89.13 144.43,89.13 144.4,89.1 143.85,89.1 143.45,89.51 143.45,90.21 142.71,90.94 141.61,90.94 141.48,91.07 141.48,91.15 141.55,91.22 141.55,91.29 141.65,91.38 141.83,91.38 v2(141.84,91.37)
  IN4 w0.147: 144.49,89.14 144.51,89.17 151.7,89.17 154.08,91.55 159.79,91.55 163.2,94.95 167.38,94.95 167.51,95.08 167.51,95.15 167.45,95.21 167.45,95.27 167.33,95.4 v2(167.26,95.4)
  BOTTOM w0.076: CPU1.D11 141.51,91.7 v2(141.84,91.37)
PEG_CRX_GTX_P1_C: length 7.3
  TOP w0.089: 179.08,97 179.11,97 179.14,97.03 179.43,97.03 179.66,97.26 182.12,97.26 182.28,97.42 182.93,97.42 183.19,97.16 183.19,97.05 183.14,97 183.14,96.95 183.01,96.82 182.83,96.82 v2(182.8,96.85)
  TOP w0.114: 179.08,97 177.54,97 CG10.2
  BOTTOM w0.117: UG9.BF26 v2(182.8,96.85)
PEG_CRX_GTX_P2: length 42.6
  TOP w0.114: CG22.1 176.59,98.18 173.16,98.18 172.06,97.08 167.83,97.08 167.67,96.93 167.67,96.81 v2(167.84,96.65)
  IN4 w0.089: 144.74,90.16 144.72,90.16 144.69,90.13 144.16,90.13 143.21,91.08 143.21,91.46 142.72,91.96 141.65,91.96 140.98,92.63 140.8,92.63 v2(140.52,92.92)
  IN4 w0.147: v2(167.84,96.65) 167.65,96.83 167.65,97.07 167.37,97.36 164.21,97.36 159.37,92.52 153.72,92.52 151.36,90.16 144.74,90.16
  BOTTOM w0.089: v2(140.52,92.92) 140.52,92.86 CPU1.F12
PEG_CRX_GTX_P2_C: length 5.7
  TOP w0.089: v2(182.2,98.15) 181.66,97.61 180.24,97.61 179.97,97.88 179.06,97.88 179.06,97.88 179.04,97.88
  TOP w0.114: 179.04,97.88 177.95,97.88 177.83,98 CG22.2
  BOTTOM w0.114: UG9.BF27 v2(182.2,98.15)
PEG_CRX_GTX_P3: length 41.9
  TOP w0.114: CG26.1 176.59,99.39 171.57,99.39 170.38,98.2 167.53,98.2 167.39,98.34 165.69,98.34 165.56,98.21 165.56,98.02 v2(165.74,97.85)
  IN4 w0.089: 145.43,91.36 145.43,91.35 145.42,91.35 145.39,91.32 144.61,91.32 144.36,91.58 143.85,91.58 142.92,92.51 141.69,92.51 141.56,92.64 141.56,92.82 141.69,92.95 v2(141.84,92.95)
  IN4 w0.147: v2(165.74,97.85) 165.57,98.01 165.57,98.32 165.28,98.61 164.12,98.61 158.84,93.34 153.33,93.34 151.16,91.17 148.58,91.17 148.4,91.36 145.43,91.36
  BOTTOM w0.076: CPU1.D13 141.51,93.09 141.66,92.95 v2(141.84,92.95)
PEG_CRX_GTX_P3_C: length 5.5
  TOP w0.089: 179.09,99.08 179.11,99.08 179.13,99.1 179.84,99.1 180.64,98.3 180.91,98.3 181.13,98.3 181.37,98.53 181.37,98.82 v2(181.5,98.95)
  TOP w0.114: CG26.2 v4(178.18,99.21) 178.44,99.21 178.57,99.08 179.09,99.08
  BOTTOM w0.114: UG9.BG29 181.73,99.25 181.5,99.02 v2(181.5,98.95)
PEG_CRX_GTX_P4: length 42.7
  TOP w0.114: CG28.1 176.57,100.67 171.64,100.67 169.89,98.92 167.88,98.92 v2(167.49,99.32)
  IN4 w0.089: 145.31,91.91 145.29,91.91 145.26,91.93 143.88,91.93 143.33,92.48 143.33,92.86 142.83,93.37 141.68,93.37 141.16,93.89 140.7,93.89 v2(140.54,93.72)
  IN4 w0.147: 145.31,91.91 150.89,91.91 153.13,94.14 158.85,94.14 164.49,99.79 167.4,99.79 167.57,99.61 167.57,99.42 167.58,99.41 v2(167.49,99.32)
  BOTTOM w0.076: CPU1.F14 140.41,94.13 140.54,94 v2(140.54,93.72)
PEG_CRX_GTX_P4_C: length 7.8
  TOP w0.089: v2(182.8,98.95) 182.97,98.95 183.1,99.08 183.1,99.35 182.93,99.52 182.35,99.52 182.17,99.34 180.79,99.34 180.19,99.94 179.06,99.94 179.06,99.93 179.04,99.93
  TOP w0.114: CG28.2 177.34,100.6 177.47,100.73 177.6,100.73 177.68,100.82 178.01,100.82 178.89,99.93 179.04,99.93
  BOTTOM w0.114: UG9.BF29 v2(182.8,98.95)
PEG_CRX_GTX_P5: length 41.3
  TOP w0.114: v2(166.57,100.5) 166.41,100.66 166.41,100.85 166.61,101.05 170.02,101.05 170.83,101.86 175.95,101.86 176.59,101.86 CG30.1
  IN4 w0.089: v2(141.9,94.52) 141.79,94.52 141.66,94.39 141.66,94.28 141.82,94.12 143.22,94.12 143.79,93.55 144.56,93.55 144.59,93.58 144.6,93.58 144.61,93.59
  IN4 w0.147: 144.61,93.59 144.64,93.61 151.06,93.61 153.13,95.68 158.49,95.68 163.78,100.96 164.54,100.96 164.79,101.21 166.1,101.21 166.38,100.92 166.38,100.68 v2(166.57,100.5)
  BOTTOM w0.076: CPU1.D15 141.53,94.89 141.53,94.6 141.68,94.46 141.84,94.46 v2(141.9,94.52)
PEG_CRX_GTX_P5_C: length 6.6
  TOP w0.089: v2(182.2,100.25) 182.03,100.25 181.48,99.7 181.14,99.7 180.4,100.44 180.4,100.7 180.37,100.74
  TOP w0.114: 180.37,100.74 179.29,101.81 177.47,101.81 CG30.2
  BOTTOM w0.114: UG9.BF30 v2(182.2,100.25)
PEG_CRX_GTX_P6: length 41.7
  TOP w0.114: CG32.1 176.62,103.33 176.59,103.33 170.22,103.33 169.86,103.69 168.09,103.69 167.83,103.43 167.83,103.09 167.71,102.96 v2(167.71,102.96)
  IN4 w0.089: v2(140.54,96.1) 140.54,95.83 140.73,95.64 140.99,95.64 141.57,95.07 143.44,95.07 143.51,95.14
  IN4 w0.147: 143.51,95.14 151.45,95.14 153.36,97.05 155.59,97.05 156.86,98.32 158.12,98.32 161.6,101.8 164.2,101.8 164.87,102.47 167.71,102.47 167.84,102.6 167.84,102.83 v2(167.71,102.96)
  BOTTOM w0.089: v2(140.54,96.1) 140.54,96.03 CPU1.F16
PEG_CRX_GTX_P6_C: length 6.2
  TOP w0.114: v2(181.49,101.04) 181.45,101.04 181.32,101.17 181.32,102.15 180.01,103.47 v4(178.84,103.47) CG32.2
  BOTTOM w0.114: UG9.BG32 181.8,101.3 181.54,101.04 v2(181.49,101.04)
PEG_CRX_GTX_P7: length 42.8
  TOP w0.114: v2(167.01,102.98) 166.97,102.98 166.72,103.23 166.72,103.67 167.36,104.31 176.49,104.31 176.49,104.31 176.59,104.31 176.76,104.14 CG35.1
  IN4 w0.097: v2(141.84,96.1) 141.8,96.1 141.68,95.97 141.68,95.63 141.83,95.48 142.65,95.48 143.69,96.52
  IN4 w0.147: v2(167.01,102.98) 166.82,103.17 166.82,103.62 166.53,103.91 165.18,103.91 164.06,102.79 162.5,102.79 162.07,103.21 160.73,103.21 157.96,100.44 157.57,100.44 155.03,97.9 153.01,97.9 151.63,96.52 149.57,96.52 149.04,95.99 147.89,95.99 147.37,96.52 143.69,96.52
  BOTTOM w0.076: v2(141.84,96.1) 141.67,96.1 141.5,96.27 141.5,96.48 CPU1.D17
PEG_CRX_GTX_P7_C: length 8.2
  TOP w0.114: CG35.2 177.34,104.14 177.55,104.35 177.6,104.35 177.72,104.47 178.35,104.47 178.76,104.06 179.08,104.06 179.1,104.08 180.18,104.08 181.88,102.37 182.13,102.37 v4(182.54,101.97) 183.07,101.43 183.07,101.21 182.91,101.05 v2(182.8,101.05)
  BOTTOM w0.114: v2(182.8,101.05) 182.8,101.15 182.6,101.35 UG9.BF32
PEG_CRX_GTX_P8: length 118.8
  IN4 w0.089: 147.84,101.1 147.82,101.1 147.77,101.05 145.68,101.05 144.86,100.23 144.86,98.52 144.37,98.03 143.86,98.03 142.59,96.76 141.46,96.76 141.16,97.06 140.87,97.06 140.69,97.25 140.35,97.25 140.25,97.35 140.25,97.39 140.25,97.4 140.25,97.55 140.38,97.67 v2(140.54,97.67)
  IN4 w0.147: 147.84,101.1 147.95,101.1 154.27,107.42 154.33,107.42 156.94,110.03 157.95,110.03 158.62,110.7 158.62,111.07 162.72,115.18 162.72,136.27 158,140.99 150.76,140.99 150.17,141.59 145.2,141.59 144.69,141.08 141.15,141.08 140.62,141.61 135.73,141.61 134.02,143.32 132.39,143.32 130.93,141.86 118.46,141.86 117.64,142.69 111.6,142.69 110.08,144.21 106.17,144.21 105.59,143.63 105.59,143.37 105.68,143.28 105.77,143.28 105.9,143.15 v2(105.9,142.87)
  BOTTOM w0.089: v2(140.54,97.67) 140.54,97.44 140.7,97.28 CPU1.E18
  BOTTOM w0.114: CM63.1 105.71,144.23 v4(105.71,143.55) 105.71,143.05 v2(105.9,142.87)
PEG_CRX_GTX_P9: length 117.9
  IN4 w0.089: v2(141.19,97.67) 141.28,97.58 141.28,97.27 141.61,96.94 142.52,96.94 143.79,98.21 144.3,98.21 144.65,98.56 144.65,101.23 145.38,101.95 147.54,101.95 147.76,102.17 147.83,102.17 147.84,102.19
  IN4 w0.147: 147.84,102.19 148.43,102.78 148.43,103.23 157.31,112.1 158.9,112.1 161.77,114.97 161.77,121.6 162.07,121.9 162.07,122.82 161.78,123.11 161.3,123.11 161.15,123.26 161.15,123.7 161.3,123.85 161.78,123.85 162.07,124.14 162.07,124.85 161.78,125.13 161.3,125.13 161.15,125.28 161.15,137.09 157.93,140.32 150.37,140.32 149.63,141.06 145.42,141.06 144.81,140.44 141.01,140.44 140.46,140.99 132.63,140.99 132.29,141.33 117.98,141.33 117.37,141.95 109.89,141.95 109.43,142.41 103.32,142.41 103.19,142.54 v2(103.19,143.35)
  BOTTOM w0.076: CPU1.E19 140.86,98 v2(141.19,97.67)
  BOTTOM w0.114: v2(103.19,143.35) 103.04,143.5 103.04,144.16 CM64.1
