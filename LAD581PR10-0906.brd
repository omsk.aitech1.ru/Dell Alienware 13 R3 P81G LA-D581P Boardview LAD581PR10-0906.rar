# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_D28: length 36.2
  IN3 w0.14: v2(210.96,105.09) 210.93,105.12 210.93,105.57 211.32,105.96 212.79,105.96 212.93,105.82 216.99,105.82 220.49,109.31 224.75,109.31 229.12,113.68 239.52,113.68 239.87,113.33 239.87,111.96 v2(239.48,111.57)
  BOTTOM w0.089: v2(239.48,111.57) 239.88,111.97 UG3.E4
  BOTTOM w0.17: v2(210.96,105.09) UG9.F38
FBB_D29: length 34.2
  IN3 w0.14: v2(239.48,110.77) 239.08,111.17 239.08,112.52 238.81,112.79 229.24,112.79 225.06,108.61 220.87,108.61 217.4,105.14 212.96,105.14 212.49,105.61 211.94,105.61 v2(211.52,105.19)
  BOTTOM w0.089: UG3.E2 v2(239.48,110.77)
  BOTTOM w0.17: v2(211.52,105.19) 211.2,105.51 UG9.E38
FBB_D30: length 32.2
  IN3 w0.14: v2(212.2,104.45) 212.61,104.04 217.37,104.04 221.12,107.78 236.04,107.78 237.12,108.86 237.12,109.82 238.27,110.96 238.27,111.96 v2(238.68,112.37)
  BOTTOM w0.089: UG3.F4 v2(238.68,112.37)
  BOTTOM w0.17: UG9.D36 v2(212.2,104.45)
FBB_D31: length 32.7
  IN3 w0.14: v2(238.68,110.77) 238.14,110.23 238.14,108.48 236.74,107.09 221.38,107.09 217.63,103.34 212.61,103.34 v2(211.5,104.45)
  BOTTOM w0.089: UG3.F2 v2(238.68,110.77)
  BOTTOM w0.17: v2(211.5,104.45) UG9.E36
FBB_D32: length 21.5
  IN1 w0.145: v2(206.29,117.6) 206.77,118.08 206.77,119.59 210.45,123.28 211.51,123.28 v2(217.41,129.18)
  BOTTOM w0.089: v2(217.41,129.18) 217.81,129.58 UG4.A4
  BOTTOM w0.142: UG9.M50 206.3,114.1 205.95,114.45 205.95,114.85 205.68,115.12 205.68,116.99
  BOTTOM w0.178: 205.68,116.99 v2(206.29,117.6)
FBB_D33: length 22.9
  IN1 w0.145: v2(205.3,112.8) 205.4,112.9 205.4,113.72 205.23,113.89 205.23,119.2 205.37,119.34 205.37,120.29 209.88,124.8 211.18,124.8 215.17,128.79 215.17,128.79 215.56,129.18 v2(215.81,129.18)
  BOTTOM w0.089: UG4.A2 v2(215.81,129.18)
  BOTTOM w0.17: UG9.P48 205.15,112.8 v2(205.3,112.8)
FBB_D34: length 21.6
  IN1 w0.145: v2(206.31,116.42) 207.35,117.46 207.35,118.9 209.75,121.31 210.47,121.31 217.8,128.64 217.8,129.59 v2(217.41,129.98)
  BOTTOM w0.089: v2(217.41,129.98) 217.81,130.38 UG4.B4
  BOTTOM w0.142: v2(206.31,116.42) 206.31,116.36 205.91,115.96 205.91,115.24 206.3,114.85 UG9.M51
FBB_D35: length 22.9
  IN1 w0.145: v2(205.9,113.65) 206.13,113.89 206.13,114.92 205.85,115.2 205.85,118.35 206.07,118.57 206.07,120.04 210.09,124.06 211.36,124.06 216.21,128.91 216.21,129.58 v2(216.61,129.98)
  BOTTOM w0.089: UG4.B2 v2(216.61,129.98)
  BOTTOM w0.17: UG9.M49 v2(205.9,113.65)
FBB_D36: length 31.4
  IN1 w0.145: v2(205.2,112.15) 204.87,112.48 204.87,114.48 203.66,115.69 203.66,121.25 205.63,123.21 206.26,123.21 209.37,126.33 210.71,126.33 212.99,128.61 212.99,131.91 213.86,132.78 217.01,132.78 v2(217.41,133.18)
  BOTTOM w0.089: UG4.E4 217.81,132.78 v2(217.41,133.18)
  BOTTOM w0.17: UG9.P47 v2(205.2,112.15)
FBB_D37: length 24.3
  IN1 w0.145: v2(204.2,116.95) 204.67,117.42 204.67,121.12 206.01,122.45 206.52,122.45 209.56,125.5 210.9,125.5 213.76,128.36 213.76,131.28 214.45,131.98 215.41,131.98 v2(215.81,132.38)
  BOTTOM w0.089: UG4.E2 v2(215.81,132.38)
  BOTTOM w0.142: v2(204.2,116.95) 204.9,116.25 UG9.P52
FBB_D38: length 38.5
  IN1 w0.145: v2(217.41,133.98) 216.91,134.48 213.14,134.48 211.53,132.87 211.53,129.31 210.14,127.91 207.34,127.91 200.86,121.44 200.86,115.53 201.62,114.78 203.54,114.78 204.29,114.03 204.29,111.24 v2(203.9,110.85)
  BOTTOM w0.089: v2(217.41,133.98) 217.41,133.98 UG4.F4
  BOTTOM w0.17: UG9.R46 v2(203.9,110.85)
FBB_D39: length 32.5
  IN1 w0.145: v2(215.81,133.18) 215.41,133.58 213.39,133.58 212.23,132.42 212.23,128.93 210.52,127.21 208.29,127.21 202.96,121.88 202.96,115.85 204.6,114.21 204.6,112 v2(205.3,111.3)
  BOTTOM w0.089: UG4.F2 v2(215.81,133.18)
  BOTTOM w0.17: UG9.P46 205.05,111.3 v2(205.3,111.3)
FBB_D40: length 29.5
  IN3 w0.14: v2(223.81,129.18) 221.85,127.21 215.47,127.21 213.63,125.37 209.75,125.37 207.59,123.21 207.59,119.53 207.02,118.96 207.02,116.88 207.1,116.8 v2(207.9,116)
  BOTTOM w0.089: UG4.A11 223.41,129.58 v2(223.81,129.18)
  BOTTOM w0.102: 207.35,114.8 207.35,114.53 207,114.18 UG9.L50
  BOTTOM w0.142: v2(207.9,116) 207.6,115.7 207.6,115.05 207.35,114.8
FBB_D41: length 30.3
  IN3 w0.14: v2(207.95,116.6) 208.1,116.45 208.69,116.45 209.56,117.32 209.56,118.34 209.84,118.62 209.84,122.35 210.58,123.09 215.46,123.09 216.6,124.23 222.9,124.23 225.69,127.02 225.69,128.9 v2(225.41,129.18)
  BOTTOM w0.089: UG4.A13 225.01,129.58 v2(225.41,129.18)
  BOTTOM w0.142: UG9.L51 207,114.81 207.34,115.15 207.34,116.34 207.6,116.6 v2(207.95,116.6)
FBB_D42: length 29.4
  IN3 w0.089: 224.23,128.39 224.23,129.56 v2(223.81,129.98)
  IN3 w0.14: 224.23,128.39 224.23,128.04 222.58,126.39 216.74,126.39 214.96,124.61 209.95,124.61 208.29,122.96 208.29,119.79 207.34,118.83 207.34,117.67 v2(207.85,117.16)
  BOTTOM w0.089: UG4.B11 223.41,130.38 v2(223.81,129.98)
  BOTTOM w0.142: UG9.L52 207,116.57 207.59,117.16 v2(207.85,117.16)
FBB_D43: length 32.7
  IN3 w0.089: 224.99,128.39 224.99,129.56 v2(225.41,129.98)
  IN3 w0.14: 224.99,128.39 224.99,127.53 223.09,125.63 217.04,125.63 215.13,123.72 210.14,123.72 208.99,122.58 208.99,118.39 208.65,118.05 208.15,118.05 207.9,118.3 v2(207.9,118.39)
  BOTTOM w0.089: v2(225.41,129.98) 225.01,130.38 UG4.B13
  BOTTOM w0.142: v2(207.9,118.39) 207.86,118.39 206.72,117.25 206.72,115.57 206.66,115.51 206.66,113.59 UG9.L49
FBB_D44: length 39.5
  IN3 w0.14: v2(205.88,110.03) 206.66,110.81 206.66,114.69 205.82,115.53 205.82,118.13 206.07,118.39 206.07,121.25 205.69,121.63 205.69,123.66 208.8,126.77 212.74,126.77 214.64,128.68 217.95,128.68 220.04,130.77 220.04,131.33 221.48,132.77 223.42,132.77 v2(223.81,132.38)
  BOTTOM w0.089: UG4.E11 223.41,132.78 v2(223.81,132.38)
  BOTTOM w0.1: UG9.M46 206.67,110.78 206.67,110.2 206.57,110.1 205.95,110.1 v2(205.88,110.03)
FBB_D45: length 36.1
  IN3 w0.14: v2(225.41,133.18) UG4.E13 225.01,132.23 224.75,131.97 222.13,131.97 218.2,128.04 215.15,128.04 213.18,126.07 209.31,126.07 206.52,123.28 206.52,121.75 206.77,121.5 206.77,116.57 207.37,115.97 207.37,114.88 207.01,114.51 207.01,112.44 v2(207.3,112.15)
  BOTTOM w0.089: UG4.E13 v2(225.41,133.18)
  BOTTOM w0.17: UG9.L47 v2(207.3,112.15)
FBB_D46: length 37.5
  IN3 w0.14: v2(205.89,112.82) 206.3,113.23 206.3,114.2 205.25,115.25 205.25,121.12 204.99,121.37 204.99,123.91 208.61,127.53 211.64,127.53 214.62,130.52 214.62,133.34 214.85,133.57 223.42,133.57 v2(223.81,133.18)
  BOTTOM w0.089: UG4.F11 223.41,133.58 v2(223.81,133.18)
  BOTTOM w0.17: UG9.M48 206.03,112.82 v2(205.89,112.82)
FBB_D47: length 42
  IN3 w0.14: v2(206,111.55) 205.8,111.75 205.04,111.75 204.67,112.12 204.67,120.86 204.23,121.31 204.23,124.04 208.42,128.23 211.29,128.23 214.08,131.02 214.08,133.89 214.57,134.38 225.01,134.38 v2(225.41,133.98)
  BOTTOM w0.089: UG4.F13 v2(225.41,133.98)
  BOTTOM w0.17: UG9.M47 v2(206,111.55)
FBB_D48: length 51.5
  IN5 w0.145: v2(211.6,112.25) 212.8,112.25 213.2,111.85 215.03,111.85 232.56,129.38 232.56,139.56 227.59,144.53 224.89,144.53 223.77,143.41 223.77,142.82 v2(223.81,142.78)
  BOTTOM w0.089: UG4.U11 v2(223.81,142.78)
  BOTTOM w0.11: UG9.D48 v2(211.6,112.25)
FBB_D49: length 40.6
  IN5 w0.145: v2(225.41,142.78) 225.81,142.38 226.91,142.38 227.73,141.57 227.73,141.02 230.6,138.14 230.6,130.66 214.39,114.45 214.05,114.45 213.85,114.65 213.3,114.65 v2(212.9,114.25)
  BOTTOM w0.089: UG4.U13 v2(225.41,142.78)
  BOTTOM w0.178: UG9.C50 v2(212.9,114.25)
FBB_D50: length 48
  IN5 w0.145: v2(223.81,141.98) 224.21,142.38 224.21,142.93 225.16,143.88 227.29,143.88 231.91,139.26 231.91,129.75 214.51,112.35 213.4,112.35 v2(212.9,112.85)
  BOTTOM w0.089: UG4.T11 v2(223.81,141.98)
  BOTTOM w0.17: UG9.C48 v2(212.9,112.85)
FBB_D51: length 44.6
  IN5 w0.145: v2(225.41,141.98) 225.01,142.38 225.01,143.03 225.21,143.23 227.02,143.23 231.25,138.99 231.25,130.11 214.4,113.25 213.2,113.25 v2(212.9,113.55)
  BOTTOM w0.089: UG4.T13 v2(225.41,141.98)
  BOTTOM w0.17: UG9.C49 v2(212.9,113.55)
FBB_D52: length 39.7
  IN5 w0.145: v2(223.81,139.58) 224.22,139.17 224.22,138.62 224.45,138.39 226.9,138.39 228.17,137.12 228.17,130.64 225.62,128.1 223.41,128.1 210.77,115.46 210.77,114.52 211.04,114.25 211.04,113.41 v2(211.5,112.95)
  BOTTOM w0.089: UG4.N11 v2(223.81,139.58)
  BOTTOM w0.11: UG9.E49 v2(211.5,112.95)
FBB_D53: length 38
  IN5 w0.145: v2(225.41,139.58) 225.82,139.17 227.9,139.17 228.87,138.2 228.87,130.39 225.88,127.41 224.71,127.41 212.66,115.36 211.3,115.36 211.02,115.08 211.02,114.73 v2(211.5,114.25)
  BOTTOM w0.089: UG4.N13 v2(225.41,139.58)
  BOTTOM w0.178: UG9.E50 v2(211.5,114.25)
FBB_D54: length 36.3
  IN5 w0.145: v2(223.81,138.78) 223.41,139.18 220.64,139.18 219.6,138.14 219.6,126.22 208.99,115.61 208.99,113.57 209.31,113.25 209.7,113.25 v2(210.1,112.85)
  BOTTOM w0.089: UG4.M11 v2(223.81,138.78)
  BOTTOM w0.17: UG9.F49 v2(210.1,112.85)
FBB_D55: length 35.7
  IN5 w0.145: v2(225.41,137.98) 224.87,137.44 221.44,137.44 220.36,136.36 220.36,126.01 211.09,116.73 210.64,116.73 210.04,116.13 210.04,114.74 210.5,114.28 UG9.F48 v2(210.2,112.25)
  BOTTOM w0.089: v2(225.41,137.98) 225.01,138.38 UG4.M13
  BOTTOM w0.17: v2(210.2,112.25) UG9.F48
FBB_D56: length 40.7
  IN1 w0.145: v2(218.21,141.98) 218.62,142.39 222.35,142.39 222.62,142.12 222.62,135.51 221.98,134.87 221.98,128.83 222.65,128.17 222.65,126.33 213.67,117.35 212.54,117.35 211.75,116.56 211.75,115.8 210.94,114.99 210.94,114.39 210.2,113.65 v2(210.1,113.65)
  BOTTOM w0.089: UG4.U4 v2(218.21,141.98)
  BOTTOM w0.178: UG9.F50 210.4,113.95 v2(210.1,113.65)
FBB_D57: length 42.9
  IN1 w0.145: v2(216.61,141.98) 217.85,143.22 223.92,143.22 224.2,142.94 224.2,138.14 223.15,137.09 223.15,135.15 222.58,134.58 222.58,128.99 223.28,128.29 223.28,125.95 214.09,116.76 212.67,116.76 v2(212.36,116.45)
  BOTTOM w0.089: UG4.U2 v2(216.61,141.98)
  BOTTOM w0.142: UG9.D52 211.85,115.4 211.85,115.97 212.32,116.45 v2(212.36,116.45)
FBB_D58: length 35.5
  IN1 w0.145: v2(218.21,141.18) 218.61,140.78 220.66,140.78 220.87,140.57 220.87,127.02 v2(208.1,114.25)
  BOTTOM w0.089: v2(218.21,141.18) 217.81,141.58 UG4.T4
  BOTTOM w0.178: UG9.J50 v2(208.1,114.25)
FBB_D59: length 41
  IN1 w0.145: v2(209.4,112.85) 209.05,113.2 209.05,114 210.15,115.1 210.29,115.1 211.01,115.82 211.01,116.47 212.49,117.94 212.99,117.94 221.88,126.83 221.88,128.23 221.44,128.68 221.44,140.74 220.6,141.58 UG4.T2 v2(215.81,141.98)
  BOTTOM w0.089: UG4.T2 v2(215.81,141.98)
  BOTTOM w0.178: UG9.H48 v2(209.4,112.85)
FBB_D60: length 32.7
  IN1 w0.145: v2(210.02,117.42) 210.03,117.41 210.77,117.41 211.85,118.49 211.85,119 220.3,127.44 220.3,135.71 219.7,136.31 219.7,138.75 219.23,139.22 218.1,139.22 217.66,138.78 v2(217.41,138.78)
  BOTTOM w0.089: UG4.N4 v2(217.41,138.78)
  BOTTOM w0.142: UG9.H51 209.1,114.8 209.74,115.44 209.74,116.3 209.85,116.41 209.85,117.25 v2(210.02,117.42)
FBB_D61: length 32.6
  IN1 w0.129: v2(208,115.05) 208.2,115.05 208.98,115.82 208.98,116.66 209.11,116.8
  IN1 w0.145: v2(216.61,138.78) 216.61,138.48 216.71,138.38 218.38,138.38 218.61,138.15 218.61,137.58 219.03,137.16 219.03,135.99 219.76,135.26 219.76,129.35 219.66,129.25 219.66,127.73 211.27,119.34 210.54,119.34 209.56,118.36 209.56,117.25 209.11,116.8
  BOTTOM w0.089: UG4.N2 v2(216.61,138.78)
  BOTTOM w0.178: UG9.J51 v2(208,115.05)
FBB_D62: length 31.3
  IN1 w0.145: v2(208.53,117.63) 208.99,118.09 208.99,118.73 210.24,119.98 211.03,119.98 218.96,127.91 218.96,129.25 219.11,129.39 219.11,134.74 218.16,135.69 218.16,137.08 217.41,137.83 v2(217.41,137.98)
  BOTTOM w0.089: UG4.M4 v2(217.41,137.98)
  BOTTOM w0.142: v2(208.53,117.63) 209,117.16 209,115.85 208.75,115.6 208.75,113.6 UG9.H49
FBB_D63: length 31
  IN1 w0.145: v2(215.81,138.78) UG4.M2 216.21,135.33 216.36,135.18 217.66,135.18 218.6,134.24 218.6,129.59 218.39,129.37 218.39,128.23 210.77,120.61 210.08,120.61 208.53,119.06 208.53,118.51 v2(208.48,118.46)
  BOTTOM w0.089: UG4.M2 v2(215.81,138.78)
  BOTTOM w0.142: v2(208.48,118.46) 208.5,118.46 209.34,117.62 209.34,115.59 UG9.H52
FBB_DBI0: length 25.3
  IN2 w0.145: v2(232.28,109.97) 231.88,109.57 231.88,108.4 230.79,107.32 222.24,107.32 217.48,102.56 217.48,102.17 216.7,101.39 v2(216.7,101.3)
  BOTTOM w0.089: UG3.P2 232.68,110.37 v2(232.28,109.97)
  BOTTOM w0.102: 215.02,100.85 214.84,100.67 213.81,100.67 213.48,101 212.95,101 UG9.C32
  BOTTOM w0.142: 215.02,100.85 216.25,100.85 216.7,101.3 v2(216.7,101.3)
FBB_DBI1: length 30.8
  IN2 w0.145: v2(211.5,102.45) 212.17,103.12 213.87,103.12 224.76,114.01 229.82,114.01 231.89,116.07 231.89,119.18 v2(232.28,119.57)
  BOTTOM w0.089: UG3.P13 v2(232.28,119.57)
  BOTTOM w0.1: UG9.E33 211.2,102.15 v2(211.5,102.45)
FBB_DBI2: length 41.7
  IN2 w0.145: v2(241.08,119.57) 240.68,119.97 240.68,122.13 238.39,124.42 225.38,124.42 217.05,116.1 217.05,113.25 213.39,109.59 211.64,109.59 v2(211.5,109.45)
  BOTTOM w0.089: UG3.D13 v2(241.08,119.57)
  BOTTOM w0.178: UG9.E44 v2(211.5,109.45)
FBB_DBI3: length 51.8
  IN2 w0.145: v2(240.28,109.97) 241.28,109.97 241.48,110.17 241.48,114.16 240.68,114.96 240.23,114.96 239.08,116.11 239.08,121.45 237.44,123.09 228.29,123.09 213.43,108.23 211.03,108.23 v2(209.98,107.18)
  BOTTOM w0.089: UG3.D2 240.68,110.37 v2(240.28,109.97)
  BOTTOM w0.102: v2(209.98,107.18) 209.8,107 UG9.G39
FBB_DBI4: length 26.1
  IN2 w0.145: v2(204.2,116.35) 205.78,117.93 205.78,119.49 207.68,121.39 207.68,124.7 212.61,129.63 214.83,129.63 215.57,130.37 216.03,130.37 216.22,130.57 216.22,131.2 216.59,131.58 v2(216.61,131.58)
  BOTTOM w0.089: UG4.D2 v2(216.61,131.58)
  BOTTOM w0.142: UG9.P49 204.55,113.6 204.55,115.48 204.65,115.58 204.65,116.13 204.43,116.35 v2(204.2,116.35)
FBB_DBI5: length 31.5
  IN2 w0.145: v2(207.4,113.65) 207.13,113.92 207.13,114.74 207.85,115.46 208.56,115.46 208.91,115.81 208.91,116.1 209.79,116.98 210.39,116.98 211.98,118.57 211.98,122.26 215.41,125.69 218.33,125.69 221.57,128.93 221.57,130.39 222.35,131.17 225.01,131.17 v2(225.41,131.58)
  BOTTOM w0.089: UG4.D13 225.01,131.98 v2(225.41,131.58)
  BOTTOM w0.1: v2(207.4,113.65) 207.33,113.58 207.33,113.12 207,112.79 UG9.L48
FBB_DBI6: length 38.7
  IN2 w0.145: v2(225.41,140.38) 225.81,139.98 226.65,139.98 228.04,138.58 228.04,128.55 226.2,126.71 224.05,126.71 212.72,115.38 211.36,115.38 211.03,115.05 211.03,114.13 211.51,113.65 v2(211.6,113.65)
  BOTTOM w0.089: UG4.P13 v2(225.41,140.38)
  BOTTOM w0.178: UG9.D50 v2(211.6,113.65)
FBB_DBI7: length 37.2
  IN2 w0.145: v2(210.39,118.51) 209.25,119.66 209.25,122.52 213.82,127.09 217.69,127.09 219.6,128.99 219.6,138.9 219.33,139.17 216.22,139.17 v2(215.81,139.58)
  BOTTOM w0.089: UG4.P2 v2(215.81,139.58)
  BOTTOM w0.142: UG9.H50 209.45,114.3 209.45,114.8 210.1,115.44 210.1,116.23 210.45,116.59 210.45,118.45 v2(210.39,118.51)
FBB_EDC0: length 23.6
  IN2 w0.145: v2(231.47,110.77) 231.08,110.38 231.08,108.75 230.6,108.27 222.05,108.27 216.36,102.58 v2(216.36,102.32)
  BOTTOM w0.089: UG3.R2 231.87,110.37 v2(231.47,110.77)
  BOTTOM w0.142: v2(216.36,102.32) 216.17,102.51 213.76,102.51 UG9.B33
FBB_EDC1: length 29.3
  IN2 w0.145: v2(231.48,118.77) 231.08,118.37 231.08,116.22 229.69,114.83 224.37,114.83 213.08,103.54 211.29,103.54 v2(210.9,103.15)
  BOTTOM w0.089: UG3.R13 v2(231.48,118.77)
  BOTTOM w0.1: UG9.E35 v2(210.9,103.15)
FBB_EDC2: length 47.3
  IN2 w0.145: v2(241.88,118.77) 241.48,119.16 241.48,122.54 238.9,125.12 224.61,125.12 216.29,116.8 216.29,113.88 212.47,110.06 209.99,110.06 209.67,109.74 209.09,109.74 v2(208.91,109.56)
  BOTTOM w0.089: v2(241.88,118.77) 241.48,119.17 UG3.C13
  BOTTOM w0.178: v2(208.91,109.56) 209.1,109.75 UG9.G44
FBB_EDC3: length 50.2
  IN2 w0.145: v2(208.8,105.25) 208.8,105.1 209.01,104.89 209.01,104.25 209.21,104.05 212.78,104.05 213.33,104.6 213.33,105.46 229.12,121.25 236.03,121.25 237.47,119.81 237.47,115.18 239.08,113.57 239.08,111.35 239.27,111.16 240.68,111.16 v2(241.08,110.77)
  BOTTOM w0.089: UG3.C2 v2(241.08,110.77)
  BOTTOM w0.178: UG9.H38 v2(208.8,105.25)
FBB_EDC4: length 25
  IN2 w0.145: v2(215.81,130.78) 215.6,130.78 215.15,130.33 212.36,130.33 206.59,124.56 206.59,121.5 204.89,119.8 204.89,118.35 204.67,118.12 v2(204.2,118.12)
  BOTTOM w0.089: UG4.C2 v2(215.81,130.78)
  BOTTOM w0.142: 205.41,116.91 205.41,115.75 205.44,115.72 205.44,115.04 205.26,114.86 205.26,114.31 UG9.P50
  BOTTOM w0.178: 205.41,116.91 v2(204.2,118.12)
FBB_EDC5: length 26.9
  IN2 w0.145: v2(224.61,130.78) 224.2,130.37 222.62,130.37 222.26,130.01 222.26,128.8 221.82,128.36 221.82,128.12 213.06,119.36 213.06,118.83 210.64,116.42 210.33,116.42 209.69,115.78 209.69,115.6 208.56,114.47 208.56,114.08 208.37,113.89 208.37,113.12 v2(208.1,112.85)
  BOTTOM w0.089: UG4.C13 v2(224.61,130.78)
  BOTTOM w0.178: UG9.J48 v2(208.1,112.85)
FBB_EDC6: length 40.4
  IN2 w0.145: v2(224.61,141.18) 225.01,140.78 226.8,140.78 228.8,138.77 228.8,127.98 226.71,125.88 224.3,125.88 215.28,116.86 215.28,115.04 214.77,114.53 213.99,114.53 213.88,114.64 212.66,114.64 212.35,114.95 v2(212.2,114.95)
  BOTTOM w0.089: v2(224.61,141.18) 225.01,140.78 UG4.R13
  BOTTOM w0.178: UG9.D51 v2(212.2,114.95)
FBB_EDC7: length 35.3
  IN2 w0.145: v2(211.34,118.55) 211.34,119.39 210.99,119.74 210.99,122.54 214.97,126.52 218.14,126.52 220.17,128.55 220.17,139.09 219.73,139.53 218.14,139.53 217.69,139.98 216.99,139.98 216.61,140.36 v2(216.61,140.38)
  BOTTOM w0.089: UG4.R2 v2(216.61,140.38)
  BOTTOM w0.142: UG9.F51 210.85,115 210.85,115.65
  BOTTOM w0.178: v2(211.34,118.55) 211.34,118 211.04,117.7 211.04,115.84 210.85,115.65
FBB_WCK01: length 31.5
  IN2 w0.119: v2(208.1,102.35) 208.24,102.35 208.39,102.2 208.39,101.89 208.76,101.52 213.01,101.52 214.02,102.53 215.05,102.53 225.52,113 232.35,113 232.54,112.81 232.54,112.6 v2(232.29,112.35)
  BOTTOM w0.089: UG3.P4 232.68,112.04 232.36,112.35 v2(232.29,112.35)
  BOTTOM w0.119: UG9.J33 208.4,102.22 208.27,102.35 v2(208.1,102.35)
FBB_WCK01#: length 31.3
  IN2 w0.119: v2(208.8,102.35) 208.6,102.15 208.6,101.97 208.85,101.73 212.93,101.73 213.93,102.74 214.96,102.74 225.44,113.21 232.44,113.21 232.75,112.9 232.75,112.6 232.94,112.4 v2(233.04,112.4)
  BOTTOM w0.089: v2(233.04,112.4) 232.89,112.4 232.68,112.61 UG3.P5
  BOTTOM w0.119: UG9.H33 v2(208.8,102.35)
FBB_WCK23: length 48
  IN2 w0.102: v2(240.32,112.38) 240.27,112.38 239.85,112.79 239.85,113.49
  IN2 w0.119: v2(208.1,106.55) 208.26,106.55 208.39,106.42 208.39,106.15 208.75,105.79 212.6,105.79 228.66,121.86 237.04,121.86 238.07,120.83 238.07,115.28 239.85,113.49
  BOTTOM w0.089: v2(240.32,112.38) 240.32,112.33 240.68,111.97 UG3.D4
  BOTTOM w0.119: UG9.J39 208.4,106.42 208.27,106.55 v2(208.1,106.55)
FBB_WCK23#: length 48.1
  IN2 w0.102: 240,113.64 240.01,113.63 240.01,113.62 240.05,113.58 240.05,113.41 240.04,113.4 240.04,112.87 240.16,112.76 240.28,112.76 240.42,112.9 240.42,113.17 v2(240.5,113.24)
  IN2 w0.119: v2(208.8,106.55) 208.6,106.35 208.6,106.24 208.84,106 212.51,106 228.58,122.07 237.12,122.07 238.28,120.92 238.28,115.37 240,113.64
  BOTTOM w0.089: v2(240.5,113.24) 240.43,113.17 240.43,112.88 240.54,112.77 UG3.D5
  BOTTOM w0.119: UG9.H39 v2(208.8,106.55)
FBB_WCK45: length 32.6
  IN2 w0.119: v2(207.3,110.85) 206.89,110.85 206.76,110.98 206.76,115.04 207.22,115.5 207.22,119.6 208.48,120.86 208.48,123.79 212.33,127.63 216.98,127.63 218.99,129.64 218.99,132.54 218.73,132.8 218.22,132.8 217.8,132.38 v2(217.53,132.38)
  BOTTOM w0.089: UG4.D4 217.81,132.1 v2(217.53,132.38)
  BOTTOM w0.119: UG9.L46 v2(207.3,110.85)
FBB_WCK45#: length 32.5
  IN2 w0.119: v2(218.21,132.26) 218.21,132.47 218.34,132.59 218.65,132.59 218.78,132.46 218.78,129.73 216.89,127.83 212.24,127.83 208.28,123.87 208.28,120.95 207.02,119.69 207.02,115.58 206.55,115.12 206.55,110.89 206.8,110.64 206.97,110.64 207.3,110.32 v2(207.3,110.15)
  BOTTOM w0.089: UG4.D5 218.34,131.98 218.21,132.1 v2(218.21,132.26)
  BOTTOM w0.119: v2(207.3,110.15) 207.3,110.31 207.16,110.45 UG9.L45
FBB_WCK67: length 46.7
  IN2 w0.119: v2(209.5,112.25) 209.34,112.09 209.15,112.09 208.93,112.3 208.93,113.74 210.41,115.21 210.77,115.21 211.59,116.03 211.59,116.3 223.07,127.79 225.99,127.79 227,128.8 227,135.56 225.1,137.46 221.65,137.46 220.89,138.22 220.89,140.09 220.17,140.8 218.75,140.8 v2(218.33,140.38)
  BOTTOM w0.089: v2(218.33,140.38) 217.93,139.98 UG4.P4
  BOTTOM w0.119: UG9.H47 v2(209.5,112.25)
FBB_WCK67#: length 46.6
  IN2 w0.119: v2(209.4,111.45) 209.4,111.75 209.27,111.88 209.06,111.88 208.72,112.22 208.72,113.83 210.32,115.42 210.68,115.42 211.38,116.11 211.38,116.39 222.98,127.99 225.9,127.99 226.79,128.88 226.79,135.48 225.02,137.25 221.57,137.25 220.68,138.14 220.68,140 220.09,140.59 218.88,140.59 218.77,140.48 218.77,140.3 218.9,140.18 v2(219.09,140.18)
  BOTTOM w0.089: UG4.P5 218.89,139.98 v2(219.09,140.18)
  BOTTOM w0.119: UG9.H46 v2(209.4,111.45)
FBC_CLK0: length 37.3
  TOP w0.119: RG124.1 235.17,86.69 235.17,86.32 234.92,86.08 v2(234.72,86.08)
  IN5 w0.119: v2(209.5,89.75) 209.67,89.75 210.07,89.35 212.72,89.35 213.05,89.67 219.16,89.67 221.31,87.53 223.62,87.53 224.49,86.65 225.78,86.65 225.9,86.53 225.9,85.59 226.14,85.35 226.67,85.35 226.91,85.59 226.91,86.53 227.03,86.65 228.85,86.65 228.97,86.53 228.97,86.16 229.21,85.92 229.74,85.92 229.98,86.16 229.98,86.53 230.1,86.65 235.15,86.65 235.28,86.53 235.28,86.35 235.15,86.22 234.86,86.22 v2(234.72,86.08) 234.86,85.94 235.09,85.94 235.27,85.76 235.27,85.14 234.46,84.33 234.46,84.01 234.36,83.91 v2(234.13,83.91)
  BOTTOM w0.089: UG5.J12 234.26,83.51 234.13,83.63 v2(234.13,83.91)
  BOTTOM w0.119: UG9.G15 v2(209.5,89.75)
FBC_CLK0#: length 37
  TOP w0.119: RG527.1 235.41,86.77 235.41,86.35 v2(235.68,86.08)
  IN5 w0.119: v2(210.05,89.9) 210.05,89.68 210.18,89.56 212.63,89.56 212.96,89.88 219.25,89.88 221.39,87.74 223.71,87.74 224.58,86.86 225.87,86.86 226.11,86.62 226.11,85.68 226.23,85.56 226.59,85.56 226.71,85.68 226.71,86.62 226.95,86.86 228.93,86.86 229.17,86.62 229.17,86.25 229.29,86.13 229.65,86.13 229.77,86.25 229.77,86.62 230.01,86.86 235.24,86.86 235.49,86.61 235.49,86.27 v2(235.68,86.08) 235.48,85.87 235.48,85.05 234.67,84.25 234.67,83.92 234.36,83.61 v2(234.36,83.11)
  BOTTOM w0.089: v2(234.36,83.11) 234.65,82.82 UG5.J11
  BOTTOM w0.119: UG9.F15 v2(210.05,89.9)
FBC_CLK1: length 36.3
  TOP w0.119: v2(235.04,92.28) 235.04,92.28 235.33,92 235.33,91.82 234.97,91.46 RG125.1
  IN1 w0.119: v2(234.14,94.74) 234.14,94.91 234.3,95.07 234.48,95.07 234.57,94.98 234.57,94.28 235.58,93.27 235.58,92.82 v2(235.04,92.28) 235.15,92.16 235.41,92.16 235.57,91.99 235.57,91.8 235.4,91.62 227.1,91.62 225.72,93.01 214.76,93.01 214.25,93.51 210.09,93.51 209.81,93.24 208.51,93.24 208.39,93.36 208.39,93.54 v2(208.8,93.96)
  BOTTOM w0.089: UG6.J12 234.32,95.15 234.14,94.97 v2(234.14,94.74)
  BOTTOM w0.119: UG9.H21 208.93,93.65 208.8,93.78 v2(208.8,93.96)
FBC_CLK1#: length 36
  TOP w0.119: RG528.1 235.62,91.76 235.62,92.2 v2(235.78,92.35)
  IN1 w0.119: v2(234.25,95.55) 234.3,95.55 234.78,95.07 234.78,94.37 235.78,93.36 235.78,92.36 v2(235.78,92.35) 235.78,91.71 235.48,91.41 227.02,91.41 225.63,92.8 214.67,92.8 214.16,93.31 210.17,93.31 209.89,93.03 208.38,93.03 208.18,93.23 208.18,93.87 v2(208.1,93.95)
  BOTTOM w0.089: v2(234.25,95.55) 234.65,95.95 UG6.J11
  BOTTOM w0.119: UG9.J21 v2(208.1,93.95)
FBC_CMD0: length 35
  BOTTOM w0.142: 235.85,73.75 235.85,73.75 235.98,73.87 235.98,74.38 235.85,74.51 235.85,75.91 UG5.G3 ; UG9.C11 212.95,86.3 213.45,86.3 213.72,86.03 215.9,86.03 216.45,85.47 216.45,84.41
  BOTTOM w0.178: 216.45,84.41 217.12,83.74 217.12,80.77 225.57,72.31 231.92,72.31 232.43,72.83 234.93,72.83 235.85,73.75
FBC_CMD1: length 35.4
  TOP w0.089: v2(235.05,75.91) UG5.J3 234.65,76.92 234.51,77.06 RG51.2
  BOTTOM w0.142: 234.39,73.18 235.05,73.83 v2(235.05,75.91) UG5.J3 ; UG9.B11 213.45,86.65 213.8,86.3 216.02,86.3 216.75,85.58 216.75,84.86 217.13,84.48
  BOTTOM w0.178: 234.39,73.18 232.11,73.18 231.76,72.83 225.79,72.83 217.64,80.98 217.64,83.97 217.13,84.48
FBC_CMD2: length 34.5
  TOP w0.178: v2(234.25,75.11) 233.82,75.54 233.82,79.02 234.14,79.34 RG58.1
  BOTTOM w0.089: UG5.J2 234.65,75.51
  BOTTOM w0.142: 233.86,73.68 234.25,74.07 v2(234.25,75.11) 234.65,75.51 ; 217.2,85.2 217.2,85.51 216.06,86.65 UG9.A11
  BOTTOM w0.178: 217.2,85.2 218.16,84.24 218.16,81.2 226.01,73.35 231.71,73.35 231.92,73.56 233.74,73.56 233.86,73.68
FBC_CMD3: length 31.1
  BOTTOM w0.089: 233.05,76.3 UG5.L3
  BOTTOM w0.142: 233.05,76.3 233.4,75.94 233.4,74.47 232.81,73.87 ; UG9.D11 212.25,87 216.19,87 218.04,85.15
  BOTTOM w0.178: 218.04,85.15 218.68,84.5 218.68,81.41 226.22,73.87 232.81,73.87
FBC_CMD4: length 26.6
  BOTTOM w0.089: 233.85,77.98 UG5.K5
  BOTTOM w0.142: UG9.A12 216.57,87.35 ; 227.22,77.29 227.52,77.29 227.79,77.56 227.79,77.94 228.1,78.26 233.57,78.26 233.85,77.98
  BOTTOM w0.178: 227.22,77.29 223.54,77.29 219.2,81.63 219.2,84.72 216.57,87.35
FBC_CMD5: length 28.8
  BOTTOM w0.142: 227.19,77.82 227.93,78.56 234.02,78.56 234.2,78.38 234.2,77.56 233.85,77.2 UG5.K4 ; UG9.B12 213.5,87.35 213.85,87.7 216.86,87.7
  BOTTOM w0.178: 227.19,77.82 227.18,77.81 223.76,77.81 219.72,81.85 219.72,84.93 219,85.66 218.9,85.66 216.86,87.7
FBC_CMD6: length 29.1
  BOTTOM w0.142: UG9.C12 212.79,87.35 213.14,87.7 213.5,87.7 213.73,87.93 214.66,87.93 214.76,88.03 217.07,88.03 217.17,87.93 ; 227.22,78.36 227.31,78.36 227.81,78.87 234.23,78.87 234.65,78.45 UG5.J5
  BOTTOM w0.178: 227.22,78.36 223.95,78.36 220.25,82.06 220.25,85.15 219.37,86.03 219.08,86.03 217.17,87.93
FBC_CMD7: length 30.5
  BOTTOM w0.142: UG9.C14 212.95,88.4 213.45,88.4 213.68,88.17 214.47,88.17 214.6,88.29 217.36,88.29 217.49,88.17 ; UG5.J4 234.65,77.3 235.03,77.68 235.03,78.7 234.56,79.17 227.69,79.17 227.4,78.88 227.22,78.88
  BOTTOM w0.178: 227.22,78.88 224.16,78.88 220.77,82.28 220.77,85.37 219.63,86.5 219.15,86.5 217.49,88.17
FBC_CMD8: length 28.8
  BOTTOM w0.142: UG5.H5 235.45,78.92 234.91,79.45 227.27,79.45 227.22,79.4 ; 217.76,88.4 217.61,88.55 214.42,88.55 214.28,88.4 213.8,88.4 213.45,88.75 UG9.B14
  BOTTOM w0.178: 217.76,88.4 218.97,87.19 219.68,87.19 221.68,85.19 221.68,82.75 225.04,79.4 227.22,79.4
FBC_CMD9: length 29.5
  BOTTOM w0.142: 218.21,88.75 218.11,88.85 214.1,88.85 UG9.A14 ; UG5.H4 235.45,77.28 235.85,77.68 235.85,79.02 235.14,79.73 227.41,79.73 227.22,79.92
  BOTTOM w0.178: 218.21,88.75 219.23,87.73 219.87,87.73 222.2,85.4 222.2,82.97 225.25,79.92 227.22,79.92
FBC_CMD10: length 32.5
  BOTTOM w0.142: 227.13,80.44 227.55,80.02 235.14,80.02 235.85,80.73 235.85,83.02 236.25,83.41 UG5.G12 ; 218.51,89.1 212.25,89.1 UG9.D14
  BOTTOM w0.178: 227.13,80.44 225.47,80.44 222.72,83.19 222.72,85.62 220.09,88.25 219.36,88.25 218.51,89.1
FBC_CMD11: length 27.8
  BOTTOM w0.142: UG9.A15 218.65,89.45 ; UG5.H10 235.45,81.09 234.66,80.3 227.71,80.3 227.05,80.96
  BOTTOM w0.178: 227.05,80.96 225.68,80.96 223.24,83.4 223.24,85.83 220.31,88.77 219.33,88.77 218.65,89.45
FBC_CMD12: length 29.1
  BOTTOM w0.142: UG5.H11 235.45,82.61 235.09,82.26 235.09,81.24 234.44,80.59 227.83,80.59 226.94,81.48 ; UG9.B15 213.5,89.45 213.84,89.79 218.71,89.79
  BOTTOM w0.178: 218.71,89.79 219.21,89.29 220.52,89.29 223.76,86.05 223.76,83.62 225.9,81.48 226.94,81.48
FBC_CMD13: length 28.9
  BOTTOM w0.142: UG5.K11 234.2,82.35 234.2,81.24 233.85,80.89 227.95,80.89 226.84,82 ; 214.72,90.1 214.64,90.03 213.73,90.03 213.5,89.8 213.15,89.8 212.8,89.45 UG9.C15
  BOTTOM w0.178: 226.84,82 226.11,82 224.29,83.83 224.29,86.27 220.74,89.81 219.28,89.81 218.99,90.1 214.72,90.1
FBC_CMD14: length 27.3
  BOTTOM w0.102: 213.45,90.5 213.18,90.5 212.83,90.85 UG9.C17
  BOTTOM w0.142: 214.71,90.45 214.54,90.27 213.68,90.27 213.45,90.5 ; 226.72,82.52 228.07,81.18 233.44,81.18 233.85,81.58 UG5.K10
  BOTTOM w0.178: 214.71,90.45 219.21,90.45 219.32,90.33 220.95,90.33 224.81,86.48 224.81,84.05 226.33,82.52 226.72,82.52
FBC_CMD15: length 27.7
  BOTTOM w0.142: 214.55,90.85 214.2,90.51 213.79,90.51 213.45,90.85 UG9.B17 ; 226.61,83.05 228.16,81.49 233.15,81.49 233.44,81.79 233.44,83.02 233.05,83.41 UG5.L12
  BOTTOM w0.178: 214.55,90.85 221.17,90.85 225.33,86.7 225.33,84.33 226.61,83.05
FBC_CMD16: length 31.7
  BOTTOM w0.142: UG9.B24 213.5,95.75 213.85,96.1 217.16,96.1 ; UG6.L3 235.85,102.75 235.85,104.16
  BOTTOM w0.178: 235.85,104.16 236.04,104.35 236.04,105.37 235.85,105.56 235.85,105.56 234.9,106.51 227.17,106.51 220.18,99.53 219.22,99.53 218.09,98.4 218.09,97.03 217.16,96.1
FBC_CMD17: length 32.3
  TOP w0.089: RG52.2 235.98,103.69 v2(235.05,102.75)
  BOTTOM w0.142: 235.05,103.13 v2(235.05,102.75) UG6.J3
  BOTTOM w0.178: UG9.A24 217.34,95.75 218.61,97.01 218.61,98.06 219.56,99.01 220.4,99.01 227.38,105.99 234.35,105.99 235.05,105.3 235.05,103.13
FBC_CMD18: length 33.4
  TOP w0.178: RG57.1 234.43,107.15 234.01,106.73 234.01,104.86 234.14,104.74 234.14,103.66 v2(234.25,103.55)
  BOTTOM w0.142: 217.41,95.4 212.25,95.4 UG9.D23
  BOTTOM w0.178: 217.41,95.4 219.04,97.03 219.04,97.73 219.8,98.49 220.61,98.49 227.6,105.47 233.95,105.47 234.14,105.28 234.14,104.44 234.23,104.35 234.23,103.57 v2(234.25,103.55) 234.65,103.15 UG6.J2
FBC_CMD19: length 26
  BOTTOM w0.142: UG6.G3 233.05,102.44 233.39,102.78 233.39,104.13 ; UG9.A23 217.49,95.05
  BOTTOM w0.178: 217.49,95.05 219.46,97.02 219.46,97.41 220.02,97.97 220.83,97.97 227.81,104.95 232.56,104.95 233.39,104.13
FBC_CMD20: length 24.2
  BOTTOM w0.142: UG9.B23 213.45,95.05 213.8,94.7 217.17,94.7 217.24,94.76 217.64,94.76 ; 226.94,101.33 227.85,100.42 233.62,100.42 233.85,100.65 UG6.H5
  BOTTOM w0.178: 226.94,101.33 225.06,101.33 221.17,97.45 220.08,97.45 219.79,97.15 219.79,96.91 217.64,94.76
FBC_CMD21: length 26.2
  BOTTOM w0.142: 226.89,100.81 227.6,100.1 233.88,100.1 234.27,100.48 234.27,101.05 233.85,101.47 UG6.H4 ; UG9.C23 212.95,94.7 213.45,94.7 213.69,94.46 217.78,94.46
  BOTTOM w0.178: 217.78,94.46 220.25,96.93 221.39,96.93 225.28,100.81 226.89,100.81
FBC_CMD22: length 25.6
  BOTTOM w0.142: 217.93,94.2 214.37,94.2 214.35,94.22 213.72,94.22 213.5,94 213.11,94 212.76,93.65 UG9.C21 ; 226.87,100.29 227.34,99.82 234.11,99.82 234.65,100.35 UG6.J5
  BOTTOM w0.178: 217.93,94.2 220.13,96.4 221.6,96.4 225.49,100.29 226.87,100.29
FBC_CMD23: length 26.2
  BOTTOM w0.142: 226.96,99.77 227.19,99.54 234.28,99.54 235.09,100.35 235.09,101.12 234.66,101.55 UG6.J4 ; UG9.B21 213.52,93.65 213.85,93.99 214.16,93.99 214.24,93.9 218.09,93.9
  BOTTOM w0.178: 226.96,99.77 225.71,99.77 221.82,95.88 220.07,95.88 218.09,93.9
FBC_CMD24: length 24.7
  BOTTOM w0.142: UG9.A21 218.39,93.65 ; 226.96,99.25 234.5,99.25 235.45,100.2 UG6.K5
  BOTTOM w0.178: 226.96,99.25 225.92,99.25 222.04,95.36 220.11,95.36 218.39,93.65
FBC_CMD25: length 28.7
  BOTTOM w0.142: UG9.D20 212.25,93.3 215.24,93.3 215.34,93.2 ; UG6.K4 235.45,101.4 235.79,101.05 235.79,99.78 234.96,98.96 227.34,98.96 227.12,98.73
  BOTTOM w0.178: 227.12,98.73 226.14,98.73 222.25,94.84 220.07,94.84 218.42,93.2 215.34,93.2
FBC_CMD26: length 27.6
  BOTTOM w0.142: UG6.L12 235.79,95.61 235.79,98.07 235.18,98.68 227.51,98.68 227.04,98.21 ; 215.22,92.82 215.09,92.95 UG9.A20
  BOTTOM w0.178: 215.22,92.82 218.6,92.82 220.11,94.32 222.47,94.32 226.35,98.21 227.04,98.21
FBC_CMD27: length 26.1
  BOTTOM w0.142: 215.21,92.41 215.01,92.61 213.79,92.61 213.45,92.95 UG9.B20 ; UG6.K10 235.45,97.71 234.77,98.39 227.62,98.39 226.89,97.65
  BOTTOM w0.178: 226.89,97.65 226.53,97.65 222.68,93.8 220.12,93.8 218.73,92.41 215.21,92.41
FBC_CMD28: length 27.2
  BOTTOM w0.142: 219,92.11 214.95,92.11 214.7,92.37 213.68,92.37 213.45,92.6 212.95,92.6 UG9.C20 ; 226.75,97.13 226.77,97.13 227.71,98.07 234.46,98.07 235.09,97.43 235.09,96.35 235.45,96 UG6.K11
  BOTTOM w0.178: 219,92.11 220.17,93.28 222.9,93.28 226.75,97.13
FBC_CMD29: length 26.3
  BOTTOM w0.142: 226.65,96.29 226.65,96.54 227.85,97.75 233.76,97.75 234.2,97.31 234.2,96.29 233.86,95.95 UG6.H11 ; 214.69,91.85 214.4,92.13 213.73,92.13 213.5,91.9 213.1,91.9 212.75,91.55 UG9.C18
  BOTTOM w0.178: 226.65,96.29 223.12,92.76 220.22,92.76 219.31,91.85 214.69,91.85
FBC_CMD30: length 24.8
  BOTTOM w0.142: UG9.B18 213.5,91.55 213.85,91.9 214.18,91.9 214.52,91.56 ; UG6.H10 233.85,97.15 233.53,97.47 227.95,97.47 227.03,96.54 227.03,95.53
  BOTTOM w0.178: 227.03,95.53 227.03,94.87 224.4,92.24 220.22,92.24 219.54,91.56 214.52,91.56
FBC_CMD31: length 25.3
  BOTTOM w0.142: UG9.A18 214.33,91.22 219.65,91.22 ; 227.19,94.29 227.41,94.51 227.41,96.54 228.04,97.18 233.25,97.18 233.44,96.99 233.44,95.72 233.05,95.33 UG6.G12
  BOTTOM w0.178: 227.19,94.29 224.61,91.72 220.14,91.72 219.65,91.22
FBC_D0: length 19.5
  IN3 w0.14: v2(227.38,76.5) 224.4,76.5 218.9,82.01 216.8,82.01 216.44,82.37 214.79,82.37 214.55,82.61 213.18,82.61 v2(212.31,83.49)
  BOTTOM w0.089: v2(227.38,76.5) 227.99,77.11 UG5.U4
  BOTTOM w0.17: UG9.C6 212.31,83.44
  BOTTOM w0.178: 212.31,83.44 v2(212.31,83.49)
FBC_D1: length 19.8
  IN3 w0.14: v2(227.85,75.11) 227.56,75.4 226.39,75.4 225.95,75.84 224.04,75.84 218.58,81.3 216.8,81.3 216.2,81.91 v2(215.64,81.91)
  BOTTOM w0.089: v2(227.85,75.11) 228.24,75.51 UG5.U2
  BOTTOM w0.1: UG9.D6 212.26,82.79 214.12,82.79
  BOTTOM w0.15: v2(215.64,81.91) 214.76,82.79 214.12,82.79
FBC_D2: length 18.9
  IN3 w0.14: v2(214.82,83.49) 214.82,83.78 215.27,84.22 218.71,84.22 224.68,78.26 227.1,78.26 v2(228.65,76.71)
  BOTTOM w0.089: UG5.T4 v2(228.65,76.71)
  BOTTOM w0.142: UG9.A6 214.48,83.15 v2(214.82,83.49)
FBC_D3: length 20.1
  IN3 w0.14: v2(213.6,83.45) 214.09,82.96 214.64,82.96 214.9,82.7 219.28,82.7 224.55,77.43 227.31,77.43 228.1,76.64 228.1,76.45 228.26,76.29 228.26,75.5 v2(228.65,75.11)
  BOTTOM w0.089: UG5.T2 v2(228.65,75.11)
  BOTTOM w0.178: UG9.B6 v2(213.6,83.45)
FBC_D4: length 24.8
  IN3 w0.14: v2(231.85,76.71) 231.45,76.31 231.45,74.1 231.22,73.87 225.82,73.87 225.31,74.38 223.28,74.38 217.76,79.91 216.23,79.91 215.54,80.6 214.45,80.6 v2(213.6,81.45)
  BOTTOM w0.089: UG5.N4 231.45,77.11 v2(231.85,76.71)
  BOTTOM w0.178: v2(213.6,81.45) UG9.B4
FBC_D5: length 20.7
  IN3 w0.14: v2(215.15,81.12) 215.78,81.12 216.3,80.61 218.26,80.61 223.72,75.14 225.5,75.14 225.94,74.71 230.65,74.71 v2(231.05,75.11)
  BOTTOM w0.089: UG5.N2 v2(231.05,75.11)
  BOTTOM w0.1: v2(215.15,81.12) 214.53,81.75 UG9.A4
FBC_D6: length 28.1
  IN3 w0.14: v2(215.15,79.8) 215.15,79.23 215.93,78.45 217.25,78.45 222.77,72.92 224.55,72.92 224.99,72.48 232.11,72.48 233.15,73.51 233.15,76.21 v2(232.65,76.71)
  BOTTOM w0.089: v2(232.65,76.71) 232.25,77.11 UG5.M4
  BOTTOM w0.1: v2(215.15,79.8) 214.25,80.7 213.65,80.7 UG9.B3
FBC_D7: length 25.6
  IN3 w0.14: v2(231.85,75.11) 232.25,74.71 232.25,73.85 231.57,73.18 225.5,73.18 225.06,73.62 223.09,73.62 217.5,79.21 216.04,79.21 215.64,79.6 215.64,79.88 215.33,80.2 214.45,80.2 213.7,80.95 213.4,80.95 v2(212.9,81.45)
  BOTTOM w0.089: UG5.M2 232.24,75.51 v2(231.85,75.11)
  BOTTOM w0.17: UG9.C4 v2(212.9,81.45)
FBC_D8: length 18.2
  IN1 w0.089: v2(227.85,83.11) 227.81,83.15 227.19,83.15
  IN1 w0.145: 227.19,83.15 226.01,83.15 225.21,83.95 219.26,83.95 217.34,85.87 214.5,85.87 213.78,85.15 212.6,85.15 v2(212.2,85.55)
  BOTTOM w0.089: UG5.U11 v2(227.85,83.11)
  BOTTOM w0.178: UG9.D9 v2(212.2,85.55)
FBC_D9: length 17.1
  IN1 w0.145: v2(227.85,84.71) 219.56,84.71 217.73,86.54 213.89,86.54 v2(212.9,85.55)
  BOTTOM w0.089: UG5.U13 v2(227.85,84.71)
  BOTTOM w0.178: UG9.C9 v2(212.9,85.55)
FBC_D10: length 20.3
  IN1 w0.089: 227.19,82.38 227.92,82.38 v2(228.65,83.11)
  IN1 w0.145: v2(211.35,85.68) 212.29,84.74 214.49,84.74 214.65,84.9 216.14,84.9 216.3,85.05 217.22,85.05 219.14,83.13 224.44,83.13 225.19,82.38 227.19,82.38
  BOTTOM w0.089: UG5.T11 v2(228.65,83.11)
  BOTTOM w0.178: v2(211.35,85.68) 211.2,85.53 UG9.E9
FBC_D11: length 17.2
  IN2 w0.145: v2(214.67,85.32) 215.1,85.75 216.73,85.75 217.81,84.67 226.97,84.67 227.32,84.31 228.25,84.31 v2(228.65,84.71)
  BOTTOM w0.089: UG5.T13 v2(228.65,84.71)
  BOTTOM w0.142: v2(214.67,85.32) 214.66,85.32 214.23,84.89 213.66,84.89 UG9.B9
FBC_D12: length 21.8
  IN1 w0.1: 230.65,81.8 230.65,82.51
  IN1 w0.129: 230.65,82.51 231.05,82.91 v2(231.05,83.11) ; v2(215.68,83.18) 216.29,82.58 216.78,82.58 ; 230.65,81.8 229.07,80.22 227.22,80.22
  IN1 w0.145: 216.78,82.58 219.13,80.22 227.22,80.22
  BOTTOM w0.089: UG5.N11 v2(231.05,83.11)
  BOTTOM w0.142: UG9.B8 213.43,84.55 213.8,84.18 214.68,84.18 v2(215.68,83.18)
FBC_D13: length 21.7
  IN1 w0.1: 230.65,84.31 230.65,82.91 ; 230.45,82.71 230.05,82.71 ; 229.85,82.51 229.85,82.01
  IN1 w0.129: 230.05,82.71 229.85,82.51 ; 227.28,80.99 228.83,80.99 229.85,82.01 ; v2(231.05,84.71) 230.65,84.31 ; 216.53,83.76 v2(216.33,83.76) ; 230.65,82.91 230.45,82.71
  IN1 w0.145: 227.28,80.99 219.3,80.99 218.1,82.19 216.53,83.76
  BOTTOM w0.089: UG5.N13 v2(231.05,84.71)
  BOTTOM w0.178: v2(216.33,83.76) 215.53,84.55 UG9.A8
FBC_D14: length 27.1
  IN1 w0.1: UG5.M11 232.25,81.95
  IN1 w0.129: 227.22,78.76 229.46,78.76 232.25,81.55 232.25,81.95 ; v2(231.85,83.11) UG5.M11
  IN1 w0.145: v2(210.8,82.85) 211.11,82.54 214.49,82.54 214.78,82.24 214.78,82.04 215.54,81.29 218.06,78.76 227.22,78.76
  BOTTOM w0.089: UG5.M11 v2(231.85,83.11)
  BOTTOM w0.17: UG9.F6 v2(210.8,82.85)
FBC_D15: length 27.3
  IN1 w0.1: 231.45,84.31 231.45,81.68
  IN1 w0.129: 227.22,79.46 229.23,79.46 231.45,81.68 ; v2(231.85,84.71) 231.45,84.31
  IN1 w0.145: 227.22,79.46 218.69,79.46 215.11,83.04 211.31,83.04 v2(210.9,83.45)
  BOTTOM w0.089: UG5.M13 v2(231.85,84.71)
  BOTTOM w0.17: v2(210.9,83.45) UG9.E6
FBC_D16: length 44.1
  IN1 w0.1: 210.41,92.92 210.41,92.26
  IN1 w0.129: 210.41,92.26 v2(210.1,91.95) ; v2(241.45,82.31) 242.14,83
  IN1 w0.145: 210.41,92.92 210.57,93.08 211.06,93.08 211.25,92.89 213.79,92.89 214.58,92.1 225.25,92.1 226.48,90.87 241.33,90.87 242.97,89.24 242.97,83.59 242.46,83.08 242.22,83.08 242.14,83
  BOTTOM w0.089: v2(241.45,82.31) 241.05,82.71 UG5.A11
  BOTTOM w0.178: UG9.F18 v2(210.1,91.95)
FBC_D17: length 37.5
  IN1 w0.129: v2(241.45,84.71) 241.57,84.83 241.57,86.38
  IN1 w0.145: v2(209.5,91.85) 209.94,91.41 213.54,91.41 214.31,90.64 222.01,90.64 223.03,89.62 239.03,89.62 241.57,87.09 241.57,86.38
  BOTTOM w0.089: UG5.A13 241.05,84.31 v2(241.45,84.71)
  BOTTOM w0.17: v2(209.5,91.85) UG9.G18
FBC_D18: length 40.3
  IN1 w0.1: 241.05,82.71 241.05,83.28 241.28,83.51 241.65,83.51
  IN1 w0.129: 241.05,82.71 v2(240.65,82.31) ; 241.65,83.51 241.71,83.51 241.84,83.64 241.84,83.79 242.14,84.09 242.14,86.02
  IN1 w0.145: 242.14,86.02 242.14,87.91 239.73,90.32 226.01,90.32 224.93,91.4 214.43,91.4 213.89,91.94 213.56,91.94 212.95,92.55 212.2,92.55 v2(211.5,91.85)
  BOTTOM w0.089: UG5.B11 240.25,82.71 v2(240.65,82.31)
  BOTTOM w0.178: UG9.E18 v2(211.5,91.85)
FBC_D19: length 38.6
  IN1 w0.1: 241.05,84.31 241.05,85.89
  IN1 w0.129: v2(240.65,83.91) 241.05,84.31 ; 241.05,85.89 240.55,86.38
  IN1 w0.145: v2(208.63,92.02) 209.69,90.96 213.07,90.96 214.15,89.88 221.25,89.88 222.2,88.92 238.39,88.92 240.43,86.89 240.43,86.51 240.55,86.38
  BOTTOM w0.089: UG5.B13 240.25,84.31 v2(240.65,83.91)
  BOTTOM w0.178: UG9.H18 v2(208.63,92.02)
FBC_D20: length 32.9
  IN1 w0.1: 238.65,87.01 238.65,83.51
  IN1 w0.129: 238.65,83.51 v2(238.25,83.11)
  IN1 w0.145: 238.65,87.01 237.43,88.23 221.5,88.23 220.63,89.1 213.94,89.1 213.23,89.81 212.55,89.81 v2(212.37,89.99)
  BOTTOM w0.089: v2(238.25,83.11) 237.85,82.71 UG5.E11
  BOTTOM w0.17: UG9.D15 211.9,89.47 212.37,89.94 v2(212.37,89.99)
FBC_D21: length 32.4
  IN1 w0.1: 237.85,84.31 237.85,86.38
  IN1 w0.129: v2(237.45,83.91) 237.85,84.31
  IN1 w0.145: 237.85,86.38 237.85,86.87 237.19,87.53 220.87,87.53 219.89,88.51 213.95,88.51 213.11,89.35 212.2,89.35 212.02,89.53 211.39,89.53 v2(210.97,89.95)
  BOTTOM w0.089: v2(237.45,83.91) 237.85,84.31 UG5.E13
  BOTTOM w0.17: v2(210.97,89.95) 210.97,89.68 UG9.E15
FBC_D22: length 33.4
  IN1 w0.1: 237.05,85.9 237.05,83.51
  IN1 w0.129: 237.05,83.51 v2(237.45,83.11)
  IN1 w0.145: v2(210.1,90.48) 210.1,90.45 210.44,90.11 210.44,89.83 211.12,89.15 211.76,89.15 212.04,88.87 213.01,88.87 214.02,87.86 219.46,87.86 220.49,86.83 236.68,86.83 237.05,86.46 237.05,85.9
  BOTTOM w0.089: v2(237.45,83.11) 237.05,82.71 UG5.F11
  BOTTOM w0.178: v2(210.1,90.48) 210.07,90.48 209.8,90.75 UG9.G17
FBC_D23: length 31.7
  IN1 w0.145: v2(208.8,90.55) 209.1,90.25 209.1,89.54 209.74,88.9 210.4,88.9 210.55,88.75 211.57,88.75 212,88.32 213.01,88.32 214.09,87.24 218.42,87.24 219.53,86.13 234.04,86.13 235.18,84.99 236.37,84.99 v2(236.65,84.71)
  BOTTOM w0.089: UG5.F13 237.05,84.31 v2(236.65,84.71)
  BOTTOM w0.178: UG9.H17 v2(208.8,90.55)
FBC_D24: length 41.1
  IN5 w0.089: v2(208.1,89.75) 208.61,89.24 208.89,88.96 211.94,88.96 212.05,88.85
  IN5 w0.145: v2(241.52,77.3) 241.84,77.62 241.84,78.99 240.72,80.11 238.98,80.11 238.21,80.88 237.93,80.88 237.89,80.92 235.82,80.92 234.9,81.84 234.33,81.84 234.24,81.75 227.45,81.75 223.14,86.06 220.72,86.06 218.12,88.66 214.02,88.66 213.83,88.85 212.05,88.85
  BOTTOM w0.089: v2(241.52,77.3) 241.24,77.3 UG5.A4
  BOTTOM w0.178: UG9.J15 v2(208.1,89.75)
FBC_D25: length 43.6
  IN5 w0.089: v2(208.65,89.9) 209.41,89.14 212.96,89.14 213,89.19
  IN5 w0.145: 213,89.19 218.52,89.19 220.93,86.78 223.42,86.78 227.49,82.71 233.77,82.71 233.99,82.5 235.12,82.5 235.79,81.83 238.87,81.83 239.22,81.49 239.22,81.16 239.61,80.76 240.81,80.76 242.77,78.79 242.77,77.24 v2(241.45,75.91)
  BOTTOM w0.089: UG5.A2 241.05,75.51 v2(241.45,75.91)
  BOTTOM w0.178: UG9.H15 v2(208.65,89.9)
FBC_D26: length 35.9
  IN5 w0.089: v2(210.94,88.32) 211.2,88.58 211.68,88.58 211.91,88.35
  IN5 w0.145: 211.91,88.35 212.94,88.35 213.7,87.59 214.39,87.59 214.52,87.46 217.46,87.46 220.35,84.57 222.66,84.57 226.78,80.45 233.78,80.45 234.37,79.86 237.45,79.86 238.43,78.88 239.98,78.88 240.25,78.61 240.25,77.91 v2(240.65,77.51)
  BOTTOM w0.089: UG5.B4 240.25,77.11 v2(240.65,77.51)
  BOTTOM w0.17: v2(210.94,88.32) 210.94,88.49 UG9.E14
FBC_D27: length 39.2
  IN5 w0.089: 211.98,88.61 211.81,88.78 210.53,88.78 v2(210.2,88.45)
  IN5 w0.145: 211.98,88.61 213.31,88.61 213.76,88.16 217.65,88.16 220.43,85.38 222.89,85.38 227.2,81.07 234.06,81.07 234.74,80.39 237.67,80.39 237.71,80.35 237.81,80.35 238.74,79.42 240.56,79.42 241.06,78.92 241.06,77.16 240.65,76.75 v2(240.65,75.91)
  BOTTOM w0.089: v2(240.65,75.91) 240.25,75.51 UG5.B2
  BOTTOM w0.17: UG9.F14 v2(210.2,88.45)
FBC_D28: length 36
  IN5 w0.145: v2(237.45,76.71) 237.85,77.11 237.85,78.54 237.14,79.25 234.23,79.25 233.63,79.84 226.46,79.84 222.53,83.77 220.28,83.77 217.16,86.89 214.39,86.89 214.26,87.02 213.22,87.02 212.98,87.26 209.71,87.26 v2(208.8,86.35)
  BOTTOM w0.089: v2(237.45,76.71) 237.45,76.71 UG5.E4
  BOTTOM w0.178: UG9.H11 v2(208.8,86.35)
FBC_D29: length 36.2
  IN5 w0.145: v2(209.85,85.8) 209.8,85.85 209.8,86.5 210.25,86.95 211.76,86.95 211.81,86.9 212.79,86.9 213.26,86.43 214.22,86.43 214.33,86.32 216.77,86.32 220.18,82.9 222.31,82.9 225.96,79.25 233.34,79.25 234.01,78.58 235.7,78.58 236.28,78 236.73,78 237.05,77.68 237.05,75.51 v2(237.45,75.11)
  BOTTOM w0.089: v2(237.45,75.11) 237.45,75.11 UG5.E2
  BOTTOM w0.142: UG9.G11 209.8,85.85 v2(209.85,85.8)
FBC_D30: length 30.8
  IN5 w0.145: v2(236.65,77.51) 236.22,77.51 235.74,77.99 233.84,77.99 233.2,78.63 225.55,78.63 222.04,82.14 219.84,82.14 216.23,85.75 214.26,85.75 213.97,86.04 213.15,86.04 212.62,86.57 211.72,86.57 211.63,86.66 211.11,86.66 v2(210.8,86.35)
  BOTTOM w0.089: UG5.F4 v2(236.65,77.51)
  BOTTOM w0.17: UG9.F11 v2(210.8,86.35)
FBC_D31: length 31.3
  IN5 w0.145: v2(211.45,86.25) 211.75,85.95 211.75,85.37 212.01,85.11 213.71,85.11 214.08,84.74 215.98,84.74 219.41,81.32 221.73,81.32 225.02,78.02 232.91,78.02 233.6,77.33 235.85,77.33 236.25,76.93 236.25,76.31 v2(236.65,75.91)
  BOTTOM w0.089: v2(236.65,75.91) UG5.F2
  BOTTOM w0.17: v2(211.45,86.25) 211.45,86.4 UG9.E11
FBC_D32: length 22.5
  IN1 w0.129: 212.09,99.25 211.94,99.4 210.64,99.4 210.49,99.54 208.69,99.54 v2(208.1,98.95)
  IN1 w0.145: 212.09,99.25 213.66,99.25 214.07,99.66 221.59,99.66 224.2,102.26 227.54,102.26 v2(227.85,101.95)
  BOTTOM w0.089: UG6.A4 v2(227.85,101.95)
  BOTTOM w0.178: UG9.J29 v2(208.1,98.95)
FBC_D33: length 19.9
  IN1 w0.089: v2(210.8,100.25) 211.18,99.87 211.66,99.87 211.74,99.95 212.26,99.95
  IN1 w0.145: v2(227.85,103.55) 227.59,103.8 226.6,103.8 226.46,103.66 223.6,103.66 220.68,100.74 213.71,100.74 212.92,99.95 212.26,99.95
  BOTTOM w0.178: UG9.F30 v2(210.8,100.25) ; UG6.A2 v2(227.85,103.55)
FBC_D34: length 21.9
  IN1 w0.089: 211.92,98.93 211.67,99.18 210.48,99.18 210.38,99.28 209.73,99.28 v2(209.4,98.95)
  IN1 w0.145: 211.92,98.93 212.83,98.93 212.99,98.77 218.2,98.77 218.39,98.96 221.95,98.96 224.54,101.55 228.24,101.55 v2(228.65,101.95)
  BOTTOM w0.089: UG6.B4 v2(228.65,101.95)
  BOTTOM w0.178: UG9.H29 v2(209.4,98.95)
FBC_D35: length 22
  IN1 w0.129: 212.18,99.6 212.14,99.64 210.81,99.64 210.57,99.88 209.87,99.88 v2(209.5,100.25)
  IN1 w0.145: v2(228.65,103.55) 228.24,103.14 226.89,103.14 226.71,102.96 223.88,102.96 221.13,100.21 213.94,100.21 213.34,99.6 212.18,99.6
  BOTTOM w0.178: UG6.B2 v2(228.65,103.55) ; UG9.G30 v2(209.5,100.25)
FBC_D36: length 24.7
  IN1 w0.145: v2(218.54,101.3) 218.54,101.34 219.08,101.88 219.4,101.88 223.12,105.6 230.95,105.6 231.45,105.1 231.45,102.35 v2(231.85,101.95)
  BOTTOM w0.089: UG6.E4 v2(231.85,101.95)
  BOTTOM w0.102: UG9.B30 213.5,99.95 213.83,100.28 214.22,100.28 214.31,100.19 215.09,100.19 215.12,100.22
  BOTTOM w0.142: 217.37,100.84 218.08,100.84 v2(218.54,101.3)
  BOTTOM w0.178: 215.12,100.22 215.19,100.29 216.68,100.29 216.86,100.47 217,100.47 217.37,100.84
FBC_D37: length 20.7
  IN1 w0.145: v2(219.71,101.31) 220.23,101.31 223.28,104.35 223.85,104.35 224.45,104.95 230.4,104.95 230.65,104.7 230.65,103.95 v2(231.05,103.55)
  BOTTOM w0.142: v2(219.71,101.31) 219.66,101.26 219.66,101.22 219.23,100.79 218.76,100.79 218.3,100.33 217.39,100.33 217.01,99.95 UG9.A30
  BOTTOM w0.178: UG6.E2 v2(231.05,103.55)
FBC_D38: length 33.3
  IN1 w0.1: 209.02,100.47 209.02,101.21 209.3,101.48 210.97,101.48 211.16,101.29 213.87,101.29
  IN1 w0.129: 209.02,100.47 v2(208.8,100.25)
  IN1 w0.145: 213.87,101.29 214.28,101.7 217.13,101.7 217.37,101.94 217.37,102.22 222.06,106.91 232,106.91 233.05,105.86 233.05,102.36 v2(232.65,101.95)
  BOTTOM w0.089: UG6.F4 v2(232.65,101.95)
  BOTTOM w0.17: UG9.H30 v2(208.8,100.25)
FBC_D39: length 25.4
  IN1 w0.145: v2(217.35,101.31) 217.78,101.74 218.22,101.74 222.74,106.25 231.66,106.25 232.25,105.67 232.25,103.95 v2(231.85,103.55)
  BOTTOM w0.102: UG9.C30 212.8,99.95 213.15,100.3 213.5,100.3 213.68,100.48 214.99,100.48
  BOTTOM w0.142: v2(217.35,101.31) 217.35,101.3 216.86,100.81
  BOTTOM w0.178: 214.99,100.48 215.1,100.59 216.37,100.59 216.58,100.81 216.86,100.81 ; UG6.F2 v2(231.85,103.55)
FBC_D40: length 18.1
  IN5 w0.145: v2(227.85,95.55) 226.54,96.86 222.2,96.86 222.07,96.73 214.42,96.73 214.34,96.81 214.34,96.81 214.11,97.04 214.11,97.6 213.67,98.04 212.31,98.04 v2(212.2,98.15)
  BOTTOM w0.089: UG6.A11 v2(227.85,95.55)
  BOTTOM w0.17: UG9.D27 v2(212.2,98.15)
FBC_D41: length 22.9
  IN5 w0.145: v2(208.11,96.81) 208.11,96.86 208.5,97.25 212.4,97.25 213.36,96.29 213.36,95.78 213.99,95.15 221.89,95.15 222.46,94.58 225.88,94.58 226.77,93.69 227.58,93.69 v2(227.85,93.95)
  BOTTOM w0.089: UG6.A13 228.24,94.35 v2(227.85,93.95)
  BOTTOM w0.178: UG9.J26 208.4,97.1 v2(208.11,96.81)
FBC_D42: length 21
  IN5 w0.145: v2(228.65,95.55) 228.25,95.15 227.28,95.15 226.33,96.1 222.9,96.1 222.77,96.23 214.38,96.23 213.71,96.91 213.71,97.18 213.13,97.75 210.6,97.75 v2(210.2,98.15)
  BOTTOM w0.089: UG6.B11 v2(228.65,95.55)
  BOTTOM w0.17: UG9.F27 v2(210.2,98.15)
FBC_D43: length 21.9
  IN5 w0.145: v2(228.65,93.95) 228.25,94.35 227.06,94.35 226.07,95.34 222.65,95.34 222.25,95.73 214.42,95.73 212.66,97.5 210.15,97.5 v2(209.5,98.15)
  BOTTOM w0.089: UG6.B13 v2(228.65,93.95)
  BOTTOM w0.178: UG9.G27 v2(209.5,98.15)
FBC_D44: length 22.3
  IN5 w0.145: v2(216.25,99.2) 217.03,98.42 218.22,98.42 218.35,98.55 221.48,98.55 222.07,99.15 228.47,99.15 230.65,96.97 230.65,95.95 v2(231.05,95.55)
  BOTTOM w0.089: UG6.E11 v2(231.05,95.55)
  BOTTOM w0.142: v2(216.25,99.2) 215.53,98.48 213.78,98.48 213.5,98.2 213.12,98.2 212.77,97.85 UG9.C27
FBC_D45: length 24.5
  IN5 w0.145: v2(231.85,93.95) UG6.E13 231.45,97.37 228.99,99.82 221.83,99.82 221.04,99.03 218.46,99.03 218.23,98.8 217.25,98.8 v2(216.85,99.2)
  BOTTOM w0.089: UG6.E13 231.45,94.35 v2(231.85,93.95)
  BOTTOM w0.142: v2(216.85,99.2) 215.85,98.2 213.85,98.2 213.5,97.85 UG9.B27
FBC_D46: length 23.3
  IN5 w0.145: v2(231.85,95.55) UG6.F11 232.25,97.5 229.23,100.52 221.67,100.52 220.69,99.54 218.33,99.54 v2(218.04,99.25)
  BOTTOM w0.089: UG6.F11 v2(231.85,95.55)
  BOTTOM w0.178: UG9.A27 216.72,97.85 218.04,99.16 v2(218.04,99.25)
FBC_D47: length 28.4
  IN5 w0.145: v2(232.65,93.95) 232.11,93.42 230.99,93.42 230.64,93.76 230.64,95.02 230.5,95.15 229.97,95.15 229.85,95.28 229.85,96.67 228.06,98.45 222.2,98.45 221.78,98.03 216.47,98.03 215.85,98.65 214.37,98.65 213.7,99.32 211.45,99.32 v2(210.94,98.81)
  BOTTOM w0.089: v2(232.65,93.95) 232.25,94.35 UG6.F13 ; UG9.G29 210.03,99.25 210.39,98.89 210.85,98.89 v2(210.94,98.81)
FBC_D48: length 44.6
  IN5 w0.145: v2(241.45,95.55) 241.46,95.56 242.21,95.56 242.85,94.92 242.85,91.47 238.78,87.4 225.31,87.4 224.3,88.42 221.63,88.42 219.59,90.46 213.44,90.46 213.13,90.77 211.92,90.77 211.74,90.95 209.6,90.95 209.05,91.5 209.05,92.25 208.8,92.5 v2(208.8,92.65)
  BOTTOM w0.089: UG6.U11 v2(241.45,95.55)
  BOTTOM w0.178: UG9.H20 v2(208.8,92.65)
FBC_D49: length 34.6
  IN5 w0.145: v2(212.2,91.85) 212.35,91.7 220.12,91.7 221.71,90.11 224.49,90.11 225.8,88.8 237.94,88.8 241.05,91.9 241.05,93.55 v2(241.45,93.95)
  BOTTOM w0.089: UG6.U13 v2(241.45,93.95)
  BOTTOM w0.178: UG9.D18 v2(212.2,91.85)
FBC_D50: length 41.3
  IN5 w0.145: v2(240.65,95.55) 241.05,95.15 241.6,95.15 241.84,94.91 241.84,92.85 241.86,92.83 241.86,91.43 238.53,88.1 225.57,88.1 224.37,89.29 221.64,89.29 219.85,91.08 213.5,91.08 213.37,91.21 212.07,91.21 211.92,91.36 210.89,91.36 210.5,91.75 210.5,92.16 210.13,92.53 v2(210.02,92.53)
  BOTTOM w0.089: UG6.T11 v2(240.65,95.55)
  BOTTOM w0.178: v2(210.02,92.53) 210.02,92.73 UG9.G20
FBC_D51: length 35.2
  IN5 w0.145: v2(240.65,94.75) 240.25,94.35 240.25,92.22 237.52,89.5 226.07,89.5 224.49,91.08 221.56,91.08 220.35,92.29 213.15,92.29 212.9,92.54 211.47,92.54 v2(211.33,92.4)
  BOTTOM w0.089: UG6.T13 240.25,94.35 v2(240.65,94.75)
  BOTTOM w0.178: UG9.E20 211.33,92.82 v2(211.33,92.4)
FBC_D52: length 36.3
  IN5 w0.145: v2(210.9,94.65) 210.47,94.22 210.47,93.74 211.18,93.03 212.95,93.03 213.12,92.86 220.62,92.86 221.7,91.78 224.74,91.78 226.07,90.45 237.49,90.45 238.65,91.61 238.65,95.15 v2(238.25,95.55)
  BOTTOM w0.089: UG6.N11 v2(238.25,95.55)
  BOTTOM w0.17: UG9.F23 v2(210.9,94.65)
