# Allegro board LAD581PR10-0906.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NVVDD_VIDBUF: length 2.6
  BOTTOM w0.203: PR6119.1 202.02,28.46 v1(201.89,28.59) 201.59,28.59 200.87,29.31 PU6100.6
NVVDD_VREF: length 3.2
  TOP w0.114: v2(200.07,28.79) v1(200.43,29.15)
  TOP w0.254: PC6120.2 v2(200.07,28.79)
  BOTTOM w0.203: PU6100.8 v2(200.07,28.79)
  BOTTOM w0.254: v2(200.07,28.79) 200.24,28.62 PR6127.1
NVVDD_VSS_SENSE: length 124.4
  IN1 w0.381: v2(173.67,92.23) 174,92.23 174.26,91.97 174.26,90.45 170.38,86.57 170.38,83.84 169.95,83.41 169.95,78.71 171,77.67 171,76.97 171.71,76.26 171.71,70.59 177.43,64.86 181.13,64.86 181.97,64.02 181.97,63.05 184.22,60.81 184.38,60.81 184.69,60.5 184.69,60.07 184.42,59.8 184.42,57.16 185.24,56.34 185.24,53.87 185.46,53.65 185.46,52.62 185.73,52.35 187.48,52.35 187.96,51.86 187.96,41.61 188.25,41.32 188.25,39.5 193.71,34.04 193.71,31.96 197.65,28.02 197.65,26.86 v2(198.45,26.06)
  BOTTOM w0.127: UG9.BL45 178.8,110.45 178.36,110.89 177.37,110.89
  BOTTOM w0.254: v2(173.67,92.23) 173.65,92.23 173.08,91.65 167.02,91.65 163.72,94.96 163.72,99.78 164.81,100.88 164.81,102.78 v1(172.16,110.13) 172.16,111.59 173.35,112.78 174.15,112.78 174.43,112.5 PR6128.2 175.76,112.5 177.37,110.89 ; v2(198.45,26.06) 198.47,26.09 PR6122.1
NVVDDS_B+:
  vias: v2(219.98,46.19) v2(219.98,45.55) v2(219.98,44.92) v2(220.04,40.98) v2(220.04,40.35) v2(220.04,39.71) v2(220.55,45.87) v2(220.55,45.24) v2(220.55,40.66) v2(220.55,40.03) v2(223.92,48.16) v2(224.55,48.16) v2(225.19,48.16) v2(225.82,48.16) v2(234.32,47.14) v2(234.31,46.51) v2(234.95,46.51) v2(234.95,47.14) v3(222.11,47.17)
NVVDDS_BST1: length 1
  BOTTOM w0.114: 216.78,32.46 217.15,32.46 v1(217.58,32.89)
NVVDDS_COMP: length 5.1
  TOP w0.254: PR6207.2 210.9,30.39 210.53,30.76 210.52,30.76 v2(210.2,31.08) 210.07,31.21 v1(210.07,31.9) 209.8,32.17 PC6209.2
  BOTTOM w0.203: PU6200.12 210.61,30.67 v2(210.2,31.08) PR6210.2
NVVDDS_HG1: length 14.8
  TOP w0.114: v2(219.22,48.28) v1(219.81,48.28)
  IN1 w1.016: 216.42,32.22 216.42,32.79 217.79,34.16 217.79,36.19 219.09,37.49 219.09,41.81 ; 218.84,47.14 219.03,46.95 219.03,43.71
  vias: v2(215.47,31.3) v2(216.05,31.3) v2(218.58,48.28) v2(218.77,42.81) v2(219.41,42.81)
NVVDDS_LG1: length 10.6
  IN1 w1.016: 213.37,41.36 213.37,35.01 ; 213.18,47.08 213.18,43.59
  BOTTOM w0.114: v2(212.93,48.28) v1(212.93,49.03)
  vias: v2(212.93,42.77) v2(213.56,48.28) v2(213.63,42.77) v2(213.56,34.12) v2(213.56,33.49)
NVVDDS_PSI: length 83
  TOP w0.089: RG564.2 183.02,79.49 183.3,79.21 RG503.1 RG565.2 183.92,78.47 184.19,78.21 184.19,78.19
  TOP w0.114: v2(183.99,74.8) 184.19,75.01 184.19,78.19
  IN5 w0.097: v2(218.73,30.62) 217.73,30.62 216.25,29.14 210.12,29.14 209.71,28.73 203,28.73 201.96,27.69 199.77,27.69 198.88,28.58 196.62,28.58 195.24,29.96 192.97,32.23 192.97,36.38 191.17,38.18 191.17,42 190.46,42.72 190.46,47.93 190.19,48.2 190.19,50.58 186.21,54.56 186.21,56.08 185.89,56.4 185.89,61.01 186.21,61.33 186.21,63.32 184.56,64.97 184.56,65.8 184.71,65.95 184.71,67.96 184.97,68.22 184.97,71.78 183.34,73.4 183.34,74.26 183.89,74.8 v2(183.99,74.8)
  BOTTOM w0.254: PR6228.1 218.38,30.62 v2(218.73,30.62)
NVVDDS_SW1:
  vias: v1(214.95,36.82) v2(214.36,47.27) v2(214.36,46.26) v2(214.36,45.24) v2(214.36,44.23) v2(214.36,41.62) v2(214.36,40.61) v2(214.36,39.59) v2(214.36,38.57) v2(214.54,48.98) v2(214.54,48.4) v2(214.94,36.02) v2(214.94,33.86) v2(215.18,48.98) v2(215.18,48.4) v2(215.43,47.26) v2(215.43,46.24) v2(215.43,45.23) v2(215.43,44.21) v2(215.81,48.98) v2(215.81,48.4) v2(216.14,41.62) v2(216.14,40.61) v2(216.14,39.59) v2(216.14,38.57) v2(216.45,48.98) v2(216.45,48.4)
NVVDDS_VCC_SENSE: length 131
  IN4 w0.254: v2(208.72,26.88) 208.61,26.99 208.61,27.71 207.79,28.54 206.77,28.54 204.74,26.5 203.34,26.5 202.42,25.58 195.98,25.58 195.31,26.25 191.34,26.25 189.75,27.84 189.75,36.03 188.16,37.62 188.16,41.43 187.85,41.74 187.85,47.01 187.28,47.59 186.64,47.59 186.2,47.14 185.6,47.14 185.47,47.27 185.47,53.06 185.06,53.48 185.06,55.86 182.62,58.3 182.62,63.68 181.29,65 172.02,65 169.05,67.97 169.05,78.89 169.97,79.81 169.97,83.3 177.05,90.38 177.05,93.65 177.62,94.22 177.62,98.07 175.34,100.35 175.34,109.24 174.51,110.07 v2(173.94,110.07)
  BOTTOM w0.254: UG9.BM45 178.17,110.32 176.18,110.32 PR6223.2 175.22,110.13 174,110.13 v2(173.94,110.07) ; PR6220.1 208.76,26.92 v2(208.72,26.88)
NVVDDS_VID: length 83.7
  TOP w0.114: v2(216.61,28.41) v1(217.22,28.41)
  IN5 w0.097: v2(182.96,77.94) 182.32,77.3 182.32,74.14 184.77,71.69 184.77,68.42 183.82,67.48 183.82,65.39 186.01,63.2 186.01,61.41 185.7,61.09 185.7,56.44 185.34,56.09 185.34,54.93 185.73,54.54 185.95,54.54 189.61,50.88 189.61,43.28 190.97,41.92 190.97,38.1 192.77,36.3 192.77,32.15 196.54,28.38 198.8,28.38 199.69,27.49 202.04,27.49 202.57,28.02 216.23,28.02 v2(216.61,28.41)
  BOTTOM w0.114: UG9.BE4 183.53,81.42 183.53,79.53 183.64,79.41 183.64,78.79 182.96,78.1 v2(182.96,77.94)
  BOTTOM w0.254: PR6208.1 216.82,28.61 v2(216.61,28.41)
NVVDDS_VIDBUF: length 2.6
  TOP w0.114: v2(214.52,28.47) v1(215.09,28.47)
  BOTTOM w0.203: PU6200.6 213.82,29.17 v2(214.52,28.47) 214.52,28.15 PR6216.1
NVVDDS_VREF: length 3.5
  TOP w0.114: v1(213.74,29.42) 213.74,29.42 PC6214.2
  TOP w0.254: v2(213.06,28.66) 213.06,29.12 PC6214.2
  BOTTOM w0.203: v2(213.06,28.66) 213.02,28.7 PU6200.8
  BOTTOM w0.254: v2(213.06,28.66) 213.07,28.65 PR6224.1
NVVDDS_VSS_SENSE: length 134.6
  IN4 w0.254: v2(208.1,26.88) 208.23,27.01 208.23,27.46 207.53,28.15 206.9,28.15 204.87,26.12 203.53,26.12 202.63,25.23 195.83,25.23 195.16,25.89 191.07,25.89 189.31,27.65 189.31,35.84 187.78,37.37 187.78,41.17 187.47,41.49 187.47,46.89 187.15,47.2 186.77,47.2 186.32,46.76 185.43,46.76 185.08,47.12 185.08,52.88 184.7,53.26 184.7,55.72 182.26,58.16 182.26,63.46 181.07,64.65 171.75,64.65 168.7,67.7 168.7,79.11 169.5,79.91 169.5,83.4 176.67,90.58 176.67,93.75 177.24,94.32 177.24,97.88 174.96,100.16 174.96,108.99 174.51,109.43 v2(173.94,109.43)
  BOTTOM w0.254: v2(208.1,26.88) 208.1,26.63 208.99,25.74 v3(210.83,25.74) 211.28,26.18 PR6219.1 ; UG9.BM44 178.11,109.94 176.56,109.94 PR6225.2 175.22,109.75 174.45,109.75 174.13,109.43 v2(173.94,109.43)
ON/OFF#: length 247.9
  TOP w0.114: SW1.2 81.77,19.06 v2(82.5,18.33) 82.5,18 82.44,17.93 v3(82.44,16.98) 82.44,16.41 83.14,15.7 83.14,15.58 84.11,14.62 RE63.1 84.24,14.62 85.11,13.75 CE27.1 85.11,13.51 85.48,13.13 86.03,13.13 86.22,12.94 UE5.114
  IN2 w0.097: v2(130.27,165.23) 130.38,165.34 132.44,165.34 132.72,165.06 135.16,165.06 135.53,165.43 136.93,165.43 137.28,165.08 139.84,165.08 142.42,167.66 147.4,167.66 148.73,166.33 155.78,166.33 156.85,165.26 167.9,165.26 170.72,162.44 v2(171.63,162.44)
  IN5 w0.097: v2(82.5,18.33) 80.95,19.88 77.15,19.88 74.52,22.5 74.52,47.97 77.04,50.49 77.04,55.96 82.8,61.72 82.8,92.02 84.27,93.49 84.27,143.74 86.06,145.52 87.56,145.52 89.25,147.21 105.54,147.21 108.12,149.78 108.28,149.78 110.41,151.92 110.48,151.92 118.54,159.98 122.93,159.98 127.52,164.57 127.52,164.87 127.53,164.87 127.53,164.96 128.15,165.59 129.9,165.59 v2(130.27,165.23)
  BOTTOM w0.114: v2(171.63,162.44) 171.97,162.44 SW2.2
OUT_A:
  vias: v1(28.58,15.45) v2(28.46,16.72) v2(28.9,16.25)
OUT_B:
  vias: v1(28.82,15.35)
OUT_C:
  vias: v1(24.39,16.6)
OUT_D: length 0.6
  BOTTOM w0.114: v1(24.1,16.58) 24.01,16.68 v2(23.55,16.68)
  vias: v2(23.16,16.25)
OVERT#: length 11.9
  TOP w0.114: UG23.5 188.61,82.21 187.28,80.87 187.28,80.61 v1(186.64,79.97) 185.69,79.02 RG9.1 185.05,79.02 v2(184.8,78.76)
  IN3 w0.124: v2(181.5,82.15) 181.5,80.6 181.78,80.33 183.24,80.33 v2(184.8,78.76)
  BOTTOM w0.114: UG9.BG5 v2(181.5,82.15)
P1: length 19.4
  TOP w0.254: PR706.1 63.69,33.18 v2(63.07,32.56)
  IN5 w0.254: v2(52.65,43.96) 54.84,43.96 57.48,41.32 59.51,41.32 60.85,39.99 60.85,39.32 62.31,37.86 62.31,35.92 63.07,35.16 v2(63.07,32.56)
  vias: v2(50.49,47.45) v2(50.49,46.81) v2(50.49,46.18) v2(50.49,45.54) v2(50.49,44.91) v2(50.49,44.27) v2(50.99,46.5) v2(50.99,45.86) v2(50.99,45.23) v2(50.99,44.59) v2(50.99,43.96) v2(51.5,46.81) v2(51.5,46.18) v2(51.5,45.54) v2(51.5,44.91) v2(51.5,44.27) v2(52.01,43.96) v2(52.01,43.26) v2(52.01,42.62) v2(52.65,43.26) v2(52.65,42.62) v3(52.21,44.86)
P2:
  vias: v3(54.27,43)
PA_USB2_RBIAS: length 2.8
  TOP w0.102: UT1.H19 v2(152.75,157.14)
  BOTTOM w0.127: v2(152.75,157.14) 152.75,157.15 v1(152.04,157.86) 151.72,158.18 151.72,158.99 RT43.1
PB_USB2_RBIAS: length 2.3
  TOP w0.102: UT1.F19 152.11,158.43 v2(152.11,158.45)
  BOTTOM w0.114: v1(152.75,160.02) RT44.1
  BOTTOM w0.127: v2(152.11,158.45) 152.22,158.56 152.22,159.35 RT44.1
PBTN_OUT#: length 111
  TOP w0.089: CH174.1 174.61,48.52 RH2.2 ; 175.84,47.46 v1(176.01,47.28) v2(177.31,47.28)
  TOP w0.102: CH174.1 175.65,47.65 175.84,47.46
  TOP w0.114: v2(89.05,16.71) 88.48,16.14 UE5.106
  IN2 w0.097: v2(177.31,47.28) 176.29,47.28 175.91,46.9 175.91,46.3 175.45,45.84 174.54,45.84 174.14,45.43 173.13,45.43 172.58,44.88 167.97,44.88 167.75,44.66 164.35,44.66 163.53,43.84 160.82,43.84 160.44,43.46 158.45,43.46 156.62,41.63 153,41.63 148.29,36.92 147.78,36.92 145.56,34.7 145.56,31.08 144.41,29.93 143.46,29.93 139.84,26.31 136.9,26.31 136.36,25.77 115.54,25.77 111.55,21.78 110.19,21.78 109.08,20.67 104.41,20.67 104.12,20.97 98.42,20.97 96.76,19.3 91.64,19.3 v2(89.05,16.71)
  BOTTOM w0.089: UH1.AT13 177.42,47.17 v2(177.31,47.28)
PC0: length 4.3
  TOP w0.114: v1(163.12,107.86) RV625.1 162.19,108.27 162.03,108.44 v2(161.52,108.44) 160.9,108.44 160.73,108.27 RV624.1
  BOTTOM w0.114: v2(161.52,108.44) UV21.38
PC1: length 5.8
  BOTTOM w0.114: RV626.1 156.47,99.19 156.97,99.69 156.97,100.49 RV627.1 156.97,101.49 157.6,101.49 158.27,102.16 UV21.55
PC_BEEP: length 4.3
  TOP w0.254: DA1.1 31.32,33.1 RA9.1 30.99,32.06 31.19,31.86 v1(31.19,31.51) 31.19,30.77 RA15.1
PCH_AZ_BITCLK: length 34.5
  TOP w0.114: RP2.5 183.57,27.08 v1(185.88,29.39) 186.2,29.7 190.38,29.7 v2(190.54,29.86)
  IN5 w0.097: v2(179.9,48.26) 180.84,48.26 181.37,47.73 181.37,46.98 181.92,46.43 184.27,46.43 186.51,44.18 186.51,37.69 187.1,37.11 188.03,37.11 189.88,35.25 189.88,30.21 190.23,29.86 v2(190.54,29.86)
  BOTTOM w0.089: UH1.BA9 179.99,48.34 v2(179.9,48.26)
PCH_AZ_CODEC_BITCLK: length 189.4
  TOP w0.114: RP2.4 183.57,24.45 v1(183.28,24.15) 182.91,24.15 v2(182.41,23.66)
  IN2 w0.104: v2(182.41,23.66) 182.41,23.56 182.04,23.18 182.04,22.73 181.83,22.53 181.64,22.53 180.26,21.15 179.07,21.15 176.87,18.95 160.53,18.95 158.43,16.85 152.47,16.85 151.98,16.35 151.98,15.09 151.02,14.14 146.07,14.14 144.88,12.96 139.88,12.96 138.85,11.93 132.57,11.93 132.03,11.39 125.03,11.39 123.32,9.68 120.29,9.68 120.09,9.49 118.71,9.49 118.01,8.79 116.86,8.79 116.54,8.46 116.54,7.96 114.88,6.31 103.48,6.31 102.79,7 96.19,7 95.58,6.39 85.42,6.39 83.35,8.46 63.05,8.46 61.29,10.21 44.52,10.21 41.71,13.02 35.38,13.02 34.52,13.88 34.52,16.22 32.87,17.87 32.38,17.87 31.84,18.41 31.84,18.74 29.82,20.77 29.82,24.46 30.43,25.07 30.43,30.06 30.21,30.28 30.21,32.97 v2(31.87,34.62)
  BOTTOM w0.114: v2(31.87,34.62) RA2.1 31.28,35.32 30.63,35.98 UA1.13
PCH_AZ_CODEC_RST#: length 185.5
  TOP w0.114: v2(181.83,23.66) 181.83,23.89 183.07,25.13 RP2.3 ; v2(33.29,34.12) 32.02,35.39 v1(31.95,35.39)
  IN2 w0.104: v2(181.83,23.66) 181.81,23.64 181.55,23.64 179.89,21.99 178.91,21.99 177.39,20.47 169.18,20.47 168.41,19.71 160.32,19.71 158.15,17.54 152.08,17.54 151.29,16.74 151.29,15.38 150.74,14.83 145.78,14.83 144.6,13.65 139.59,13.65 138.57,12.62 132.28,12.62 131.74,12.08 125.26,12.08 124.83,12.51 122.1,12.51 119.84,10.25 118.49,10.25 117.72,9.48 116.38,9.48 113.9,7 103.76,7 103.07,7.69 96.69,7.69 96.47,7.9 94.4,7.9 93.57,7.08 87.34,7.08 86.95,7.47 85.31,7.47 83.64,9.15 63.35,9.15 61.58,10.92 44.81,10.92 42.01,13.72 36.01,13.72 35.27,14.47 35.27,16.56 31.77,20.05 31.77,24.52 31.77,24.52 31.77,25.73 31.77,25.74 31.77,26.54 31.55,26.76 31.55,32.38 v2(33.29,34.12)
  BOTTOM w0.114: RA17.2 33.09,33.92 v2(33.29,34.12)
PCH_AZ_CODEC_RST#_R: length 2.8
  BOTTOM w0.114: RA17.1 31.42,34.05 30.28,34.05 30.13,34.2 29.34,34.2 29.21,34.32 UA1.15
PCH_AZ_CODEC_SDIN0: length 220.1
  TOP w0.114: v2(183,23.63) 183.47,23.63 184.13,24.29 184.13,26.89 185.94,28.7 v1(187.17,28.7) 190,28.7 v2(190.54,29.23)
  IN2 w0.104: v2(183,23.63) 183,23.66 182.4,24.26 181.87,24.26 179.82,22.21 178.82,22.21 177.3,20.69 169.05,20.69 168.32,19.96 160.28,19.96 158.06,17.75 152,17.75 151.08,16.83 151.08,15.47 150.65,15.04 145.69,15.04 144.51,13.85 139.51,13.85 138.48,12.83 132.2,12.83 131.66,12.29 125.35,12.29 124.62,13.02 120.97,13.02 117.69,9.73 116.34,9.73 113.81,7.21 103.85,7.21 103.16,7.9 96.77,7.9 96.56,8.11 94.31,8.11 93.49,7.29 87.44,7.29 87.05,7.68 85.4,7.68 83.72,9.35 63.45,9.35 61.67,11.13 44.9,11.13 42.1,13.94 36.11,13.94 35.47,14.58 35.47,16.64 31.99,20.13 31.99,24.61 31.98,24.61 31.98,25.65 31.99,25.65 31.99,26.63 31.77,26.85 31.77,31.41 33.25,32.89 33.61,32.89 v2(33.9,33.17)
  IN5 w0.097: v2(190.54,29.23) 190.96,29.65 190.96,30.8 191.17,31.01 191.17,35.56 188.01,38.73 188.01,43.98 184.27,47.72 184.27,48.92 v2(183.39,49.8)
  BOTTOM w0.089: UH1.BE7 181.87,49.58 181.95,49.66 182.09,49.66 182.55,50.12 183.07,50.12 v2(183.39,49.8)
  BOTTOM w0.114: RA18.1 33.76,33.03 v2(33.9,33.17)
PCH_AZ_CODEC_SDOUT: length 198.2
  TOP w0.114: RP2.1 182.07,25.32 181.09,24.33 181.09,22.97 181.41,22.65 v1(182.17,22.65) 182.46,22.94 v2(182.46,23.07)
  IN2 w0.104: v2(29.89,33.51) 29.73,33.34 29.73,29.94 29.92,29.74 29.92,27.54 29.03,26.65 29.03,25.26 28.65,24.87 28.65,23.6 29.02,23.23 29.02,18.49 30.18,17.33 32.7,17.33 34.03,16.01 34.03,13.69 35.18,12.54 41.51,12.54 44.38,9.68 61.14,9.68 62.85,7.97 64.78,7.97 65.99,6.76 65.99,5.55 66.69,4.85 69.29,4.85 69.61,5.17 69.61,7.14 70.44,7.97 83.15,7.97 85.55,5.57 100.79,5.57 101.73,6.52 102.59,6.52 103.53,5.57 115.19,5.57 116.5,6.88 117.95,6.88 118.79,7.72 118.79,8.75 119.02,8.98 120.28,8.98 120.5,9.2 123.52,9.2 125.06,10.73 125.83,10.73 126,10.91 132.23,10.91 132.77,11.44 139.05,11.44 140.08,12.47 145.08,12.47 146.27,13.65 151.22,13.65 153.05,15.48 157.76,15.48 160.73,18.46 178.79,18.46 181.43,21.11 182.64,21.11 182.78,21.25 182.78,22.75 v2(182.46,23.07)
  BOTTOM w0.114: RA10.1 v2(29.89,33.51) 29.69,33.71 28.98,33.71 28.41,34.28 UA1.17
PCH_AZ_CODEC_SYNC: length 187.6
  TOP w0.114: RP2.2 182.57,25.04 181.37,23.84 181.37,23.38 v2(181.66,23.09)
  IN2 w0.104: v2(181.66,23.09) 181.3,23.09 179.98,21.78 179,21.78 177.49,20.27 169.42,20.27 168.61,19.46 160.36,19.46 158.23,17.33 152.17,17.33 151.49,16.66 151.49,15.3 150.82,14.62 145.86,14.62 144.68,13.44 139.68,13.44 138.65,12.42 132.37,12.42 131.83,11.88 125.18,11.88 124.75,12.31 122.49,12.31 122,11.82 122,10.37 121.79,10.17 120.08,10.17 119.95,10.04 118.57,10.04 117.81,9.27 116.48,9.27 114,6.79 103.68,6.79 102.99,7.49 96.6,7.49 96.39,7.7 94.48,7.7 93.66,6.87 87.24,6.87 86.85,7.27 85.23,7.27 83.55,8.94 63.25,8.94 61.49,10.7 44.73,10.7 41.92,13.51 35.91,13.51 35.06,14.36 35.06,16.37 31.56,19.87 31.56,24.43 31.55,24.43 31.55,25.82 31.56,25.83 31.56,26.45 31.34,26.67 31.34,32.75 32.52,33.93 32.52,34.97 32.36,35.13 v2(30.65,35.13)
  BOTTOM w0.114: v2(30.65,35.13) 30.65,35.35 30.42,35.58 UA1.14
PCH_AZ_RST#: length 36
  TOP w0.114: RP2.6 183.07,27.28 186.09,30.3 v1(186.96,30.3) 191.28,30.3 v2(191.34,30.36)
  IN5 w0.097: v2(182.76,49.76) 183.28,50.28 183.59,50.28 184.47,49.39 184.47,47.82 188.23,44.06 188.23,38.82 191.38,35.67 191.38,30.4 v2(191.34,30.36)
  BOTTOM w0.089: UH1.BD8 181.42,49.16 181.7,49.16 182.02,49.48 182.48,49.48 v2(182.76,49.76)
PCH_AZ_SDOUT: length 39.9
  TOP w0.089: RH16.2 179.33,51.56 179.33,50.8 179.66,50.47 179.66,50.25 180.03,49.88 v2(180.89,49.88)
  TOP w0.114: v2(190.55,31.53) 190.11,31.1 v1(189.75,31.1) 185.28,31.1 182.07,27.89 RP2.8
  IN5 w0.097: v2(180.89,49.88) 180.89,49.88 180.89,49.54 181.37,49.07 181.37,48.56 181.72,48.21 181.72,47.29 182.16,46.85 184.53,46.85 187.56,43.82 187.56,38.54 190.55,35.55 v2(190.55,31.53)
  BOTTOM w0.089: v2(180.89,49.88) 180.56,49.88 UH1.BB7
PCH_AZ_SYNC: length 34.6
  TOP w0.114: RP2.7 182.57,28.05 185.22,30.69 v1(188.33,30.69) 190.45,30.69 v2(190.57,30.81)
  IN5 w0.097: v2(183.19,49.26) 184.06,48.39 184.06,47.61 187.78,43.89 187.78,38.64 190.76,35.66 190.76,31.9 190.96,31.7 190.96,31.2 v2(190.57,30.81)
  BOTTOM w0.076: UH1.BD9 181.23,48.6 181.61,48.98
  BOTTOM w0.089: 181.61,48.98 181.77,48.98 182.05,49.26 v2(183.19,49.26)
PCH_BATLOW#: length 150.3
  TOP w0.114: v2(138.69,152.38) 139.04,152.03 v1(139.37,152.03) 139.56,152.03 139.93,152.4 RT14.2
  IN1 w0.097: v2(138.69,152.38) 141.44,149.63 142.78,149.63 143.55,148.87 152.08,148.87 152.5,148.44 152.5,147.92 153.94,146.48 156.38,146.48 157.2,145.66 159.4,145.66 159.85,146.11 161.12,146.11 161.17,146.06 161.48,146.06 169.63,137.92 169.63,129.32 170.33,128.61 170.33,114.43 168.25,112.35 168.25,106.35 165.45,103.54 165.45,102.72 164.63,101.91 164.63,98.45 164.18,98 164.18,96.45 161.36,93.63 161.36,89.79 162.62,88.53 162.62,77.95 164.5,76.07 164.5,68.25 167.65,65.1 167.65,61.14 174.18,54.6 174.18,52.52 176.18,50.52 176.76,50.52 176.99,50.29 176.99,49.36 177.62,48.73 180.07,48.73 180.75,48.05 v2(180.75,47.29)
  BOTTOM w0.089: 183.48,47.46 183.48,47.18 182.94,46.64 182.01,46.64 181.81,46.84 UH1.BD13 181.35,46.87 180.92,47.29 v2(180.75,47.29)
  BOTTOM w0.114: 183.48,47.46 183.67,47.65 184.27,47.65 184.54,47.39 184.54,46.51 184.97,46.08 RH515.1
PCH_CPU_BCLK_N: length 75.3
  IN2 w0.089: v2(144.1,108.31) 143.94,108.05 143.97,107.87 144.13,107.77 147.81,107.77 147.82,107.78 147.84,107.78
  IN2 w0.104: v2(152.22,63.2) 152.05,63.03 151.9,63.03 150.96,63.97 150.96,73.16 152.24,74.44 152.24,78.17 150.11,80.3 150.11,90.5 151.46,91.85 151.46,98.22 150.75,98.93 150.75,105.28 148.24,107.78 147.84,107.78
  BOTTOM w0.076: v2(144.1,108.31) 143.76,107.96 CPU1.A32
  BOTTOM w0.102: 163.37,55.16 163.37,53.35 163.56,53.16 UH1.H2
  BOTTOM w0.114: v2(152.22,63.2) 152.24,63.2 152.47,62.96 153.83,62.96 154.92,61.87 162.18,61.87 163.37,60.68 163.37,55.16
PCH_CPU_BCLK_P: length 75.3
  IN2 w0.089: v2(143.54,107.43) 143.7,107.68 143.88,107.72 144.07,107.6 147.81,107.6 147.82,107.59 147.84,107.59
  IN2 w0.104: v2(152.22,62.61) 152,62.83 151.82,62.83 150.76,63.89 150.76,73.24 152.05,74.52 152.05,78.09 149.91,80.22 149.91,90.58 151.26,91.93 151.26,98.14 150.55,98.85 150.55,105.2 148.16,107.59 147.84,107.59
  BOTTOM w0.076: CPU1.B31 143.45,107.51 v2(143.54,107.43)
  BOTTOM w0.102: 163.14,55.17 163.14,53.3 163.37,53.08 163.37,52.27 163.09,51.99 UH1.G2
  BOTTOM w0.114: 163.14,55.17 163.14,55.25 163.15,55.26 163.15,60.59 162.09,61.65 154.82,61.65 153.73,62.74 152.35,62.74 v2(152.22,62.61)
PCH_CPU_PCIBCLK_N: length 78.2
  IN2 w0.089: 147.84,108.92 147.82,108.92 147.81,108.91 146.58,108.91 145.44,110.06 142.33,110.06 142.17,110.22 v2(141.61,110.22)
  IN2 w0.104: v2(152.21,65.51) 151.98,65.27 151.8,65.27 151.63,65.43 151.63,68.98 152.92,70.26 152.92,78.45 150.79,80.58 150.79,90.22 152.13,91.56 152.13,98.5 151.42,99.21 151.42,105.75 148.25,108.92 147.84,108.92
  BOTTOM w0.076: CPU1.C36 141.62,110.23 v2(141.61,110.22)
  BOTTOM w0.102: 164.2,55.14 164.2,54.18 163.96,53.95 163.96,52.88 164.03,52.81 164.16,52.81 164.24,52.74 164.24,52.63 UH1.J1
  BOTTOM w0.114: v2(152.21,65.51) 152.39,65.33 153.15,65.33 154.24,64.24 157.35,64.24 158.35,63.24 161.95,63.24 164.2,60.99 164.2,55.14
PCH_CPU_PCIBCLK_P: length 77.8
  IN2 w0.089: v2(142.09,109.72) 142.24,109.88 145.36,109.88 146.51,108.74 147.81,108.74 147.82,108.73 147.84,108.73
  IN2 w0.104: 147.84,108.73 148.17,108.73 151.23,105.67 151.23,99.13 151.94,98.42 151.94,91.64 150.59,90.3 150.59,80.5 152.73,78.37 152.73,70.34 151.44,69.06 151.44,65.35 151.72,65.08 152.06,65.08 v2(152.21,64.92)
  BOTTOM w0.076: v2(142.09,109.72) 142.07,109.74 CPU1.D35
  BOTTOM w0.102: 163.97,55.08 164.01,55.04 164.01,54.26 163.77,54.03 163.77,52.81 163.87,52.71 163.87,52.37 164.03,52.2 UH1.J2
  BOTTOM w0.114: 163.97,55.08 163.97,55.12 163.99,55.14 163.99,55.16 163.97,55.18 163.97,60.9 161.85,63.02 158.25,63.02 157.25,64.02 154.14,64.02 153.06,65.11 152.4,65.11 v2(152.21,64.92)
PCH_DPWROK: length 122.1
  TOP w0.089: v2(178.06,48.27) 177.54,48.27 RH90.2
  TOP w0.114: UE5.127 89.2,7.74 90.23,8.77 90.23,10.02 90.36,10.15 90.36,11.79 90.81,12.24 90.81,16.16 v2(90.25,16.72) ; DE4.2 113.22,23.85 114.36,22.71 v2(114.36,22.36) 115.19,22.36 v3(115.2,22.34)
  IN2 w0.097: v2(178.06,48.27) 177.81,48.03 177.81,47.12 175.67,44.98 174.39,44.98 174.24,45.13 173.09,45.13 171.99,44.03 167.89,44.03 167.61,44.31 164.26,44.31 163.58,43.62 161,43.62 160.55,43.16 158.98,43.16 156.92,41.11 153.37,41.11 150.26,38 150.26,36.79 149.75,36.28 147.91,36.28 146.13,34.51 146.13,30.89 144.67,29.42 144.16,29.42 140.57,25.84 137.1,25.84 136.56,25.29 117.29,25.29 114.36,22.36 v2(114.36,22.36) 112.8,22.36 111.26,20.81 109.9,20.81 109.28,20.2 107.33,20.2 106.68,19.55 101.44,19.55 100.5,20.49 98.62,20.49 96.95,18.82 91.84,18.82 90.25,17.24 v2(90.25,16.72)
  BOTTOM w0.089: v2(178.06,48.27) 178.06,48.05 UH1.AV11
PCH_JTAG_TCK: length 179.1
  TOP w0.114: v2(178.39,55.97) 178.39,56.3 v3(178.58,56.49) ; JPCMC.32 71.2,70.4 v2(71.06,70.25) 70.83,70.02 68.03,70.02 RC35.1
  IN2 w0.097: v2(98.31,103.45) 98.31,103.22 97.48,102.39 97.48,94.85 93.33,90.7 88.3,90.7 83.31,85.71 83.31,84.21 71.32,72.21 71.32,71.65 71.5,71.47 71.5,70.69 v2(71.06,70.25) 71.06,69.43 70.75,69.12 70.75,68.45 79.55,59.65 87.07,59.65 88.27,58.45 152.75,58.45 154.59,56.61 162.81,56.61 164.05,57.85 169.93,57.85 170.95,56.83 175.56,56.83 176.7,55.7 178.12,55.7 v2(178.39,55.97)
  BOTTOM w0.076: 177.57,54.09 178.23,54.74
  BOTTOM w0.089: 177.57,54.09 177.57,53.91 176.96,53.29 176.96,52.28 176.93,52.25 176.93,51.96 177.16,51.73 UH1.AR3 ; CPU1.BR28 103.49,104.86 103.05,104.42 102.72,104.42 102.47,104.17 101.53,104.17 100.51,103.15 99.92,103.15
  BOTTOM w0.114: v2(98.31,103.45) 98.33,103.45 98.63,103.15 99.92,103.15
  BOTTOM w0.127: v2(178.39,55.97) 178.23,55.81 178.23,54.74
PCH_PLTRST#: length 244.1
  TOP w0.089: UH3.2 180.15,36.78 180.39,36.54 180.57,36.54 180.8,36.78 UH3.1 181.34,36.97 182.34,37.97 v1(182.48,37.97) 182.58,37.97 183.06,38.45 183.66,38.45 183.78,38.58 v2(183.78,38.63)
  IN5 w0.097: v2(128.13,164.94) 128.33,164.74 130.33,164.74 131.54,165.95 131.54,166.66 133.22,168.35 133.22,169.44 136.29,172.5 140.84,172.5 141.73,173.39 145.92,173.39 146.83,172.49 146.83,169.99 147.47,169.35 151.18,169.35 153.01,171.18 153.01,173.29 155.22,175.49 163.02,175.49 165.37,173.14 165.37,168.24 165.94,167.66 165.94,166.38 168.19,164.13 168.19,158.74 168.44,158.48 168.45,158.48 170.15,156.78 171.74,156.78 172.49,156.03 172.49,151.36 176.25,147.61 176.25,144.36 176.67,143.94 176.67,140.93 175.08,139.34 175.08,135.15 174.69,134.75 174.69,107.4 172.17,104.89 172.17,88.58 168.14,84.55 168.14,79.68 166.1,77.64 166.1,65.38 165.56,64.84 v2(165.56,63.97) 165.56,59.67 170.56,54.67 170.56,48.18 171.07,47.67 171.07,45.74 171.45,45.36 174.11,45.36 174.56,44.9 175.67,44.9 177.12,43.45 183.74,43.45 184.29,42.91 184.29,38.96 183.96,38.63 v2(183.78,38.63)
  BOTTOM w0.089: v2(183.78,38.63) 183.6,38.63 183.33,38.9 183.33,39.59 182.43,40.5 181.98,40.5 181.89,40.41 181.41,40.41 181.29,40.29 180.65,40.29 180.35,39.99 UH1.BB27
  BOTTOM w0.114: UG10.2 185.45,59.55 185.13,59.23 183.48,59.23 183.32,59.4 182.64,59.4 182.32,59.08 182.32,58.98 181.94,58.6 180.2,58.6 178.03,60.77 178.03,61.4 175.53,63.91 172.23,63.91 171.2,62.88 166.58,62.88 165.56,63.9 v2(165.56,63.97) ; v2(128.13,164.94) 127.78,165.3 UM3.2
PCH_PWR_EN: length 258.5
  TOP w0.114: PR300.1 v3(218.01,20.06) 218.25,19.82 218.25,19.05 216.96,17.76 215.84,17.76 211.32,13.23 185.31,13.23 184.57,12.49 v2(184.1,12.49) ; RE74.1 v2(83.58,16.65) ; U18.4 149.56,61.87 C268.1 153.1,62.18 154.2,63.28 159.52,63.28 159.79,63.01 162.01,63.01 162.67,62.35 162.67,59.24 164.16,57.75 165.8,57.75 169.42,61.37 v2(170.06,61.37)
  IN1 w0.097: v2(83.58,16.65) 84.82,16.65 87.01,18.84 91.33,18.84 91.99,19.5 94.87,19.5 99.43,24.06 102.12,24.06 102.12,24.06 102.82,24.06 103.18,23.7 106.06,23.7 106.58,24.22 116.87,24.22 116.96,24.31 118.48,24.31 118.96,23.82 118.96,23.82 119.14,23.64 129.04,23.64 129.55,24.15 143.93,24.15 144.47,23.61 144.95,23.61 146.37,25.02 154.82,25.02 156.18,23.67 160.29,23.67 165.11,18.86 166.65,18.86 170.14,15.37 179.63,15.37 181.11,13.89 182.7,13.89 v2(184.1,12.49)
  BOTTOM w0.114: v2(170.06,61.37) 170.06,61.37 170.73,62.04 172.08,62.04 172.89,62.85 174.72,62.85 177.18,60.38 177.23,60.38 177.99,59.62 177.99,58.87 179.1,57.76 185.55,57.76 186.53,56.78 186.53,53.86 188.22,52.17 188.22,43.08 188.52,42.77 189.82,42.77 189.94,42.65 189.94,42.06 190.51,41.49 190.51,36.85 192.36,35.01 192.36,23.49 191.62,22.76 186.71,22.76 186.09,22.14 184,22.14 183.29,21.42 181.12,21.42 180.67,20.98 180.67,17.23 181.01,16.89 181.01,13.12 181.64,12.49 v2(184.1,12.49)
PCH_PWROK: length 114.8
  TOP w0.089: v3(177.89,47.38) 178.6,48.1 v2(178.6,48.27)
  TOP w0.114: DE3.2 113.96,22.19 v2(114.38,21.77) ; RE75.1 CE44.1 101.07,3.8 UE5.32 101.07,7.14 100.94,7.27 100.94,9.5 100.34,10.1 100.34,12.65 99.58,13.41 99.58,13.98 99.61,14.01 99.61,16.55 100.53,17.48 100.53,19.19 v2(100.47,19.26)
  IN2 w0.097: v2(100.47,19.26) 100.58,19.15 106.85,19.15 107.5,19.79 109.45,19.79 110.07,20.41 111.43,20.41 112.79,21.77 v2(114.38,21.77) 114.38,21.8 117.46,24.89 127.31,24.89 136.85,24.89 137.39,25.43 140.8,25.43 144.35,28.98 145.56,28.98 147.59,31.01 147.59,33.68 148.41,34.5 152.06,34.5 153.52,35.97 153.52,39.29 154.89,40.66 157.09,40.66 159.33,42.91 160.79,42.91 161.28,43.39 164.82,43.39 164.87,43.44 171.7,43.44 173.2,44.94 174.16,44.94 174.31,44.79 175.74,44.79 177.99,47.04 177.99,47.67 v2(178.6,48.27)
  BOTTOM w0.089: v2(178.6,48.27) 178.6,48.19 179.03,47.76 UH1.AW11
PCH_RTCRST#: length 104.1
  TOP w0.089: 184.56,48.72 183.44,48.72 v2(182.94,48.21) 182.94,48.94 182.66,49.21 182.17,49.21 RH84.2 182.43,50.57 CH53.1
  TOP w0.114: QE5.1 146.53,14.68 v2(145.75,15.45) ; v3(184.58,48.72) 184.56,48.72
  IN5 w0.089: v2(182.94,48.21) 182.94,48.71 182.31,49.34 182.31,50.05 182.75,50.49 184.01,50.49 184.56,49.95
  IN5 w0.097: 184.56,49.95 184.93,49.58 184.93,48.06 188.74,44.25 188.74,38.99 191.86,35.87 191.86,28.21 190.51,26.86 190.51,23.36 190.05,22.9 188.48,22.9 187.99,23.4 187.99,24.16 187.59,24.56 185.41,24.56 183.91,23.06 v2(183.12,23.06)
  BOTTOM w0.076: 181.67,47.89 181.02,47.89 UH1.BC10
  BOTTOM w0.089: v2(182.94,48.21) 182.75,48.02 181.81,48.02 181.67,47.89
  BOTTOM w0.114: v2(183.12,23.06) 183.12,22.06 182.99,21.93 180.67,21.93 180.04,21.3 180.04,17.5 178.88,16.34 177.9,16.34 177.15,15.59 176.23,15.59 173.57,12.93 166.47,12.93 165.42,11.87 162.8,11.87 157.38,17.3 CLRP1.1 144.71,16.18 145.43,15.45 v2(145.75,15.45)
PCH_RTCX1: length 7.5
  BOTTOM w0.076: 181.64,48.76 181.5,48.62 181.5,48.55 181.3,48.34 180.99,48.34 180.73,48.6
  BOTTOM w0.089: UH1.BC9 180.73,48.6 ; 181.64,48.76 181.89,48.76 182.16,49.03 182.58,49.03 182.76,48.85 183.77,48.85 RH70.1
  BOTTOM w0.114: RH70.1 184.18,49.24 184.54,49.6 184.54,49.69 184.56,49.71
  BOTTOM w0.127: 184.56,49.71 185.02,50.17 CH45.1 185.31,50.43 185.61,50.43 186.29,51.11 YH1.1
PCH_RTCX2: length 6.4
  BOTTOM w0.089: RH70.2 183.81,48.67 182.89,48.67 182.41,48.2 181.69,48.2 181.62,48.12 UH1.BD10
  BOTTOM w0.114: RH70.2 184.18,48.33 184.54,48.68 184.54,48.76 184.56,48.78
  BOTTOM w0.127: 184.56,48.78 185.02,49.24 CH46.1 185.67,49.24 186.29,48.61 YH1.2
PCH_SATALED#: length 3.3
  BOTTOM w0.089: RH512.1 170.64,28.41 v1(170.64,29.42) 170.64,29.67 171.56,30.59 UH1.AD44
PCH_SMBCLK: length 125.4
  TOP w0.089: v2(178.98,29.4) 178.89,29.4 178.6,29.11 RH463.2
  IN2 w0.089: 178.43,29.04 178.44,29.05 178.44,29.06 178.48,29.09 178.48,29.25 178.48,29.25 178.48,30.49 178.64,30.65 178.96,30.65 179.29,30.31 179.29,29.91 178.97,29.59 178.97,29.41 178.98,29.4 v2(178.98,29.4) 179.01,29.43 180.43,29.43 180.57,29.29 184.56,29.29 ; 177.89,28.5 177.89,28.5
  IN2 w0.097: 178.43,29.04 178.27,28.88 178.11,28.72 177.89,28.5 ; 177.89,28.5 177.69,28.3 177.69,24.79 175.23,22.33 168.43,22.33 167.53,21.42 159.91,21.42 157.88,19.39 152.65,19.39 152.53,19.26 152.53,19.09 v2(152.66,18.95) ; 184.56,29.29 184.77,29.29 190.34,23.72 190.34,20.78 190.95,20.17 190.95,13.78 194.49,10.23 202.24,10.23 204.01,8.47 205.77,8.47 206.05,8.75 206.05,8.85 v2(206.27,9.07)
  IN5 w0.097: v2(147.03,48.54) 147.3,48.54 147.71,48.13 147.71,46.12 147.97,45.86 148.63,45.86 148.98,45.51 148.98,43.54 150.89,41.64 150.89,37.25 149.43,35.79 149.43,35.35 149.52,35.26 149.75,35.26 v2(149.98,35.49) 150.16,35.31 150.98,35.31 151.75,34.55 151.75,23.76 150.89,22.91 150.89,21.04 152.49,19.44 152.49,19.12 v2(152.66,18.95)
  BOTTOM w0.089: v2(178.98,29.4) 178.98,29.49 179.36,29.87 179.36,30.34 179.14,30.56 179.14,31.11 178.89,31.36 UH1.AW44
  BOTTOM w0.114: JTP.15 206.2,10.93 206.04,10.77 206.04,10.32 206.1,10.26 206.1,9.24 v2(206.27,9.07) ; v2(149.98,35.49) 149.8,35.31 149.18,35.31 148.88,35.02 147.92,35.02 147.03,35.91 JDIMM2.253 ; JDIMM1.253 v2(147.03,48.54)
PCH_SMBDATA: length 128
  TOP w0.089: RH462.2 179.8,29.11 180.15,29.46 v2(180.15,31.34)
  IN2 w0.089: 184.56,29.52 184.5,29.52 184.46,29.47 180.64,29.47 180.15,29.96 v2(180.15,31.34) 179.65,31.34 179.13,30.83 178.56,30.83 178.3,30.56 178.3,29.17
  IN2 w0.097: v2(205.69,9.07) 205.82,8.94 205.82,8.84 205.67,8.69 204.1,8.69 202.34,10.46 194.58,10.46 191.17,13.87 191.17,20.27 190.56,20.87 190.56,23.82 184.86,29.52 184.56,29.52 ; 178.3,29.17 178.19,29.06 178.03,28.9 177.81,28.68 177.65,28.52 177.5,28.38 177.5,28.28 177.46,28.24 177.46,24.88 175.14,22.55 168.34,22.55 167.43,21.65 159.81,21.65 157.78,19.62 152.56,19.62 152.3,19.36 152.3,19.2 v2(152.08,18.98)
  IN5 w0.097: v2(147.07,43.27) 147.78,43.97 147.78,45.45 147.97,45.64 148.54,45.64 148.76,45.42 148.76,43.45 150.66,41.54 150.66,37.35 149.2,35.89 149.2,35.26 149.43,35.04 149.85,35.04 v2(149.98,34.91) 150.16,35.09 150.89,35.09 151.52,34.45 151.52,23.86 150.67,23 150.67,20.95 152.27,19.35 152.27,19.17 v2(152.08,18.98)
  BOTTOM w0.089: UH1.BB43 180.15,31.74 v2(180.15,31.34)
  BOTTOM w0.114: v2(147.07,43.27) 147.28,43.06 JDIMM1.254 ; JTP.16 205.7,10.94 205.79,10.84 205.79,10.22 205.86,10.16 205.86,9.24 v2(205.69,9.07) ; v2(149.98,34.91) 149.81,35.07 149.28,35.07 148.98,34.78 148.01,34.78 147.93,34.7 147.93,33.38 147.65,33.11 147.65,30.77 147.28,30.39 147.28,30.08 JDIMM2.254
PCH_SPI_CLK: length 26.3
  BOTTOM w0.114: RH104.1 186.14,32.78 186.27,32.9 187.29,32.9 187.45,32.74 187.45,30.24 187.56,30.12 189.46,30.12 v1(189.57,30.01) 189.57,29.78 189.46,29.67 187.56,29.67 187.45,29.55 187.45,29.32 187.56,29.21 189.46,29.21 189.57,29.1 189.57,28.87 189.46,28.75 187.16,28.75 187.05,28.64 187.05,28.41 187.16,28.3 189.46,28.3 189.57,28.18 189.57,27.92 189.45,27.79 183.75,27.79 183.62,27.67 183.62,26.1 183.84,25.88 UH4.6
PCH_SPI_CLK_R: length 8.8
  BOTTOM w0.089: UH1.BC31 180.96,37.75 181.27,38.06 181.46,38.06 181.57,37.95 182.28,37.95 182.89,37.34 182.89,34.49 v1(183.26,34.12) 184.28,33.1
  BOTTOM w0.114: 184.28,33.1 184.91,33.1 185.22,32.79 RH104.2
PCH_SPI_CS#: length 32.4
  IN5 w0.097: v2(181.39,27.35) 181.37,27.37 181.37,27.67 182.63,28.93 185.21,28.93 185.31,29.03 185.31,29.22 185.21,29.32 183.24,29.32 183.15,29.41 183.15,29.61 183.24,29.7 185.21,29.7 185.31,29.8 185.31,29.99 185.21,30.09 184.06,30.09 183.97,30.19 183.97,30.38 184.06,30.48 185.21,30.48 185.31,30.57 185.31,30.77 185.21,30.86 184.06,30.86 183.97,30.96 183.97,31.15 184.06,31.25 185.21,31.25 185.31,31.35 185.31,31.54 185.21,31.63 184.06,31.63 183.97,31.73 v2(183.97,32.16)
  BOTTOM w0.089: v2(183.97,32.16) 183.97,32.72 182.72,33.97 182.72,37.27 182.21,37.78 181.49,37.78 181.49,37.78 181.37,37.78 UH1.BD31
  BOTTOM w0.114: v2(181.39,27.35) 181.94,26.79 181.94,26.11 179.17,23.34 UH4.1
PCH_SPI_HOLD#: length 14
  IN5 w0.097: v2(187.19,33.42) 187.19,29.65 185.46,27.92 v2(183.13,27.92)
  BOTTOM w0.114: UH4.7 183.57,24.61 183.13,25.06 v2(183.13,27.92) ; RPH5.4 187.1,33.51 v2(187.19,33.42)
PCH_SPI_HOLD#_R: length 12.9
  TOP w0.114: RH78.2 185.41,35.32 185.41,33.67 185.42,33.67 185.42,33.51 v1(185.07,33.17) 183.75,33.17 183.62,33.29 183.62,33.64 183.75,33.76 184.4,33.76 v2(184.54,33.62)
  BOTTOM w0.089: 184.2,33.62 183.07,34.75 183.07,37.41 182.35,38.13 181.64,38.13 181.41,38.37 UH1.BD30 ; 184.56,33.62 v2(184.54,33.62)
  BOTTOM w0.114: 184.2,33.62 v2(184.54,33.62) ; 184.56,33.62 184.58,33.61 185.26,33.61 RPH5.5
PCH_SPI_SI: length 27
  BOTTOM w0.114: UH4.5 184.89,27.08 v1(189.87,27.08) 190.07,27.29 190.07,30.62 189.95,30.73 188.06,30.73 187.95,30.85 187.95,31.08 188.06,31.19 189.95,31.19 190.07,31.31 190.07,31.53 189.95,31.65 188.06,31.65 187.95,31.76 187.95,31.99 188.06,32.11 189.95,32.11 190.07,32.22 190.07,32.45 189.95,32.56 188.09,32.56 187.97,32.68 187.97,32.92 188.09,33.03 189.57,33.03 189.69,33.15 189.69,33.38 189.57,33.49 187.77,33.49 187.64,33.62 187.64,34.38 187.52,34.51 RPH5.2
PCH_SPI_SI_R: length 155.3
  TOP w0.114: v2(73.08,64.48) 72.91,64.32 67.74,64.32 RH1.2
  IN1 w0.089: 183.25,55.17 183.25,54.39 184.51,53.14 184.51,52.41 184.56,52.36
  IN1 w0.097: v2(184.09,55.65) 183.71,55.65 183.25,55.19 183.25,55.17 ; 184.56,52.36 184.96,51.96 184.96,46.03 186.2,44.79 186.2,43.33 185.49,42.63 185.49,35.77 v2(184.23,34.51)
  IN2 w0.097: v2(184.09,55.65) 184.09,55.68 183.42,56.35 180.04,56.35 178.99,55.3 176.53,55.3 175.4,56.43 163.19,56.43 162.97,56.21 161.3,56.21 160.72,55.63 160.57,55.48 155.16,55.48 152.58,58.06 79.97,58.06 73.54,64.48 v2(73.08,64.48)
  BOTTOM w0.076: 181.86,38.62 180.65,38.62 UH1.BB29
  BOTTOM w0.089: 181.86,38.62 181.98,38.51 182.48,38.51 183.43,37.56 183.43,36.6 183.84,36.18 183.84,34.91 184.16,34.6
  BOTTOM w0.114: RPH5.7 v2(184.23,34.51) 184.23,34.53 184.16,34.6 ; RH489.1 184.15,55.72 v2(184.09,55.65)
PCH_SPI_SO: length 27.7
  IN5 w0.097: v2(181.49,26.38) 181.85,26.38 181.95,26.48 181.95,27.42 182.04,27.52 182.24,27.52 182.33,27.42 182.33,26.48 182.43,26.38 182.62,26.38 182.72,26.48 182.72,27.42 182.82,27.52 183.01,27.52 183.11,27.42 183.11,26.48 183.2,26.38 183.4,26.38 183.49,26.48 183.49,27.51 183.59,27.6 183.78,27.6 183.88,27.51 183.88,26.48 183.97,26.38 184.16,26.38 184.29,26.51 184.29,27.48 184.42,27.6 184.61,27.6 184.74,27.48 184.74,26.81 184.84,26.71 185.03,26.71 185.13,26.81 185.13,27.51 185.22,27.6 186.02,27.6 187.64,29.22 187.64,33.57 v2(187.2,34.01)
  BOTTOM w0.114: RPH5.3 v2(187.2,34.01) ; v2(181.49,26.38) 179.72,24.61 UH4.2 177.28,24.61 v1(176.29,23.62)
PCH_SPI_SO_R: length 6.9
  BOTTOM w0.089: UH1.BE30 181.83,38.37 181.88,38.31 182.43,38.31 183.25,37.49 183.25,36.37 v1(183.55,36.07) 183.55,34.67 184.09,34.13
  BOTTOM w0.114: 184.09,34.13 184.22,34.01 RPH5.6
PCH_SPI_WP#: length 20
  IN5 w0.097: v2(188.04,34.11) 188.04,29.3 184.64,25.91 179.86,25.91 v2(179.82,25.95)
  BOTTOM w0.114: v2(179.82,25.95) 179.82,25.92 179.71,25.81 177.64,25.81 UH4.3 ; RPH5.1 187.22,35.01 187.73,35.52 187.99,35.52 v1(188.11,35.39) 188.11,34.19 v2(188.04,34.11)
PCH_SPI_WP#_R: length 198.4
  TOP w0.114: v2(184.27,35.15) 184.35,35.15 RH75.2 ; v2(72.76,65.07) 72.27,64.58 69.24,64.58 68.77,65.04 RC354.2
  IN2 w0.097: v2(74.06,12.03) 74.06,11.84 74.57,11.32 84.15,11.32 84.93,12.11 87.03,12.11 87.98,11.15 90.18,11.15 91.08,10.25 93.84,10.25 95.47,11.88 99.22,11.88 99.98,11.12 109.14,11.12 109.92,11.9 113.39,11.9 116.94,15.45 121.88,15.45 122.88,16.45 138.42,16.45 139.34,17.37 143.12,17.37 144.83,19.08 148.23,19.08 150.88,21.73 154.93,21.73 157.72,24.52 168.95,24.52 169.65,25.22 171.96,25.22 172.35,25.61 173.01,25.61 175.66,28.25 175.66,30.46 176.55,31.36 177.01,31.36 177.27,31.62 177.27,32.59 177.19,32.67 177.19,34.6 177.43,34.83 178.37,34.83 178.87,35.33 184.09,35.33 v2(184.27,35.15)
  IN4 w0.137: v2(74.06,12.03) 74.06,12.22 74.31,12.47 74.31,13.23 72.4,15.14 72.4,16.59 75.07,19.26 75.07,34.37 77.1,36.4 77.1,46.82 78.68,48.4 78.68,59.57 73.18,65.07 v2(72.76,65.07)
  BOTTOM w0.076: 181.94,38.8 181.01,38.8 UH1.BC29
  BOTTOM w0.089: 181.94,38.8 182.05,38.69 182.55,38.69 182.96,38.28 183.61,37.63 183.61,36.67 184.24,36.03
  BOTTOM w0.114: RPH5.8 184.41,35.01 v2(184.27,35.15)
  BOTTOM w0.127: 184.24,36.03 184.24,35.17 v2(184.27,35.15)
PCH_SRTCRST#: length 10.4
  TOP w0.089: v2(183.52,48.23) 184.48,47.28 184.48,45.64 v1(184.16,45.32) CH52.1 181.43,45.64 RH83.2
  BOTTOM w0.076: UH1.BB10 180.52,48 180.8,47.72 181.37,47.72 181.39,47.7 181.81,47.7 181.83,47.72
  BOTTOM w0.089: 181.83,47.72 181.95,47.84 183.14,47.84 v2(183.52,48.23)
PCH_SYS_PWROK_XDP: length 2
  BOTTOM w0.114: RH493.2 RH489.2 184.59,57.18 v1(185.07,56.7)
PCH_TRIGGER: length 72.1
  TOP w0.114: RH167.1 143.52,99.42 v1(143.52,97.89) 143.52,96.86 144.1,96.29 145.91,96.29 v2(146.57,95.63)
  BOTTOM w0.089: 147.84,95.66 147.46,96.04 146.99,96.04 146.65,95.69 146.64,95.69 v2(146.57,95.63) ; 174.74,55.17 174.72,55.15 174.72,54.9 174.91,54.71 174.91,52.27 174.89,52.25 UH1.AL2
  BOTTOM w0.114: 147.84,95.66 148.03,95.46 149.49,95.46 150.19,94.77 150.19,82.61 151.28,81.52 151.28,69.29 153.51,67.06 157.63,67.06 158.6,66.09 161.17,66.09 167.45,59.8 169.32,59.8 169.77,59.36 174.44,59.36 175.02,58.78 175.02,57.62 175.23,57.4 175.23,56.86 175.17,56.8 175.17,55.61 174.74,55.17
PCH_XDP_CLK_N: length 2.2
  TOP w0.089: T19.1 165.9,54.25 v2(165.54,53.89)
  BOTTOM w0.089: v2(165.54,53.89) 165.17,53.52 165.17,53.06 165.22,53 165.22,52.55 UH1.L1
PCH_XDP_CLK_P: length 2.1
  TOP w0.089: T21.1 165.93,52.97 v2(165.57,53.33)
  BOTTOM w0.089: UH1.L2 165.42,52.23 165.42,53.18 v2(165.57,53.33)
PCIE_GEN3#_GEN2: length 244.5
  TOP w0.114: v2(267.29,40.22) 267.29,43.14 267.82,43.67 UE1.18 ; v2(225.63,22.44) 225.63,22.36 v3(224.99,21.73) 224.6,21.73 222.45,19.58 222.45,17.6 224.82,15.24 224.82,14.95 224.97,14.8 224.97,13.98 224.52,13.53 215.46,13.53 215.08,13.16 215.08,11.3 214.15,10.37 180.46,10.37 180.31,10.52 170.98,10.52 170.01,9.55 v2(169.94,9.55) ; v2(65.12,9.73) 64.52,9.13 64.52,6.26 64.78,5.99 65.23,5.99 65.42,6.18 UE6.11
  IN1 w0.097: v2(99.77,12.15) 99.91,12.15 101.86,14.11 107.15,14.11 108.06,15.01 121.78,15.01 122.87,16.1 124.71,16.1 125.87,14.95 126.82,14.95 128.73,16.85 141.11,16.85 141.51,16.46 159.13,16.46 165.27,10.32 169.11,10.32 169.87,9.55 v2(169.94,9.55)
  IN4 w0.137: v2(225.63,22.44) 227.15,23.96 230.07,23.96 232.45,26.34 236.03,26.34 250.71,41.03 266.48,41.03 v2(267.29,40.22)
  IN5 w0.097: v2(65.12,9.73) 65.69,9.16 70.4,9.16 72.55,11.31 81.46,11.31 83.42,9.36 85.87,9.36 86.73,10.22 89.77,10.22 91.4,11.85 99.47,11.85 v2(99.77,12.15)
PCIE_PRX_DTX_N5: length 139.9
  IN4 w0.089: 159.65,52.99 159.65,53.43 159.16,53.92 159.16,53.99 159.15,54
  IN4 w0.097: 159.65,52.99 159.65,51.67 160.54,50.78 160.54,49.35 161.36,48.52 163.28,48.52 164.47,47.33 164.47,45.93 164.47,45.14 165.3,44.31 165.3,43.57 165.06,43.33 164.8,43.33 164.67,43.2 v2(164.67,43.01)
  IN4 w0.147: v2(194.07,145.01) 193.96,145.01 193.18,144.23 179.08,144.23 178.45,143.6 177.29,143.6 171.97,138.28 171.97,102.9 172.95,101.93 172.95,91.22 169.67,87.95 168.9,87.95 165.39,84.44 165.39,82.75 160.94,78.3 158.05,78.3 156.09,76.34 156.09,55.15 157.03,54.21 158.94,54.21 159.15,54
  BOTTOM w0.089: UH1.K19 164.67,43.09 v2(164.67,43.01)
  BOTTOM w0.114: CL2.2 196.07,144.95 195.13,144.95 194.64,145.44 194.08,145.44 193.95,145.31 193.95,145.13 v2(194.07,145.01)
PCIE_PRX_DTX_N5_C: length 3.8
  BOTTOM w0.114: CL2.1 197.45,144.74 198.51,144.74 v4(198.99,145.22) 199.49,145.73 UL1.29
PCIE_PRX_DTX_N6: length 190.1
  IN4 w0.147: v2(296.73,58.93) 296.42,58.62 294.57,58.62 279.34,43.39 276.94,43.39 272.82,39.28 270.89,39.28 270.17,38.56 265.66,38.56 265.13,38.03 251.41,38.03 235.91,22.52 234.09,22.52 231.96,20.39 231.25,20.39 230.21,19.36 228.62,19.36 228.02,18.76 222.92,18.76 222.77,18.61 219.11,18.61 215.38,14.88 212.84,14.88 209.5,11.54 194.49,11.54 192.39,13.63 167,13.63 165.07,15.56 165.07,21.3 165.07,21.53 160.81,25.79 160.81,28.52 160.65,28.68 160.65,40.59 161.06,40.99 162.89,40.99 163.16,41.26 163.16,41.47 163.21,41.52 163.21,41.56 163.34,41.69 v2(163.46,41.69)
  BOTTOM w0.089: v2(163.46,41.69) 163.33,41.69 162.77,42.25 UH1.G22
  BOTTOM w0.114: JWLAN.35 300.75,60.5 300.58,60.34 300.23,60.34 298.52,58.62 297.04,58.62 v2(296.73,58.93)
PCIE_PRX_DTX_N9: length 106.1
  IN5 w0.089: v2(163.22,37.13) 163.53,36.82 163.53,36.72 163.82,36.42 164.28,36.42 164.62,36.08 164.62,35.45 165,35.07 165,34.49 165.69,33.81 165.69,31.71 165.44,31.46 165.44,29.99 165.68,29.75 165.68,28.27 165.68,28.27 165.68,28.24
  IN5 w0.104: v2(227.91,34.6) 227.42,34.6 227.09,34.27 227.09,31.92 223.6,28.43 223.6,21.92 221.1,19.42 221.1,18.9 220.63,18.43 219.69,18.43 216.18,14.92 216.18,12.58 213.68,10.08 205.24,10.08 205.01,9.85 194.06,9.85 189.26,14.65 186.44,14.65 185.72,15.37 185.08,15.37 184.51,14.79 177,14.79 174.58,17.22 170.52,17.22 167.27,20.47 167.27,25.29 165.68,26.89 165.68,28.24
  BOTTOM w0.101: UH1.G31 162.8,37.58 v2(163.22,37.13)
  BOTTOM w0.114: JSSD1.43 224.72,34.55 224.83,34.66 227.84,34.66 v2(227.91,34.6)
PCIE_PRX_DTX_N10: length 121.8
  IN5 w0.089: 163.78,28.24 163.78,28.27 163.77,28.27 163.77,29.58 161.74,31.62 161.74,33.83 162.05,34.15 162.05,35.15 161.94,35.27 161.94,36.16 162.27,36.49 162.57,36.49 162.8,36.72 162.8,38.21 162.93,38.34 163.11,38.34 v2(163.26,38.19)
  IN5 w0.104: v2(226.62,38.66) 226.81,38.48 226.81,38.02 228.89,35.94 228.89,31.7 225.72,28.53 225.72,23.85 226.17,23.4 226.17,14.89 224.39,13.11 219,13.11 213.9,8.01 203.68,8.01 203.46,8.24 193.39,8.24 188.59,13.03 185.19,13.03 185.13,13.1 181.49,13.1 180.6,12.21 176.53,12.21 174.11,14.63 169.54,14.63 166.33,17.84 166.33,18.9 165.66,19.57 165.66,24.62 163.78,26.5 163.78,28.24
  BOTTOM w0.089: UH1.G29 162.77,38.67 v2(163.26,38.19)
  BOTTOM w0.114: JSSD1.29 224.82,38.05 225.09,37.77 226.5,37.77 226.8,38.08 226.8,38.48 v2(226.62,38.66)
PCIE_PRX_DTX_N11: length 108
  IN5 w0.089: 167.15,28.24 167.15,28.27 167.14,28.27 167.14,28.41 166.7,28.85 166.7,33.68 165.85,34.53 165.85,36.5 165.62,36.73 165.28,36.73 165.19,36.83 165.19,37.06 165.31,37.19 v2(165.37,37.19)
  IN5 w0.104: 167.15,28.24 167.15,26.54 168.07,25.62 168.07,20.8 170.1,18.77 173.37,18.77 173.67,18.46 176.15,18.46 177.9,16.71 179.5,16.71 180.59,15.63 184.19,15.63 184.82,16.25 184.87,16.31 186.2,16.31 187.03,15.48 189.66,15.48 194.49,10.64 204.68,10.64 204.91,10.87 213.35,10.87 215.29,12.81 215.29,15.37 221.69,21.76 221.69,27.64 226.09,32.04 226.09,34.4 226.75,35.06 226.75,36.38 224.55,38.58 224.55,40.47 224.8,40.73 225.28,40.73 225.45,40.89 225.54,40.89 225.6,40.96 v2(225.6,41.09)
  BOTTOM w0.089: v2(165.37,37.19) 165.24,37.19 165.09,37.34 UH1.L31
  BOTTOM w0.114: JSSD1.17 224.67,41.05 224.9,40.82 225.38,40.82 225.6,41.05 v2(225.6,41.09)
PCIE_PRX_DTX_N12: length 114.1
  IN5 w0.089: 165.08,28.24 165.08,28.32 165.08,28.33 165.08,29.4 164.62,29.86 164.62,34.27 163.53,35.36 163.53,35.76 v2(163.2,36.09)
  IN5 w0.104: 165.08,28.24 165.08,27.14 165.07,27.14 165.07,26.64 166.67,25.04 166.67,20.22 171.04,15.85 175.06,15.85 176.72,14.18 185.94,14.18 186.08,14.04 189.01,14.04 193.81,9.25 205.26,9.25 205.49,9.47 213.93,9.47 216.88,12.42 216.88,14.53 218.69,16.34 219.59,16.34 222.15,18.9 222.15,19.5 224.24,21.58 224.24,28.21 228.48,32.46 228.48,35.77 226.24,38.01 226.24,40.33 226.31,40.4 226.31,43.67 225.93,44.05 v2(225.33,44.05)
  BOTTOM w0.089: UH1.G33 162.96,36.33 v2(163.2,36.09)
  BOTTOM w0.114: JSSD1.5 v2(225.33,44.05)
PCIE_PRX_DTX_N13: length 91.1
  IN5 w0.089: 164.54,28.24 164.54,28.27 164.54,28.27 164.54,29.5 163.9,30.14 163.9,33.37 163.06,34.21 163.06,35.5 162.7,35.85 162.48,35.85 v2(162.37,35.96)
  IN5 w0.104: v2(225.63,20.13) 225.33,19.83 223.07,19.83 222.68,19.44 222.68,16.1 220.45,13.87 218.9,13.87 213.65,8.62 204.04,8.62 203.82,8.84 193.64,8.84 188.84,13.63 185.91,13.63 185.84,13.7 176.57,13.7 175.01,15.27 170,15.27 167.57,17.7 167.57,18.68 166.26,19.98 166.26,24.87 164.54,26.59 164.54,28.24
  BOTTOM w0.089: v2(162.37,35.96) 162.71,35.62 UH1.G35
  BOTTOM w0.114: v2(225.63,20.13) 225.8,19.96 226.01,19.96 226.2,20.15 JSSD2.5
PCIE_PRX_DTX_N14: length 88.1
  IN1 w0.089: v2(162.42,33.95) 162.42,34.13 162.53,34.24 162.91,34.24 163.58,33.57 165.74,33.57 166.7,32.6 166.7,29.49 167.74,28.45 167.74,28.27 167.74,28.27 167.74,28.24
  IN1 w0.104: 167.74,28.24 167.74,26.96 169.34,25.36 182.73,25.36 184.47,23.62 184.47,22.96 186.58,20.85 187.9,20.85 195.45,13.31 202.79,13.31 203.94,14.45 208.98,14.45 212.34,17.82 214.25,17.82 216.15,19.72 219.23,19.72 220.05,20.53 226.65,20.53 227.92,19.26 228.6,19.26 229.5,18.36 229.5,18.21 229.24,17.95 v2(229.2,17.95)
  BOTTOM w0.089: UH1.D39 161.9,34.06 162.31,34.06 v2(162.42,33.95)
  BOTTOM w0.114: JSSD2.17 227.81,17.15 228.08,16.87 229.2,16.87 229.46,17.14 229.46,17.72 229.4,17.79 229.4,17.89 229.34,17.95 v2(229.2,17.95)
PCIE_PRX_DTX_N15: length 83
  IN1 w0.089: v2(162.81,32.97) 162.59,33.19 162.59,33.37 162.8,33.58 163.06,33.58 163.72,32.93 163.72,32.36 163.72,31.9 167.04,28.58 167.04,28.27 167.04,28.26 167.04,28.24
  IN1 w0.104: 167.04,28.24 167.04,26.8 169.57,24.27 171.05,24.27 171.54,24.76 182.41,24.76 183.87,23.3 183.87,22.67 186.29,20.25 187.66,20.25 195.2,12.71 203.05,12.71 204.2,13.85 210.24,13.85 213.55,17.17 215.75,17.17 216.69,18.11 222.16,18.11 222.85,17.42 223.67,17.42 223.88,17.62 223.88,17.91 v2(224.01,18.04)
  BOTTOM w0.089: UH1.F41 162.48,33.04 162.73,33.04 v2(162.81,32.97)
  BOTTOM w0.114: v2(224.01,18.04) 223.65,17.68 223.65,16.85 225.19,15.31 225.19,14.33 225.54,13.98 225.87,13.98 226.04,14.15 JSSD2.29
PCIE_PRX_DTX_N16: length 93
  IN1 w0.089: v2(162.16,31.71) 162.16,31.82 162.29,31.95 162.47,31.95 162.6,31.82 162.6,31.69 164.12,30.17 164.75,30.17 165.94,28.98 165.94,28.27 165.94,28.27 165.94,28.24
  IN1 w0.104: 165.94,28.24 165.94,27.05 169.39,23.6 175.47,23.6 176.02,24.15 179.54,24.15 181.68,22.01 183.67,22.01 186.04,19.65 187.41,19.65 194.95,12.1 203.3,12.1 204.45,13.25 210.62,13.25 213.94,16.56 216.05,16.56 216.98,17.49 221.74,17.49 222.41,16.82 224.56,16.82 224.78,17.04 228.22,17.04 228.44,16.82 230.52,16.82 231.07,17.36 231.07,17.87 v2(231.12,17.92)
  BOTTOM w0.089: v2(162.16,31.71) 161.87,31.71 161.69,31.53 UH1.D43
  BOTTOM w0.114: v2(231.12,17.92) 231.08,17.88 231.08,13.24 228.49,10.65 JSSD2.43
PCIE_PRX_DTX_P5: length 140
  IN4 w0.089: 159.47,52.99 159.47,53.01 159.47,53.01 159.47,53.07 159.48,53.07 159.48,53.36 159.04,53.8 158.97,53.8 158.95,53.81
  IN4 w0.097: v2(164.67,43.76) 164.91,43.52 164.99,43.52 165.11,43.64 165.11,44.23 164.28,45.06 164.28,46 164.28,47.25 163.2,48.34 161.29,48.34 160.36,49.27 160.36,50.7 159.47,51.59 159.47,52.99
  IN4 w0.147: 158.95,53.81 158.83,53.94 156.92,53.94 155.82,55.04 155.82,76.45 157.94,78.57 160.82,78.57 165.11,82.86 165.11,84.55 168.79,88.23 169.56,88.23 172.67,91.34 172.67,101.81 171.7,102.79 171.7,138.39 177.18,143.87 178.33,143.87 178.97,144.51 193.07,144.51 193.68,145.12 193.68,145.39 v2(193.56,145.5)
  BOTTOM w0.089: v2(164.67,43.76) 164.97,43.46 UH1.L19
  BOTTOM w0.114: v2(193.56,145.5) 193.82,145.5 193.98,145.66 194.73,145.66 195.23,145.17 196.07,145.17 CL1.2
PCIE_PRX_DTX_P5_C: length 3.7
  BOTTOM w0.114: CL1.1 197.32,145.41 197.77,144.96 198.41,144.96 198.63,145.18 198.63,145.2 199.01,145.58 199.03,145.58 199.27,145.82 199.27,146.04 199.09,146.21 UL1.30
PCIE_PRX_DTX_P6: length 190.2
  IN4 w0.147: v2(296.73,58.35) 294.68,58.35 279.46,43.12 277.05,43.12 272.94,39.01 271,39.01 270.28,38.29 265.77,38.29 265.24,37.75 251.52,37.75 236.02,22.25 234.2,22.25 232.07,20.12 231.36,20.12 230.32,19.08 228.73,19.08 228.14,18.48 223.03,18.48 222.89,18.34 219.23,18.34 215.5,14.61 212.95,14.61 209.61,11.27 194.37,11.27 192.28,13.36 166.89,13.36 164.8,15.45 164.8,21.42 160.54,25.67 160.54,28.46 160.42,28.58 160.42,40.69 160.96,41.23 162.79,41.23 162.92,41.36 162.92,41.57 162.92,41.59 v2(162.82,41.69)
  BOTTOM w0.089: UH1.E22 162.15,42.36 v2(162.82,41.69)
  BOTTOM w0.114: v2(296.73,58.35) 296.79,58.4 298.61,58.4 300.33,60.11 300.64,60.11 300.75,60 JWLAN.33
PCIE_PRX_DTX_P9: length 106
  IN5 w0.089: v2(163.94,37.15) 163.74,36.94 163.74,36.76 163.9,36.6 164.35,36.6 164.8,36.16 164.8,35.52 165.18,35.14 165.18,34.57 165.86,33.88 165.86,31.63 165.62,31.39 165.62,30.07 165.86,29.82 165.86,28.27 165.87,28.27 165.87,28.24
  IN5 w0.104: v2(227.91,35.18) 227.51,34.79 227.34,34.79 226.9,34.35 226.9,32 223.41,28.51 223.41,22 220.91,19.5 220.91,18.98 220.55,18.62 219.61,18.62 215.99,15 215.99,12.66 213.6,10.27 205.16,10.27 204.93,10.04 194.14,10.04 189.34,14.84 186.52,14.84 185.8,15.56 185,15.56 184.43,14.99 177.08,14.99 174.66,17.41 170.6,17.41 167.47,20.55 167.47,25.37 165.87,26.97 165.87,28.24
  BOTTOM w0.101: UH1.H31 163.56,37.55 v2(163.94,37.15)
  BOTTOM w0.114: v2(227.91,35.18) 227.91,35.14 227.65,34.89 224.8,34.89 224.64,35.05 JSSD1.41
PCIE_PRX_DTX_P10: length 121.9
  IN5 w0.089: 163.59,28.24 163.59,28.27 163.6,28.27 163.6,29.51 161.56,31.55 161.56,33.91 161.88,34.22 161.88,35.08 161.76,35.19 161.76,36.23 162.19,36.66 162.49,36.66 162.62,36.79 162.62,38.06 162.49,38.19 v2(162.37,38.19)
  IN5 w0.104: v2(227.19,38.47) 227.16,38.47 227.03,38.33 227.03,38.08 229.08,36.02 229.08,31.62 225.92,28.45 225.92,23.93 226.37,23.48 226.37,14.81 224.47,12.91 219.08,12.91 213.98,7.82 203.6,7.82 203.38,8.04 193.31,8.04 188.51,12.84 185.11,12.84 185.05,12.9 181.57,12.9 180.68,12.01 176.45,12.01 174.03,14.44 169.46,14.44 166.14,17.76 166.14,18.82 165.47,19.49 165.47,24.54 163.59,26.42 163.59,28.24
  BOTTOM w0.089: v2(162.37,38.19) 162.37,38.46 162.09,38.74 UH1.E29
  BOTTOM w0.114: JSSD1.31 226.59,37.55 227.03,37.99 227.03,38.3 v2(227.19,38.47)
PCIE_PRX_DTX_P11: length 107.9
  IN5 w0.089: 166.96,28.24 166.96,28.34 166.52,28.77 166.52,33.61 165.68,34.45 165.68,36.42 165.55,36.55 165.21,36.55 v2(164.57,37.19)
  IN5 w0.104: v2(225.6,40.51) 224.87,40.51 224.74,40.38 224.74,38.66 226.94,36.46 226.94,34.98 226.29,34.32 226.29,31.96 221.88,27.56 221.88,21.68 215.49,15.29 215.49,12.73 213.43,10.68 204.99,10.68 204.76,10.45 194.41,10.45 189.58,15.28 186.95,15.28 186.12,16.12 184.95,16.12 184.27,15.43 180.51,15.43 179.42,16.52 177.82,16.52 176.07,18.27 173.59,18.27 173.29,18.58 170.02,18.58 167.88,20.72 167.88,25.54 166.96,26.46 166.96,28.24
  BOTTOM w0.089: v2(164.57,37.19) 164.57,37.46 164.44,37.59 UH1.K31
  BOTTOM w0.114: JSSD1.19 224.75,40.55 224.8,40.6 225.51,40.6 v2(225.6,40.51)
PCIE_PRX_DTX_P12: length 114
  IN5 w0.089: v2(163.98,36.06) 163.7,35.79 163.7,35.44 164.8,34.34 164.8,29.94 165.26,29.47 165.26,28.27 165.27,28.27 165.27,28.24
  IN5 w0.104: v2(225.41,43.28) 225.41,43.59 225.67,43.85 225.85,43.85 226.12,43.59 226.12,40.48 226.05,40.41 226.05,37.93 228.29,35.69 228.29,32.54 224.04,28.29 224.04,21.66 221.96,19.58 221.96,18.98 219.51,16.53 218.61,16.53 216.69,14.61 216.69,12.5 213.85,9.67 205.41,9.67 205.18,9.44 193.89,9.44 189.09,14.24 186.16,14.24 186.02,14.38 176.8,14.38 175.14,16.04 171.12,16.04 166.86,20.3 166.86,25.12 165.27,26.72 165.27,27.06 165.27,28.24
  BOTTOM w0.089: UH1.H33 163.72,36.32 v2(163.98,36.06)
  BOTTOM w0.114: JSSD1.7 224.6,43.55 224.85,43.8 225.03,43.8 225.17,43.66 225.31,43.66 225.41,43.57 v2(225.41,43.28)
