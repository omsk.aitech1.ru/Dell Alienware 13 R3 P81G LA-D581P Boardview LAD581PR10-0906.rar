# Allegro board LAD581PR10-0906.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SKY-S-PCH_BGA_837P-T
  round 0.305 smd: A2(-0.354,0) A3(-0.854,0) A4(-1.355,0) A42(-20.273,0) A43(-20.773,0) A44(-21.274,0) AA17(-7.715,10.039) AA18(-8.49,10.039) AA20(-9.264,10.039) AA21(-10.039,10.039) AA23(-10.814,10.039) AA25(-11.588,10.039) AA26(-12.363,10.039) AA28(-13.138,10.039) AA29(-13.913,10.039) AB7(-2.638,10.147) AB8(-3.4,10.147) AB10(-4.162,10.147) AB11(-4.924,10.147) AB13(-5.686,10.147) AB14(-6.448,10.147) AB15(-7.007,10.147) AB31(-14.62,10.147) AB32(-15.179,10.147) AB33(-15.941,10.147) AB35(-16.703,10.147) AB36(-17.465,10.147) AB38(-18.227,10.147) AB39(-18.989,10.147) AC17(-7.715,10.814) AC18(-8.49,10.814) AC20(-9.264,10.814) AC21(-10.039,10.814) AC23(-10.814,10.814) AC25(-11.588,10.814) AC26(-12.363,10.814) AC28(-13.138,10.814) AC29(-13.913,10.814) AD7(-2.638,11.481) AD8(-3.4,11.481) AD10(-4.162,11.481) AD11(-4.924,11.481) AD13(-5.686,11.481) AD14(-6.448,11.481) AD15(-7.007,11.481) AD31(-14.62,11.481) AD32(-15.179,11.481) AD33(-15.941,11.481) AD35(-16.703,11.481) AD36(-17.465,11.481) AD38(-18.227,11.481) AD39(-18.989,11.481) AE17(-7.715,11.588) AE18(-8.49,11.588) AE20(-9.264,11.588) AE21(-10.039,11.588) AE23(-10.814,11.588) AE25(-11.588,11.588) AE26(-12.363,11.588) AE28(-13.138,11.588) AE29(-13.913,11.588) AF17(-7.715,12.363) AF18(-8.49,12.363) AF20(-9.264,12.363) AF21(-10.039,12.363) AF23(-10.814,12.363) AF25(-11.588,12.363) AF26(-12.363,12.363) AF28(-13.138,12.363) AF29(-13.913,12.363) AG7(-2.638,12.586) AG8(-3.4,12.586) AG10(-4.162,12.586) AG11(-4.924,12.586) AG13(-5.686,12.586) AG14(-6.448,12.586) AG15(-7.007,12.586) AG31(-14.62,12.586) AG32(-15.179,12.586) AG33(-15.941,12.586) AG35(-16.703,12.586) AG36(-17.465,12.586) AG38(-18.227,12.586) AG39(-18.989,12.586) AH17(-7.715,13.138) AH18(-8.49,13.138) AH20(-9.264,13.138) AH21(-10.039,13.138) AH23(-10.814,13.138) AH25(-11.588,13.138) AH26(-12.363,13.138) AH28(-13.138,13.138) AH29(-13.913,13.138) AJ7(-2.74,13.767) AJ8(-3.502,13.767) AJ10(-4.264,13.767) AJ11(-5.026,13.767) AJ13(-5.788,13.767) AJ14(-6.499,13.767) AJ15(-7.007,13.767) AJ17(-7.715,13.913) AJ18(-8.49,13.913) AJ20(-9.264,13.913) AJ21(-10.039,13.913) AJ23(-10.814,13.913) AJ25(-11.588,13.913) AJ26(-12.363,13.913) AJ28(-13.138,13.913) AJ29(-13.913,13.913) AJ31(-14.62,13.767) AJ32(-15.179,13.767) AJ33(-15.941,13.767) AJ35(-16.703,13.767) AJ36(-17.465,13.767) AJ38(-18.227,13.767) AJ39(-18.989,13.767) AL7(-2.74,14.885) AL8(-3.502,14.885) AL10(-4.264,14.885) AL11(-5.026,14.885) AL13(-5.788,14.885) AL17(-7.861,14.62) AL19(-9.042,14.62) AL22(-10.147,14.62) AL24(-11.481,14.62) AL27(-12.586,14.62) AL29(-13.767,14.62) AL32(-15.154,14.91) AL33(-15.916,14.91) AL35(-16.678,14.91) AL36(-17.44,14.91) AL38(-18.202,14.91) AL39(-18.964,14.91) AM15(-6.718,15.154) AM17(-7.861,15.179) AM19(-9.042,15.179) AM22(-10.147,15.179) AM24(-11.481,15.179) AM27(-12.586,15.179) AM29(-13.767,15.128) AN7(-2.791,15.85) AN8(-3.553,15.799) AN10(-4.315,15.799) AN11(-5.061,15.84) AN15(-6.718,15.916) AN17(-7.861,15.941) AN19(-9.042,15.941) AN22(-10.147,15.941) AN24(-11.481,15.941) AN27(-12.586,15.941) AN29(-13.767,15.84) AN31(-14.885,15.84) AN36(-17.284,15.901) AN38(-18.046,15.901) AN39(-18.808,15.901) AP11(-4.774,16.365) AR7(-2.815,16.851) AR9(-3.73,16.891) AR15(-6.718,16.678) AR17(-7.861,16.703) AR19(-9.042,16.703) AR22(-10.147,16.703) AR24(-11.481,16.703) AR27(-12.586,16.703) AR29(-13.767,16.602) AR31(-14.885,16.602) AR33(-15.84,16.566) AR34(-16.365,16.854) AR38(-18.21,16.882) AR39(-18.972,16.882) AT9(-3.876,17.527) AT10(-4.503,17.477) AT13(-5.727,17.284) AT15(-6.718,17.44) AT17(-7.861,17.465) AT19(-9.042,17.465) AT22(-10.147,17.465) AT24(-11.481,17.465) AT27(-12.586,17.465) AT29(-13.767,17.364) AT31(-14.885,17.364) AT33(-15.799,17.313) AT36(-17.477,17.125) AU7(-2.878,17.808) AU35(-16.891,17.897) AU36(-17.527,17.751) AU39(-18.804,17.955) AV6(-2.577,18.459) AV11(-4.745,18.21) AV13(-5.727,18.046) AV15(-6.718,18.202) AV17(-7.861,18.227) AV19(-9.042,18.227) AV22(-10.147,18.227) AV24(-11.481,18.227) AV27(-12.586,18.227) AV29(-13.767,18.126) AV31(-14.885,18.126) AV33(-15.799,18.075) AW9(-3.673,18.804) AW11(-4.745,18.972) AW13(-5.727,18.808) AW15(-6.718,18.964) AW17(-7.861,18.989) AW19(-9.042,18.989) AW22(-10.147,18.989) AW24(-11.481,18.989) AW27(-12.586,18.989) AW29(-13.767,18.888) AW31(-14.885,18.888) AW33(-15.85,18.837) AW35(-16.851,18.813) AW37(-17.808,18.75) AY5(-2.05,19.399) AY38(-18.459,19.051) B1(0,0.354) B2(-0.484,0.484) B3(-0.99,0.488) B43(-20.614,0.51) B44(-21.144,0.484) B45(-21.628,0.354) BA40(-19.399,19.577) BB1(0,20.273) BB45(-21.628,20.273) BC1(0,20.773) BC2(-0.488,20.637) BC44(-21.118,20.614) BC45(-21.628,20.773) BD1(0,21.274) BD2(-0.484,21.144) BD3(-1.013,21.118) BD43(-20.637,21.139) BD44(-21.144,21.144) BD45(-21.628,21.274) BE2(-0.354,21.628) BE3(-0.854,21.628) BE4(-1.355,21.628) BE42(-20.273,21.628) BE43(-20.773,21.628) BE44(-21.274,21.628) C1(0,0.854) C2(-0.51,1.013) C42(-20.102,0.954) C44(-21.139,0.99) C45(-21.628,0.854) D1(0,1.355) D45(-21.628,1.355) F8(-3.169,2.577) G9(-3.819,2.878) G11(-4.777,2.815) G13(-5.778,2.791) G15(-6.743,2.74) G17(-7.861,2.74) G19(-9.042,2.638) G22(-10.147,2.638) G24(-11.481,2.638) G27(-12.586,2.638) G29(-13.767,2.638) G31(-14.91,2.664) G33(-15.901,2.82) G35(-16.882,2.656) G37(-17.955,2.823) H13(-5.829,3.553) H15(-6.743,3.502) H17(-7.861,3.502) H19(-9.042,3.4) H22(-10.147,3.4) H24(-11.481,3.4) H27(-12.586,3.4) H29(-13.767,3.4) H31(-14.91,3.426) H33(-15.901,3.582) H35(-16.882,3.418) J7(-2.823,3.673) J10(-4.101,3.876) J11(-4.737,3.73) J39(-18.75,3.819) K10(-4.151,4.503) K13(-5.829,4.315) K15(-6.743,4.264) K17(-7.861,4.264) K19(-9.042,4.162) K22(-10.147,4.162) K24(-11.481,4.162) K27(-12.586,4.162) K29(-13.767,4.162) K31(-14.91,4.188) K33(-15.901,4.344) K36(-17.125,4.151) K37(-17.751,4.101) L7(-2.656,4.745) L8(-3.418,4.745) L12(-5.263,4.774) L13(-5.788,5.061) L15(-6.743,5.026) L17(-7.861,5.026) L19(-9.042,4.924) L22(-10.147,4.924) L24(-11.481,4.924) L27(-12.586,4.924) L29(-13.767,4.924) L31(-14.91,4.95) L37(-17.897,4.737) L39(-18.813,4.777) M35(-16.854,5.263) N7(-2.82,5.727) N8(-3.582,5.727) N10(-4.344,5.727) N15(-6.743,5.788) N17(-7.861,5.788) N19(-9.042,5.686) N22(-10.147,5.686) N24(-11.481,5.686) N27(-12.586,5.686) N29(-13.767,5.686) N31(-14.91,5.712) N35(-16.566,5.788) N36(-17.313,5.829) N38(-18.075,5.829) N39(-18.837,5.778) P17(-7.861,6.499) P19(-9.042,6.448) P22(-10.147,6.448) P24(-11.481,6.448) P27(-12.586,6.448) P29(-13.767,6.448) P31(-14.91,6.474) R7(-2.664,6.718) R8(-3.426,6.718) R10(-4.188,6.718) R11(-4.95,6.718) R13(-5.712,6.718) R14(-6.474,6.718) R17(-7.861,7.007) R19(-9.042,7.007) R22(-10.147,7.007) R24(-11.481,7.007) R27(-12.586,7.007) R29(-13.767,7.007) R33(-15.84,6.743) R35(-16.602,6.743) R36(-17.364,6.743) R38(-18.126,6.743) R39(-18.888,6.743) U7(-2.638,7.861) U8(-3.4,7.861) U10(-4.162,7.861) U11(-4.924,7.861) U13(-5.686,7.861) U14(-6.448,7.861) U15(-7.007,7.861) U17(-7.715,7.715) U18(-8.49,7.715) U20(-9.264,7.715) U21(-10.039,7.715) U23(-10.814,7.715) U25(-11.588,7.715) U26(-12.363,7.715) U28(-13.138,7.715) U29(-13.913,7.715) U31(-14.62,7.861) U32(-15.128,7.861) U33(-15.84,7.861) U35(-16.602,7.861) U36(-17.364,7.861) U38(-18.126,7.861) U39(-18.888,7.861) V17(-7.715,8.49) V18(-8.49,8.49) V20(-9.264,8.49) V21(-10.039,8.49) V23(-10.814,8.49) V25(-11.588,8.49) V26(-12.363,8.49) V28(-13.138,8.49) V29(-13.913,8.49) W7(-2.638,9.042) W8(-3.4,9.042) W10(-4.162,9.042) W11(-4.924,9.042) W13(-5.686,9.042) W14(-6.448,9.042) W15(-7.007,9.042) W31(-14.62,9.042) W32(-15.179,9.042) W33(-15.941,9.042) W35(-16.703,9.042) W36(-17.465,9.042) W38(-18.227,9.042) W39(-18.989,9.042) Y17(-7.715,9.264) Y18(-8.49,9.264) Y20(-9.264,9.264) Y21(-10.039,9.264) Y23(-10.814,9.264) Y25(-11.588,9.264) Y26(-12.363,9.264) Y28(-13.138,9.264) Y29(-13.913,9.264)
  round 0.279 smd: A5(-1.855,0) A41(-19.772,0) BA1(0,19.772) BA45(-21.628,19.772) BE5(-1.855,21.628) BE41(-19.772,21.628) E1(0,1.855) E45(-21.628,1.855)
  round 0.254 smd: A6(-2.356,0) A40(-19.272,0) AB4(-1.411,10.331) AB5(-1.876,10.147) AB41(-19.751,10.147) AD4(-1.393,11.323) AD5(-1.876,11.481) AD41(-19.751,11.481) AF5(-1.929,12.535) AF41(-19.7,12.535) AG4(-1.411,12.605) AJ5(-1.978,13.767) AJ41(-19.751,13.767) AL4(-1.411,14.878) AL5(-1.978,14.885) AL41(-19.7,14.91) AN4(-1.393,15.87) AN5(-2.029,15.977) AN41(-19.57,15.901) AR5(-1.927,16.995) AR41(-19.734,16.882) AU41(-19.851,17.904) AV4(-1.585,18.134) AW4(-1.379,19.018) AW42(-20.054,18.629) AY1(0,19.272) AY45(-21.628,19.272) B6(-2.364,0.518) B25(-12.039,0.508) B40(-19.515,0.459) BA4(-1.212,19.933) BA5(-2.047,19.909) BA9(-3.723,19.851) BA11(-4.745,19.734) BA13(-5.727,19.57) BA15(-6.718,19.7) BA17(-7.861,19.751) BA20(-9.092,19.7) BA22(-10.147,19.751) BA24(-11.481,19.751) BA26(-12.535,19.699) BA29(-13.767,19.65) BA31(-14.885,19.65) BA33(-15.977,19.599) BA35(-16.995,19.7) BA41(-19.909,19.581) BB3(-0.652,20.158) BB7(-2.998,20.054) BB38(-18.134,20.043) BB39(-19.018,20.248) BB41(-19.933,20.416) BB43(-20.674,20.102) BC4(-1.526,20.674) BC42(-20.158,20.976) BE6(-2.356,21.628) BE40(-19.272,21.628) C10(-4.089,1.087) C28(-13.183,1.087) C37(-17.729,1.087) D3(-0.954,1.526) D5(-1.694,1.212) D7(-2.61,1.379) D8(-3.493,1.585) D10(-4.476,1.411) D15(-6.75,1.411) D17(-8.031,1.393) D19(-9.023,1.411) D24(-11.296,1.411) D27(-12.578,1.393) D29(-13.569,1.411) D31(-14.851,1.393) D33(-15.843,1.411) D36(-17.124,1.393) D39(-18.629,1.574) D43(-20.976,1.47) E5(-1.719,2.047) E6(-2.229,2.05) E11(-4.632,1.927) E13(-5.651,2.029) E15(-6.743,1.978) E17(-7.861,1.978) E20(-9.092,1.929) E22(-10.147,1.876) E24(-11.481,1.876) E26(-12.535,1.927) E29(-13.767,1.876) E31(-14.91,1.927) E33(-15.901,2.058) E35(-16.882,1.894) E37(-17.904,1.776) E41(-19.581,1.719) E42(-20.416,1.694) F1(0,2.356) F41(-19.577,2.229) F44(-21.11,2.364) F45(-21.628,2.356) G4(-1.574,2.998) G42(-20.248,2.61) H3(-0.926,3.423) H40(-19.051,3.169) H42(-20.043,3.493) J3(-1.087,3.898) J5(-1.776,3.723) K4(-1.393,4.503) K42(-20.217,4.476) K43(-20.54,4.089) L5(-1.894,4.745) L41(-19.7,4.632) N4(-1.411,5.785) N5(-2.058,5.727) N41(-19.599,5.651) R5(-1.927,6.718) R41(-19.65,6.743) U4(-1.411,8.058) U5(-1.876,7.861) U41(-19.65,7.861) V3(-1.087,8.445) W4(-1.393,9.05) Y5(-1.927,9.092) Y41(-19.699,9.092)
  oval 0.203x0.254 smd: A7(-2.92,0) A9(-3.962,0) A12(-5.219,0) A14(-6.261,0) A16(-7.492,0) A18(-8.534,0) A21(-9.766,0) A23(-10.807,0) A25(-12.039,0) A28(-13.08,0) A30(-14.312,0) A32(-15.354,0) A35(-16.586,0) A37(-17.652,0) A39(-18.707,0) AA4(-1.487,9.588) AA42(-20.138,9.766) AE4(-1.489,11.862) AE42(-20.14,12.039) AK4(-1.489,14.135) AK42(-20.14,14.312) AP4(-1.489,16.408) AR42(-20.14,16.586) B7(-2.87,0.508) B8(-3.555,0.386) B10(-4.089,0.579) B11(-4.603,0.418) B12(-5.219,0.508) B13(-5.88,0.386) B14(-6.363,0.579) B15(-6.877,0.418) B16(-7.492,0.508) B18(-8.153,0.386) B19(-8.636,0.579) B20(-9.15,0.418) B21(-9.766,0.508) B22(-10.426,0.386) B23(-10.909,0.579) B24(-11.423,0.418) B27(-12.699,0.386) B28(-13.183,0.579) B29(-13.696,0.418) B30(-14.312,0.508) B31(-14.973,0.386) B32(-15.456,0.579) B33(-15.97,0.418) B35(-16.586,0.508) B36(-17.246,0.386) B37(-17.729,0.579) B38(-18.205,0.418) B39(-18.757,0.508) BB10(-4.503,20.235) BB13(-5.785,20.217) BB15(-6.776,20.235) BB17(-8.058,20.217) BB19(-9.05,20.235) BB22(-10.331,20.217) BB24(-11.323,20.235) BB27(-12.605,20.217) BB29(-13.596,20.235) BB31(-14.878,20.217) BB33(-15.87,20.235) BB36(-17.151,20.217) BC8(-3.423,20.702) BC9(-3.898,20.54) BC10(-4.478,20.743) BC13(-5.658,20.702) BC14(-6.172,20.54) BC15(-6.751,20.743) BC17(-7.931,20.702) BC18(-8.445,20.54) BC19(-9.024,20.743) BC22(-10.204,20.702) BC23(-10.718,20.54) BC24(-11.298,20.743) BC26(-12.478,20.702) BC27(-12.992,20.54) BC29(-13.571,20.743) BC31(-14.751,20.702) BC32(-15.265,20.54) BC33(-15.844,20.743) BC35(-17.024,20.702) BC36(-17.538,20.54) BC38(-18.168,20.743) BD6(-2.113,21.168) BD7(-2.87,21.12) BD8(-3.423,21.21) BD9(-3.898,21.048) BD10(-4.381,21.242) BD11(-5.042,21.12) BD13(-5.658,21.21) BD14(-6.172,21.048) BD15(-6.655,21.242) BD16(-7.315,21.12) BD17(-7.931,21.21) BD18(-8.445,21.048) BD19(-8.928,21.242) BD21(-9.588,21.12) BD22(-10.204,21.21) BD23(-10.718,21.048) BD24(-11.201,21.242) BD25(-11.862,21.12) BD26(-12.478,21.21) BD27(-12.992,21.048) BD28(-13.475,21.242) BD30(-14.135,21.12) BD31(-14.751,21.21) BD32(-15.265,21.048) BD33(-15.748,21.242) BD34(-16.408,21.12) BD35(-17.024,21.21) BD36(-17.538,21.048) BD38(-18.072,21.242) BD39(-18.758,21.12) BE7(-2.92,21.628) BE9(-3.975,21.628) BE11(-5.042,21.628) BE14(-6.274,21.628) BE16(-7.315,21.628) BE18(-8.547,21.628) BE21(-9.588,21.628) BE23(-10.82,21.628) BE25(-11.862,21.628) BE28(-13.094,21.628) BE30(-14.135,21.628) BE32(-15.367,21.628) BE34(-16.408,21.628) BE37(-17.666,21.628) BE39(-18.707,21.628) C8(-3.459,0.885) C11(-4.603,0.926) C13(-5.783,0.885) C14(-6.363,1.087) C15(-6.877,0.926) C17(-8.057,0.885) C19(-8.636,1.087) C20(-9.15,0.926) C22(-10.33,0.885) C23(-10.909,1.087) C24(-11.423,0.926) C27(-12.603,0.885) C29(-13.696,0.926) C31(-14.877,0.885) C32(-15.456,1.087) C33(-15.97,0.926) C36(-17.15,0.885) C38(-18.205,0.926) D13(-5.758,1.393) D22(-10.305,1.393) L4(-1.487,5.042) M42(-20.138,5.219) T4(-1.487,7.315) T42(-20.138,7.492)
  oval 0.254x0.203 smd: AA1(0,9.588) AA2(-0.508,9.588) AA44(-21.12,9.766) AA45(-21.628,9.766) AB2(-0.418,10.204) AB3(-0.926,10.204) AB42(-20.235,10.305) AB43(-20.743,10.33) AB44(-21.242,10.426) AC1(0,10.82) AC2(-0.579,10.718) AC3(-1.087,10.718) AC43(-20.54,10.909) AC44(-21.048,10.909) AC45(-21.628,10.807) AD2(-0.386,11.201) AD3(-0.885,11.298) AD42(-20.217,11.296) AD43(-20.702,11.423) AD44(-21.21,11.423) AE1(0,11.862) AE2(-0.508,11.862) AE44(-21.12,12.039) AE45(-21.628,12.039) AF2(-0.418,12.478) AF3(-0.926,12.478) AG2(-0.579,12.992) AG3(-1.087,12.992) AG42(-20.235,12.578) AG43(-20.743,12.603) AG44(-21.242,12.699) AH1(0,13.094) AH2(-0.386,13.475) AH43(-20.54,13.183) AH44(-21.048,13.183) AH45(-21.628,13.08) AJ3(-0.885,13.571) AJ4(-1.393,13.596) AJ42(-20.217,13.569) AJ43(-20.702,13.696) AJ44(-21.21,13.696) AK1(0,14.135) AK2(-0.508,14.135) AK44(-21.12,14.312) AK45(-21.628,14.312) AL2(-0.418,14.751) AL3(-0.926,14.751) AL42(-20.235,14.851) AL43(-20.743,14.877) AL44(-21.242,14.973) AM1(0,15.367) AM2(-0.579,15.265) AM3(-1.087,15.265) AM43(-20.54,15.456) AM44(-21.048,15.456) AM45(-21.628,15.354) AN2(-0.386,15.748) AN3(-0.885,15.844) AN42(-20.217,15.843) AN43(-20.702,15.97) AN44(-21.21,15.97) AP1(0,16.408) AP2(-0.508,16.408) AR2(-0.418,17.024) AR3(-0.926,17.024) AR44(-21.12,16.586) AR45(-21.628,16.586) AT2(-0.579,17.538) AT3(-1.087,17.538) AT4(-1.411,17.151) AT42(-20.235,17.124) AT43(-20.743,17.15) AT44(-21.242,17.246) AU1(0,17.666) AU43(-20.54,17.729) AU44(-21.048,17.729) AU45(-21.628,17.652) AV2(-0.386,18.072) AV3(-0.885,18.168) AV43(-20.702,18.205) AV44(-21.21,18.205) AW1(0,18.707) AW2(-0.508,18.758) AW44(-21.12,18.757) AW45(-21.628,18.707) AY44(-21.168,19.515) BB11(-5.042,20.14) BB16(-7.315,20.14) BB21(-9.588,20.14) BB25(-11.862,20.138) BB30(-14.135,20.138) BB34(-16.408,20.138) D12(-5.219,1.489) D16(-7.492,1.489) D21(-9.766,1.489) D25(-12.039,1.487) D30(-14.312,1.487) D35(-16.586,1.487) F2(-0.459,2.113) G1(0,2.92) G2(-0.508,2.87) G44(-21.12,2.87) G45(-21.628,2.92) H2(-0.418,3.423) H43(-20.743,3.459) H44(-21.242,3.555) J1(0,3.975) J2(-0.579,3.898) J45(-21.628,3.962) K2(-0.386,4.381) K3(-0.885,4.478) K44(-21.048,4.089) L1(0,5.042) L2(-0.508,5.042) L43(-20.702,4.603) L44(-21.21,4.603) M44(-21.12,5.219) M45(-21.628,5.219) N2(-0.418,5.658) N3(-0.926,5.658) N42(-20.235,5.758) N43(-20.743,5.783) N44(-21.242,5.88) P1(0,6.274) P2(-0.579,6.172) P3(-1.087,6.172) P43(-20.54,6.363) P44(-21.048,6.363) P45(-21.628,6.261) R2(-0.386,6.655) R3(-0.885,6.751) R4(-1.393,6.776) R42(-20.217,6.75) R43(-20.702,6.877) R44(-21.21,6.877) T1(0,7.315) T2(-0.508,7.315) T44(-21.12,7.492) T45(-21.628,7.492) U2(-0.418,7.931) U3(-0.926,7.931) U42(-20.235,8.031) U43(-20.743,8.057) V1(0,8.547) V2(-0.579,8.445) V44(-21.242,8.153) V45(-21.628,8.534) W2(-0.386,8.928) W3(-0.885,9.024) W42(-20.217,9.023) W43(-20.54,8.636) W44(-21.048,8.636) Y43(-20.702,9.15) Y44(-21.21,9.15)
  round 0.368 smd: AY2(-0.518,19.263) BD40(-19.263,21.11) C4(-1.47,0.652)
SN74CBT3257CPWR_TSSOP16
  oval 0.381x1.651 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(4.55,5.775) 10(3.9,5.775) 11(3.25,5.775) 12(2.6,5.775) 13(1.95,5.775) 14(1.3,5.775) 15(0.65,5.775) 16(0,5.775)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_TST71-N-220-T170-S017_2P
  rect 0.61x1.499 smd: 1(0,0) 2(3.2,0)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
TAITW_PUBAUE-09FLBS1FF4H0_9P-T
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.43) 11(-11.35,-2.43)
  oval 1.397x2.311 hole 0.787x1.702: 12(-11.35,-9.23) 13(4.35,-9.23)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SZ14FU_SSOP5
  oval 0.381x1.448 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.675) 5(0,1.675)
TE_2260531-1_46P-T
  oval 0.508x1.803 smd: 1(0,0) 2(0.8,0) 45(18.6,0) 46(19.4,0)
  oval 0.203x1.803 smd: 3(1.55,0) 4(1.95,0) 5(2.35,0) 6(2.75,0) 7(3.15,0) 8(3.55,0) 9(3.95,0) 10(4.35,0) 11(4.75,0) 12(5.15,0) 13(5.55,0) 14(5.95,0) 15(6.35,0) 16(6.75,0) 17(7.15,0) 18(7.55,0) 19(7.95,0) 20(8.35,0) 21(8.75,0) 22(9.15,0) 23(9.55,0) 24(9.95,0) 25(10.35,0) 26(10.75,0) 27(11.15,0) 28(11.55,0) 29(11.95,0) 30(12.35,0) 31(12.75,0) 32(13.15,0) 33(13.55,0) 34(13.95,0) 35(14.35,0) 36(14.75,0) 37(15.15,0) 38(15.55,0) 39(15.95,0) 40(16.35,0) 41(16.75,0) 42(17.15,0) 43(17.55,0) 44(17.95,0)
  custom 0.688x0.688 hole 0.787x2.007: 47(25.8,0) 50(-6.7,0)
  oval 1.549x2.769 hole 0.787x2.007: 48(25.8,-4.6) 49(-6.7,-4.6)
TLC59116FIRHBR_VQFN32_5X5-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,5.1) 18(3,5.1) 19(2.5,5.1) 20(2,5.1) 21(1.5,5.1) 22(1,5.1) 23(0.5,5.1) 24(0,5.1)
  oval 0.889x0.254 smd: 9(4.3,0.8) 10(4.3,1.3) 11(4.3,1.8) 12(4.3,2.3) 13(4.3,2.8) 14(4.3,3.3) 15(4.3,3.8) 16(4.3,4.3) 25(-0.8,4.3) 26(-0.8,3.8) 27(-0.8,3.3) 28(-0.8,2.8) 29(-0.8,2.3) 30(-0.8,1.8) 31(-0.8,1.3) 32(-0.8,0.8)
  rect 3.454x3.454 smd: 33(1.75,2.55)
TOKO_1239AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2540RTER_QFN16_3X3-S
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,2.95) 10(1,2.95) 11(0.5,2.95) 12(0,2.95)
  oval 1.041x0.254 smd: 5(2.225,0.725) 6(2.225,1.225) 7(2.225,1.725) 8(2.225,2.225) 13(-0.725,2.225) 14(-0.725,1.725) 15(-0.725,1.225) 16(-0.725,0.725)
  rect 1.549x1.549 smd: 17(0.75,1.475)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS25810RVCR_QFN20_4X3-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 11(2.5,3.1) 12(2,3.1) 13(1.5,3.1) 14(1,3.1) 15(0.5,3.1) 16(0,3.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 17(-0.8,2.3) 18(-0.8,1.8) 19(-0.8,1.3) 20(-0.8,0.8)
  rect 2.591x1.6 smd: 21(1.25,1.55)
TPS51212DSCR_SON10_3X3-S
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3-S
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q80EWSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_5YEA27000163IF50Q5_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V25000012_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_FSX3M-25PM20FDO_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
YUQIU_PJ741-F07J1BE-C_6P-T
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(9.5,-5.5) 3(0,-5.2) 4(0,-7.8) 5(9.5,0) 6(9.5,-2.75) 7(0,-2.65)

## Nets
1.2V_B+: PC200.1 PC201.1 PC202.1 PC203.1 PC208.1 PC216.1 PJP203.2 PQ200.5 PR206.1
1V8_AON_ON: QG503.2 RG70.2 UG12.3 UG25.4
1V8_ENP: PC811.1 PR807.1 PR808.1 PU802.5
1V8_MAIN_EN: CG487.1 DG3.2 DG6.1 DG7.2 QG504.2 RG71.2 RG549.1 RG550.1 UG9.BE1 UG12.5 UG26.2
3/5V_B+: PC100.1 PC102.1 PC103.1 PC104.1 PC107.1 PC113.1 PC114.1 PC115.1 PJP103.2 PQ100.5 PQ102.5 PU100.12
3V3_SYS_EN: CG240.1 QG505.2 RG515.2 RG545.2 RG567.2 UG14.4
3V_EN: PR100.1 PU100.6
3V_F383_ON: RE83.1 UE5.128 UE9.4
3VS: C2524.1 J5.2 U17.8 U17.9
3VS_GATE: C258.1 R174.2 U17.5
5V_EN: PR112.1 PU100.20
5VS: C2523.1 J4.2 U17.13 U17.14
+0.6VS: CD12.1 CD13.1 CD14.1 CD15.1 CD32.1 CD88.1 CD89.1 CD90.1 JDIMM1.258 JDIMM2.258 PJP202.2
+0.6VSP: PC205.1 PC206.1 PJP202.1 PU201.2 PU201.20
+0.9V_CIO: CT78.1 CT79.1 CT80.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+0.9V_DP: CT54.1 CT57.1 CT58.1 CT59.1 CT60.1 CT61.1 CT62.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+0.9V_LVR_OUT: CT81.1 CT82.1 CT83.1 CT84.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
+0.9V_PCIE: CT55.1 CT70.1 CT71.1 CT72.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+0.9V_SVR: CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 CT69.1 CT73.1 CT74.1 CT75.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
+0.9V_USB: CT56.1 CT77.1 UT1.R15 UT1.R16
+1.0VS_VGA_PGOOD: PR821.1 PU800.9 UG27.2
+1.0VS_VGAP: PC804.1 PC805.1 PC809.1 PC818.1 PC819.1 PJP801.1 PL800.2 PR804.1
+1.2V_DDR: C2518.1 CD1.1 CD2.1 CD5.1 CD6.1 CD7.1 CD8.1 CD11.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD33.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CH118.1 CH119.1 CH120.1 CH121.1 CH122.1 CH123.1 CH124.1 CH125.1 CH126.1 CH127.1 CH128.1 CH129.1 CH130.1 CH131.1 CH132.1 CH197.1 CPU1.AA6 CPU1.AE12 CPU1.AF5 CPU1.AF6 CPU1.AG5 CPU1.AG9 CPU1.AJ12 CPU1.AL11 CPU1.AP6 CPU1.AP7 CPU1.AR6 CPU1.AR12 CPU1.AT12 CPU1.AW6 CPU1.AY6 CPU1.J5 CPU1.J6 CPU1.K6 CPU1.K12 CPU1.L6 CPU1.L12 CPU1.R6 CPU1.T6 CPU1.W6 CPU1.Y12 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP200.2 PJP201.2 RD35.1 RH206.1 RH207.1 UC1.5 UZ21.1 UZ21.2
+1.2V_VCCPLL_OC: C11.1 CPU1.BH13 CPU1.G11 UZ21.7 UZ21.8
+1.2VP: PC209.1 PC215.1 PJP200.1 PJP201.1 PL201.1 PR205.2 PU201.5 PU201.19
+1.8VA_TBTA_LDO: CT100.1 UT4.K1
+1.8VD_TBTA_LDO: CT99.1 UT4.A2
+1.8VS: CA58.1 CA59.1 CA60.1 CG288.1 CV20.1 CV1056.1 LA3.2 LA4.2 LA5.2 PJP803.2 PR6132.1 PR6229.1 RG70.1 UA4.17 UA4.21 UG12.1 UG12.2 UX1.5 UX2.5
+1.8VSP: PC812.1 PC813.1 PC815.1 PC816.1 PJP803.1 PL801.2 PR810.2
+1.35VS_B+: PC8201.1 PC8202.1 PC8203.1 PC8204.1 PC8213.1 PC8214.1 PC8220.1 PC8221.1 PJP8200.1 PQ8200.2 PQ8201.2 PR8201.2
+1.35VS_VGA: CG80.1 CG81.1 CG82.1 CG83.1 CG84.1 CG85.1 CG86.1 CG87.1 CG88.1 CG89.1 CG90.1 CG91.1 CG97.1 CG98.1 CG99.1 CG100.1 CG101.1 CG102.1 CG103.1 CG104.1 CG105.1 CG106.1 CG115.1 CG116.1 CG117.1 CG118.1 CG119.1 CG120.1 CG121.1 CG122.1 CG123.1 CG124.1 CG125.1 CG126.1 CG132.1 CG133.1 CG134.1 CG135.1 CG136.1 CG137.1 CG138.1 CG139.1 CG140.1 CG141.1 CG150.1 CG151.1 CG152.1 CG153.1 CG154.1 CG155.1 CG156.1 CG157.1 CG158.1 CG159.1 CG160.1 CG161.1 CG167.1 CG168.1 CG169.1 CG170.1 CG171.1 CG172.1 CG173.1 CG174.1 CG175.1 CG176.1 CG184.1 CG185.1 CG186.1 CG187.1 CG188.1 CG189.1 CG190.1 CG191.1 CG192.1 CG193.1 CG194.1 CG195.1 CG196.1 CG197.1 CG198.1 CG199.1 CG200.1 CG201.1 CG202.1 CG203.1 CG204.1 CG205.1 CG206.1 CG207.1 CG208.1 CG209.1 CG210.1 CG211.1 CG212.1 CG213.1 CG214.1 CG215.1 CG216.1 CG217.1 CG218.1 CG219.1 CG220.1 CG221.1 CG222.1 CG223.1 CG224.1 CG225.1 CG226.1 CG227.1 CG228.1 CG242.1 CG243.1 CG324.1 CG325.1 CG326.1 CG327.1 CG328.1 CG329.1 CG330.1 CG331.1 CG332.1 CG333.1 CG334.1 CG335.1 CG336.1 CG337.1 CG338.1 CG339.1 CG340.1 CG341.1 CG342.1 CG343.1 CG344.1 CG345.1 CG346.1 CG347.1 CG348.1 CG349.1 CG350.1 CG351.1 CG352.1 CG353.1 CG354.1 CG355.1 CG356.1 CG357.1 CG358.1 CG359.1 CG360.1 CG361.1 CG362.1 CG363.1 CG364.1 CG365.1 CG366.1 CG367.1 CG368.1 CG369.1 CG370.1 CG371.1 CG372.1 CG373.1 CG374.1 CG375.1 CG376.1 CG377.1 CG378.1 CG379.1 CG380.1 CG381.1 CG382.1 CG383.1 CG388.1 CG389.1 CG390.1 CG391.1 CG392.1 CG393.1 CG394.1 CG395.1 CG396.1 CG397.1 CG398.1 CG399.1 CG400.1 CG401.1 CG402.1 CG403.1 CG404.1 CG405.1 CG406.1 CG407.1 CG408.1 CG409.1 CG410.1 CG411.1 CG412.1 CG413.1 CG414.1 CG415.1 CG416.1 CG417.1 CG418.1 CG419.1 CG420.1 CG421.1 CG422.1 CG423.1 CG424.1 CG425.1 CG426.1 CG427.1 CG428.1 CG429.1 CG430.1 CG431.1 CG432.1 CG433.1 CG434.1 CG435.1 PJP8201.2 PJP8202.2 RG47.1 RG48.1 RG49.1 RG50.1 RG51.1 RG52.1 RG67.2 RG104.2 RG110.1 RG115.2 RG121.1 RG126.2 RG132.1 UG1.B1 UG1.B3 UG1.B12 UG1.B14 UG1.C5 UG1.C10 UG1.D1 UG1.D3 UG1.D11 UG1.D12 UG1.D14 UG1.E5 UG1.E10 UG1.F1 UG1.F3 UG1.F12 UG1.F14 UG1.G1 UG1.G2 UG1.G4 UG1.G11 UG1.G13 UG1.G14 UG1.H3 UG1.H12 UG1.K3 UG1.K12 UG1.L1 UG1.L2 UG1.L4 UG1.L11 UG1.L13 UG1.L14 UG1.M1 UG1.M3 UG1.M12 UG1.M14 UG1.N5 UG1.N10 UG1.P1 UG1.P3 UG1.P11 UG1.P12 UG1.P14 UG1.R5 UG1.R10 UG1.T1 UG1.T3 UG1.T12 UG1.T14 UG2.B1 UG2.B3 UG2.B12 UG2.B14 UG2.C5 UG2.C10 UG2.D1 UG2.D3 UG2.D11 UG2.D12 UG2.D14 UG2.E5 UG2.E10 UG2.F1 UG2.F3 UG2.F12 UG2.F14 UG2.G1 UG2.G2 UG2.G4 UG2.G11 UG2.G13 UG2.G14 UG2.H3 UG2.H12 UG2.K3 UG2.K12 UG2.L1 UG2.L2 UG2.L4 UG2.L11 UG2.L13 UG2.L14 UG2.M1 UG2.M3 UG2.M12 UG2.M14 UG2.N5 UG2.N10 UG2.P1 UG2.P3 UG2.P11 UG2.P12 UG2.P14 UG2.R5 UG2.R10 UG2.T1 UG2.T3 UG2.T12 UG2.T14 UG3.B1 UG3.B3 UG3.B12 UG3.B14 UG3.C5 UG3.C10 UG3.D1 UG3.D3 UG3.D11 UG3.D12 UG3.D14 UG3.E5 UG3.E10 UG3.F1 UG3.F3 UG3.F12 UG3.F14 UG3.G1 UG3.G2 UG3.G4 UG3.G11 UG3.G13 UG3.G14 UG3.H3 UG3.H12 UG3.K3 UG3.K12 UG3.L1 UG3.L2 UG3.L4 UG3.L11 UG3.L13 UG3.L14 UG3.M1 UG3.M3 UG3.M12 UG3.M14 UG3.N5 UG3.N10 UG3.P1 UG3.P3 UG3.P11 UG3.P12 UG3.P14 UG3.R5 UG3.R10 UG3.T1 UG3.T3 UG3.T12 UG3.T14 UG4.B1 UG4.B3 UG4.B12 UG4.B14 UG4.C5 UG4.C10 UG4.D1 UG4.D3 UG4.D11 UG4.D12 UG4.D14 UG4.E5 UG4.E10 UG4.F1 UG4.F3 UG4.F12 UG4.F14 UG4.G1 UG4.G2 UG4.G4 UG4.G11 UG4.G13 UG4.G14 UG4.H3 UG4.H12 UG4.K3 UG4.K12 UG4.L1 UG4.L2 UG4.L4 UG4.L11 UG4.L13 UG4.L14 UG4.M1 UG4.M3 UG4.M12 UG4.M14 UG4.N5 UG4.N10 UG4.P1 UG4.P3 UG4.P11 UG4.P12 UG4.P14 UG4.R5 UG4.R10 UG4.T1 UG4.T3 UG4.T12 UG4.T14 UG5.B1 UG5.B3 UG5.B12 UG5.B14 UG5.C5 UG5.C10 UG5.D1 UG5.D3 UG5.D11 UG5.D12 UG5.D14 UG5.E5 UG5.E10 UG5.F1 UG5.F3 UG5.F12 UG5.F14 UG5.G1 UG5.G2 UG5.G4 UG5.G11 UG5.G13 UG5.G14 UG5.H3 UG5.H12 UG5.K3 UG5.K12 UG5.L1 UG5.L2 UG5.L4 UG5.L11 UG5.L13 UG5.L14 UG5.M1 UG5.M3 UG5.M12 UG5.M14 UG5.N5 UG5.N10 UG5.P1 UG5.P3 UG5.P11 UG5.P12 UG5.P14 UG5.R5 UG5.R10 UG5.T1 UG5.T3 UG5.T12 UG5.T14 UG6.B1 UG6.B3 UG6.B12 UG6.B14 UG6.C5 UG6.C10 UG6.D1 UG6.D3 UG6.D11 UG6.D12 UG6.D14 UG6.E5 UG6.E10 UG6.F1 UG6.F3 UG6.F12 UG6.F14 UG6.G1 UG6.G2 UG6.G4 UG6.G11 UG6.G13 UG6.G14 UG6.H3 UG6.H12 UG6.K3 UG6.K12 UG6.L1 UG6.L2 UG6.L4 UG6.L11 UG6.L13 UG6.L14 UG6.M1 UG6.M3 UG6.M12 UG6.M14 UG6.N5 UG6.N10 UG6.P1 UG6.P3 UG6.P11 UG6.P12 UG6.P14 UG6.R5 UG6.R10 UG6.T1 UG6.T3 UG6.T12 UG6.T14 UG9.AA10 UG9.AA11 UG9.AA42 UG9.AA43 UG9.AC10 UG9.AC11 UG9.AC42 UG9.AC43 UG9.AD10 UG9.AD11 UG9.AD42 UG9.AD43 UG9.AF10 UG9.AF43 UG9.AG10 UG9.AG11 UG9.AG42 UG9.AG43 UG9.AJ10 UG9.AJ11 UG9.AJ42 UG9.AJ43 UG9.AK10 UG9.AK11 UG9.AK42 UG9.AK43 UG9.AM42 UG9.AM43 UG9.AN43 UG9.AR42 UG9.AR43 UG9.AT43 UG9.K12 UG9.K14 UG9.K15 UG9.K17 UG9.K18 UG9.K20 UG9.K21 UG9.K23 UG9.K24 UG9.K26 UG9.K27 UG9.K29 UG9.K30 UG9.K32 UG9.K33 UG9.K35 UG9.K36 UG9.K38 UG9.K39 UG9.K41 UG9.L14 UG9.L15 UG9.L18 UG9.L20 UG9.L21 UG9.L23 UG9.L24 UG9.L26 UG9.L27 UG9.L30 UG9.L32 UG9.L33 UG9.L35 UG9.L36 UG9.L39 UG9.M10 UG9.M43 UG9.P10 UG9.P11 UG9.P42 UG9.P43 UG9.R10 UG9.R11 UG9.R42 UG9.R43 UG9.U10 UG9.U11 UG9.U43 UG9.V10 UG9.V42 UG9.V43 UG9.Y10 UG9.Y11 UG9.Y42 UG9.Y43
+1.35VS_VGA_PGOOD: PR8204.1 PU8200.13 UG25.1 UG29.1
+1.35VS_VGAP: PC8207.1 PC8208.1 PJP8201.1 PJP8202.1 PL8200.2 PL8201.2 PR8209.2
+1V8_AON: CG1.1 CG66.1 CG241.1 CG246.1 CG289.1 CG291.1 CG292.1 CG293.1 CG294.1 CG320.1 CG439.1 CG440.1 CG444.1 CG483.1 PR8204.2 QG511.2 RG2.2 RG8.2 RG9.2 RG11.1 RG12.1 RG13.2 RG14.2 RG15.2 RG16.2 RG17.2 RG18.2 RG19.2 RG20.2 RG21.2 RG71.1 RG74.1 RG78.2 RG79.2 RG80.2 RG81.2 RG82.2 RG83.2 RG84.2 RG85.2 RG86.2 RG147.1 RG500.1 RG502.1 RG503.2 RG504.2 RG510.1 RG516.1 RG522.2 RV648.1 RV652.1 RX5.1 RX7.1 UG9.BA10 UG9.BB14 UG9.BC14 UG10.5 UG12.6 UG12.7 UG12.13 UG12.14 UG13.3 UG13.7 UG13.8 UG15.3 UG15.7 UG15.8 UG22.5 UG26.5 UG27.5 UG28.5 UG29.5
+1V8_MAIN: CG11.1 CG12.2 CG17.1 CG18.1 CG19.1 CG20.1 CG21.2 CG23.1 CG24.1 CG290.1 CG295.1 CG296.1 CG297.1 CG298.1 CG299.1 CG300.1 CG301.1 CG302.1 CG303.1 CG304.1 CG305.1 CG306.1 CG307.1 CG312.1 LG1.2 LG2.2 LG3.1 LG4.1 LG5.1 LG6.2 RG512.1 RG515.1 RG546.1 UG9.AM10 UG9.AM11 UG9.AN10 UG9.AN11 UG9.AR10 UG9.AR11 UG9.AT10 UG9.AT11 UG9.AV10 UG9.AV11 UG9.AW10 UG9.AW11 UG9.BB26 UG9.BB27 UG9.BB29 UG9.BB32 UG9.BC26 UG9.BC27 UG9.BC29 UG9.BC30 UG9.BC32 UG9.BD21 UG9.BD27 UG9.BD30 UG12.8 UG12.9
+1V_MPHY: CH180.1 CH181.1 CH182.1 CH183.1 CH184.1 RH6.1 RH12.2 UH1.A43 UH1.B43 UH1.C44 UH1.C45 UH1.U21 UH1.U23 UH1.U25 UH1.U26 UH1.V26
+1V_PCH: CH177.1 CH178.1 CH179.1 CH185.1 JP1.2 RH71.1 UH1.AC17 UH1.AD15 UH1.AJ5 UH1.AL5 UH1.AL22 UH1.AN19 UH1.K2 UH1.K3 UH1.N17 UH1.R17 UH1.R19 UH1.U20 UH1.V17
+1V_PCH_PRIM: JP2.2 UH1.AA23 UH1.AA26 UH1.AA28 UH1.AC23 UH1.AC26 UH1.AC28 UH1.AE23 UH1.AE26 UH1.AJ20 UH1.AJ21 UH1.AJ23 UH1.AJ25 UH1.Y23 UH1.Y25
+1V_VCCDSW: CH176.1 UH1.BA29
+1VALW: C4.1 C7.1 JP1.1 JP2.1 JPCMC.22 PJP300.2 PJP302.2 RC353.1 RH12.1 U19.1 U19.2 U19.7 U20.1 U20.2 U20.7
+1VALWP: PC306.1 PC307.1 PJP300.1 PJP302.1 PL300.2 PR307.2
+1VALWP_B+: PC301.1 PC302.1 PC303.1 PC304.1 PC310.1 PC311.1 PJP301.1 PQ300.5
+1VALWP_PGOOD: PR301.2 PU300.1 UE5.122
+2.5V_MEM: CD3.1 CD4.1 CD9.1 CD10.1 CD27.1 CD28.1 CD30.1 CD31.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP1300.2
+2.5V_MEMP: PC1303.1 PC1304.1 PC1305.1 PJP1300.1 PR1304.1 PU1300.6
+2.5VOUT: CM9.1 CM32.1 CM34.1 CM35.1 CM36.1 UM8.9 UM8.14 UM8.36 UM8.41 UM8.51
+2.5VSP_ON: PC1301.1 PR1301.1 PR1302.1 PU1300.2
+2.5VSP_VIN: PC1300.1 PC1306.1 PJP1301.2 PU1300.3
+3.3V_1.8V_DVDD: CA12.1 CA13.1 CA64.1 CA65.1 LA5.1 RA11.1 RA21.1 RA24.1 RA32.1 RA50.1 RA53.1 RA66.1 RA70.1 UA1.7 UA4.16
+3.3V_1.8V_DVDD_IO: CA1.1 CA2.1 LA3.1 RA5.1 UA1.19
+3.3V_ANA_PCIE: CT85.1 UT1.L16
+3.3V_ANA_USB2: CT86.1 UT1.J16
+3.3V_F383: CE1.1 CE3.1 CE4.2 CE19.1 CE24.1 CE25.1 CE59.1 CE64.1 CE65.1 JELC.1 RE1.1 RE2.1 RE7.1 RE8.1 RE12.1 RE13.1 RE14.1 RE15.1 RE16.1 RE17.1 RE21.1 RE23.1 RE25.1 RE26.1 RE32.1 RE40.1 RE43.1 UE1.6 UE1.7 UE2.8 UE3.27 UE4.27 UE9.1
+3.3V_FLASH: CT45.1 CT103.1 RT48.1 RT49.2 RT50.1 RT51.1 RT66.1 RT67.1 RT74.1 UT2.8 UT4.B1 UT4.G1
+3.3V_LC: CT46.1 JTAG.1 RT6.1 RT7.1 RT8.1 RT9.1 UT1.R6
+3.3V_TBT_SX: CT47.1 RT26.1 RT27.1 RT28.1 RT29.1 RT30.1 RT31.1 RT32.1 RT33.1 RT61.2 RT70.1 RT86.1 RT94.1 RT97.2 UT1.F8
+3.3V_TBT_SX_R: CT102.1 RT61.1 UT4.H2
+3V3_SYS: CG61.1 CG323.1 CG385.1 PR821.2 PR6103.1 PR6205.2 QG5.2 QX1.2 RG6.1 RG60.1 RG61.1 RG63.1 RG514.1 RV655.1 RX1.1 UG11.4 UG14.6
+3V_PCH: C266.1 C267.1 CH49.1 CH186.1 CH187.1 CH189.1 CH190.1 CH191.1 CH192.1 CH200.1 J6.1 R367.2 RC9.1 RG558.1 RG559.1 RH7.1 RH23.2 RH25.2 RH75.1 RH78.1 RH460.1 RH461.1 RH493.1 RH506.2 RH571.2 RPH6.5 RPH6.6 RPH6.7 RPH6.8 UH1.AD41 UH1.AJ41 UH1.AL41 UH1.AN5 UH1.BA20 UH1.BA31 UH1.BA45 UH1.BB45 UH1.BC42 UH1.BC44 UH1.BC45 UH1.BD3 UH1.BD40 UH1.BE3 UH1.BE4 UH1.BE41 UH1.BE42 UH1.BE43 UH4.8
+3VALW: C262.1 C263.1 C269.1 C270.1 C2514.1 C2515.1 CE22.1 CE29.1 CE30.1 CE31.2 CE32.2 CE56.1 CE62.1 CH2.1 CH82.1 CL40.1 CL41.1 CM23.1 CM70.1 LE1.1 PC817.1 PC5003.1 PJP102.2 PJP104.2 PR3.2 PR16.2 PR24.2 PR210.1 PR301.1 PR709.2 PR710.1 PR718.2 PR812.2 PR1300.1 PR5033.2 PR8221.1 PU509.15 PU800.15 R307.1 R325.1 RA13.1 RA84.2 RE24.2 RE64.2 RE70.1 RE79.1 RE91.1 RE92.1 RE93.1 RE398.1 RE400.1 RE451.1 RE452.1 RE457.1 RE459.1 RE463.1 RE464.1 RE469.1 RE470.1 RE475.1 RE477.1 RE481.1 RE483.1 RE487.1 RE489.1 RE493.1 RE494.1 RE499.1 RE500.1 RE505.1 RE506.1 RE530.1 RE642.1 RE643.1 RE644.2 RH2.1 RH453.2 RH515.2 RH533.2 RH545.2 RM5.1 RM41.1 RT53.1 RT95.1 RT97.1 RU15.2 RU16.2 RU17.2 RU18.2 RU19.2 RU20.2 RU26.1 U16.1 U16.2 U16.7 U17.6 U17.7 U18.5 UE5.9 UE5.22 UE5.33 UE5.96 UE5.125 UE6.24 UE9.5 UE10.24 UH1.BA24 UH1.W15 UH5.2 UL2.5 UM3.5 UM7.5
+3VALW_PCH: C2522.1 J6.2 U18.1
+3VALW_PD: CT88.1 CT101.1 RT53.2 UT4.H1
+3VALWP: PC118.1 PJP102.1 PJP104.1 PL101.1 PR101.1
+3VLP: CU26.1 DU8.1 PC101.1 PD5.3 PR25.2 PU100.3 RA85.2 RE63.2 RU1.1 RU4.1 RU5.1 RU7.1 UE5.111 UU5.5
+3VS: C260.1 C261.1 C2498.1 CA259.1 CD16.1 CD17.1 CD34.1 CD35.1 CG322.1 CG436.1 CG437.1 CG438.1 CH188.1 CH201.1 CM10.1 CM11.1 CM12.1 CM13.1 CM14.1 CM15.1 CM18.1 CM19.1 CM20.1 CM21.1 CM29.1 CM30.1 CM31.1 CM33.1 CV5.1 CV21.1 CV372.1 CV436.1 CV437.1 FV2.1 J5.1 JDIMM1.255 JDIMM2.255 JWLAN.2 JWLAN.4 JWLAN.64 JWLAN.66 PR515.1 PR820.1 PR5016.1 PR6107.2 PR8219.1 QH5.2 QH5.5 QX2.1 QX3.1 R2.1 R181.1 RA5.2 RA11.2 RC62.2 RC63.2 RC65.2 RD5.1 RE20.2 RE84.1 RE94.1 RE95.1 RE651.2 RF1.2 RF2.2 RF4.2 RF5.2 RG505.1 RG506.1 RG517.1 RG535.1 RG536.1 RG561.1 RH5.1 RH85.2 RH111.2 RH462.1 RH463.1 RH501.1 RH502.1 RH512.2 RH513.2 RH516.1 RH518.2 RH521.1 RH525.1 RH537.2 RH584.2 RL5.2 RM14.1 RM18.1 RM20.1 RM26.1 RM66.2 RM76.1 RM79.1 RM81.1 RM85.1 RM86.1 RM96.1 RN5.1 RN16.1 RP3.1 RP3.2 RP3.3 RP3.4 RP5.1 RP5.2 RP5.3 RP5.4 RPT1.5 RPT1.6 RPT1.7 RPT1.8 RT57.1 RT58.1 RT107.1 RV16.1 RV19.1 RV21.2 RV45.2 RV47.1 RV81.1 RV623.2 RV625.2 RV627.2 RV629.2 RV631.2 RV634.1 RV635.1 RV659.2 RV671.2 RV672.2 U2407.1 UA3.B2 UG14.1 UG14.2 UG14.7 UG16.9 UG16.12 UG25.5 UH1.AD13 UH3.5 UM4.5 UM4.9 UM4.12 UM4.16 UM8.24 UV17.5 UV21.21 UV21.26 UV21.35 UV21.49 UV21.60
+3VS_CAM: JEDP.24 JEDP.32 RV47.2
+3VS_DP: CV34.1 CV35.1 FV2.2 JDP.20
+3VS_SSD: C617.1 C618.1 C620.1 C621.1 C622.1 C623.1 C624.1 C625.1 C627.1 C628.1 C635.1 C636.1 C637.1 C638.1 C2512.1 C2513.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74 JSSD2.2 JSSD2.4 JSSD2.12 JSSD2.14 JSSD2.16 JSSD2.18 JSSD2.70 JSSD2.72 JSSD2.74 R363.2 R365.2 U16.6
+3VS_TBT: CT48.1 CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 RT20.1 RT21.1 RT76.2 RT77.2 RT95.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9 UT1.R13
+3VS_TOUCH: C2.1 JTP.11 R2.2 RE100.1 RE101.1
+5V_PVDD: CA5.1 CA6.1 CA9.1 CA10.1 RA3.1 RA68.2 RA69.2
+5V_USB_PWR1: CU2.1 CU3.1 CU6.1 CU47.1 JUSB1.1 UU1.12
+5V_USB_PWR2: CU10.1 CU11.1 CU43.1 CU45.1 JUSB2.1 UU3.1
+5V_USBC_VBUS: CU18.1 CU19.1 CU20.1 CU21.1 CU32.1 CU37.1 CU40.1 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 RU24.1 UU7.14 UU7.15
+5VA: CA14.1 CA15.1 RA8.1 UA1.45
+5VALW: C264.1 C265.1 C2516.1 C2519.1 C2520.1 C2521.1 C2525.1 CE6.1 CE7.1 CE60.1 CE61.1 CG384.1 CT90.1 CT91.1 CT92.1 CT93.1 CU7.1 CU33.1 CU34.1 CU42.1 CU44.1 CU46.1 CU48.1 JKB.1 JLOGO.1 JLOGO.2 JWDB.1 PC308.1 PC1307.1 PJP100.2 PJP101.2 PJP802.1 PJP1301.1 PR8.1 PR14.2 PR203.1 PR204.1 PR8200.2 PU300.7 PU1300.4 QE8.3 QE54.1 QE54.4 QE55.1 QE55.4 QE56.1 RE28.1 RE154.1 RE156.1 RE158.1 RE449.1 RE533.1 RE538.1 RE539.1 RE542.1 RG509.1 RG511.1 RG513.1 RG541.1 RG543.1 RM91.1 RM92.1 RM93.1 RM94.1 RU21.1 RU23.1 U16.3 U17.1 U17.2 U17.4 U19.3 U20.3 UE1.8 UE7.5 UG14.3 UT4.A11 UT4.B11 UT4.C11 UT4.D11 UT4.H10 UU1.1 UU3.5 UU7.2 UU7.3 UU7.4 UU7.5 UZ21.4
+5VALW_LED: JPWR.1 JPWR.2 QE8.1 UE7.1
+5VALWP: PC108.1 PJP100.1 PJP101.1 PL102.2 PR102.2 PU100.14
+5VS: C29.1 C256.1 C257.1 CF4.1 CF5.1 CG386.1 CV23.1 CV484.1 FV3.1 J4.1 JFAN1.4 JFAN2.4 JKBBL.15 JKBBL.16 PC6100.1 PC6200.1 PR505.1 PR553.2 PR599.2 PR5004.2 PR5011.2 PR5019.2 PR5020.2 PR5021.2 PR5022.2 PR5023.2 PR5024.2 PR5025.2 PR5026.1 PR5028.1 PR5029.1 PR5030.1 PR5031.1 PR5032.1 PU6100.18 PU6200.18 Q2409.1 Q2409.2 Q2409.5 Q2409.6 RA3.2 RA8.2 RF3.2 RF6.2 UG12.4 UV3.16 UV22.16
+5VS_TP_LED: C2508.1 JTP.1 JTP.2 Q2409.4 R144.1 R145.1 R146.1 R147.1 R150.1 R154.1
+AVDDH: CL5.1 CL6.1 CL7.1 UL1.9 UL1.22
+AVDDL: CL18.1 CL19.1 CL20.1 CL21.1 CL22.1 CL23.1 CL24.1 CL25.1 UL1.6 UL1.13 UL1.19 UL1.31 UL1.34
+DVDDL: CL43.1 CL44.1 UL1.37
+PVDD: CA52.1 CA53.1 CA54.1 CA55.1 CA56.1 CA57.1 CA61.1 CA62.1 CA63.1 CA79.1 CA80.1 CA81.1 CA82.1 CA83.1 CA84.1 RA83.1 UA4.1 UA4.37 UA4.42 UA4.43 UA4.48 UA4.51 UA4.56
+V18R: RE24.1 UE5.124
+VCC_CORE: CPU1.AA13 CPU1.AA31 CPU1.AA32 CPU1.AA33 CPU1.AA34 CPU1.AA35 CPU1.AA36 CPU1.AA37 CPU1.AA38 CPU1.AB29 CPU1.AB30 CPU1.AB31 CPU1.AB32 CPU1.AB35 CPU1.AB36 CPU1.AB37 CPU1.AB38 CPU1.AC13 CPU1.AC14 CPU1.AC29 CPU1.AC30 CPU1.AC31 CPU1.AC32 CPU1.AC33 CPU1.AC34 CPU1.AC35 CPU1.AC36 CPU1.AD13 CPU1.AD14 CPU1.AD31 CPU1.AD32 CPU1.AD33 CPU1.AD34 CPU1.AD35 CPU1.AD36 CPU1.AD37 CPU1.AD38 CPU1.AE13 CPU1.AE14 CPU1.AE30 CPU1.AE31 CPU1.AE32 CPU1.AE35 CPU1.AE36 CPU1.AE37 CPU1.AE38 CPU1.AF35 CPU1.AF36 CPU1.AF37 CPU1.AF38 CPU1.K13 CPU1.K14 CPU1.L13 CPU1.L14 CPU1.N13 CPU1.N14 CPU1.N30 CPU1.N31 CPU1.N32 CPU1.N35 CPU1.N36 CPU1.N37 CPU1.N38 CPU1.P13 CPU1.P14 CPU1.P29 CPU1.P30 CPU1.P31 CPU1.P32 CPU1.P33 CPU1.P34 CPU1.P35 CPU1.P36 CPU1.R13 CPU1.R31 CPU1.R32 CPU1.R33 CPU1.R34 CPU1.R35 CPU1.R36 CPU1.R37 CPU1.R38 CPU1.T29 CPU1.T30 CPU1.T31 CPU1.T32 CPU1.T35 CPU1.T36 CPU1.T37 CPU1.T38 CPU1.U29 CPU1.U30 CPU1.U31 CPU1.U32 CPU1.U33 CPU1.U34 CPU1.U35 CPU1.U36 CPU1.V13 CPU1.V14 CPU1.V31 CPU1.V32 CPU1.V33 CPU1.V34 CPU1.V35 CPU1.V36 CPU1.V37 CPU1.V38 CPU1.W13 CPU1.W14 CPU1.W29 CPU1.W30 CPU1.W31 CPU1.W32 CPU1.W35 CPU1.W36 CPU1.W37 CPU1.W38 CPU1.Y29 CPU1.Y30 CPU1.Y31 CPU1.Y32 CPU1.Y33 CPU1.Y34 CPU1.Y35 CPU1.Y36 PC1000.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1097.1 PC1098.1 PC1099.1 PC1100.1 PC1101.1 PC1102.1 PC1103.1 PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1108.1 PC1109.1 PC1110.1 PC1111.1 PC1123.1 PC1124.1 PC1125.1 PC1126.1 PC1127.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1161.1 PC1162.1 PC1163.1 PC1164.1 PC1165.1 PC1166.1 PC1167.1 PC1168.1 PC1169.1 PC1170.1 PC1171.1 PC1172.1 PC1173.1 PC1174.1 PC1175.1 PC1199.1 PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1236.1 PC1237.1 PC1238.1 PL501.1 PL502.1 PL503.1 PR559.2 PR560.1 PR561.1 PR569.2 PR570.1 PR571.1 PR579.2 PR580.1 PR581.1 RH197.1
+VCCGT: CPU1.AJ29 CPU1.AJ30 CPU1.AJ31 CPU1.AJ32 CPU1.AJ33 CPU1.AJ34 CPU1.AJ35 CPU1.AJ36 CPU1.AK31 CPU1.AK32 CPU1.AK33 CPU1.AK34 CPU1.AK35 CPU1.AK36 CPU1.AK37 CPU1.AK38 CPU1.AL13 CPU1.AL29 CPU1.AL30 CPU1.AL31 CPU1.AL32 CPU1.AL35 CPU1.AL36 CPU1.AL37 CPU1.AL38 CPU1.AM13 CPU1.AM14 CPU1.AM29 CPU1.AM30 CPU1.AM31 CPU1.AM32 CPU1.AM33 CPU1.AM34 CPU1.AM35 CPU1.AM36 CPU1.AN13 CPU1.AN14 CPU1.AN31 CPU1.AN32 CPU1.AN33 CPU1.AN34 CPU1.AN35 CPU1.AN36 CPU1.AN37 CPU1.AN38 CPU1.AP13 CPU1.AP14 CPU1.AP29 CPU1.AP30 CPU1.AP31 CPU1.AP32 CPU1.AP35 CPU1.AP36 CPU1.AP37 CPU1.AP38 CPU1.AR29 CPU1.AR30 CPU1.AR31 CPU1.AR32 CPU1.AR33 CPU1.AR34 CPU1.AR35 CPU1.AR36 CPU1.AT14 CPU1.AT31 CPU1.AT32 CPU1.AT33 CPU1.AT34 CPU1.AT35 CPU1.AT36 CPU1.AT37 CPU1.AT38 CPU1.AU14 CPU1.AU29 CPU1.AU30 CPU1.AU31 CPU1.AU32 CPU1.AU35 CPU1.AU36 CPU1.AU37 CPU1.AU38 CPU1.AV29 CPU1.AV30 CPU1.AV31 CPU1.AV32 CPU1.AV33 CPU1.AV34 CPU1.AV35 CPU1.AV36 CPU1.AW14 CPU1.AW31 CPU1.AW32 CPU1.AW33 CPU1.AW34 CPU1.AW35 CPU1.AW36 CPU1.AW37 CPU1.AW38 CPU1.AY29 CPU1.AY30 CPU1.AY31 CPU1.AY32 CPU1.AY35 CPU1.AY36 CPU1.AY37 CPU1.AY38 CPU1.BA13 CPU1.BA14 CPU1.BA29 CPU1.BA30 CPU1.BA31 CPU1.BA32 CPU1.BA33 CPU1.BA34 CPU1.BA35 CPU1.BA36 CPU1.BB13 CPU1.BB14 CPU1.BB31 CPU1.BB32 CPU1.BB33 CPU1.BB34 CPU1.BB35 CPU1.BB36 CPU1.BB37 CPU1.BB38 CPU1.BC29 CPU1.BC30 CPU1.BC31 CPU1.BC32 CPU1.BC35 CPU1.BC36 CPU1.BC37 CPU1.BC38 CPU1.BD13 CPU1.BD14 CPU1.BD29 CPU1.BD30 CPU1.BD31 CPU1.BD32 CPU1.BD33 CPU1.BD34 CPU1.BD35 CPU1.BD36 CPU1.BE31 CPU1.BE32 CPU1.BE33 CPU1.BE34 CPU1.BE35 CPU1.BE36 CPU1.BE37 CPU1.BE38 CPU1.BF13 CPU1.BF14 CPU1.BF29 CPU1.BF30 CPU1.BF31 CPU1.BF32 CPU1.BF35 CPU1.BF36 CPU1.BF37 CPU1.BF38 CPU1.BG29 CPU1.BG30 CPU1.BG31 CPU1.BG32 CPU1.BG33 CPU1.BG34 CPU1.BG35 CPU1.BG36 CPU1.BH33 CPU1.BH34 CPU1.BH35 CPU1.BH36 CPU1.BH37 CPU1.BH38 CPU1.BJ37 CPU1.BJ38 CPU1.BL36 CPU1.BL37 CPU1.BM36 CPU1.BM37 CPU1.BN36 CPU1.BN37 CPU1.BN38 CPU1.BP37 CPU1.BP38 CPU1.BR37 CPU1.BT37 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1112.1 PC1113.1 PC1114.1 PC1115.1 PC1116.1 PC1117.1 PC1118.1 PC1119.1 PC1120.1 PC1121.1 PC1122.1 PC1138.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PC1154.1 PC1155.1 PC1156.1 PC1157.1 PC1158.1 PC1159.1 PC1160.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC1182.1 PC1183.1 PC1184.1 PC1185.1 PC1186.1 PC1187.1 PC1188.1 PC1189.1 PC1190.1 PC1191.1 PC1192.1 PC1193.1 PC1194.1 PC1195.1 PC1196.1 PC1197.1 PC1198.1 PC1214.1 PC1215.1 PC1216.1 PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1226.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PL505.1 PL506.1 PR588.2 PR589.1 PR597.2 PR598.1 RH203.1
+VCCIO: CH102.1 CH103.1 CH104.1 CPU1.AG12 CPU1.G15 CPU1.G17 CPU1.G19 CPU1.G21 CPU1.H15 CPU1.H16 CPU1.H17 CPU1.H19 CPU1.H20 CPU1.H21 CPU1.H26 CPU1.H27 CPU1.J15 CPU1.J16 CPU1.J17 CPU1.J19 CPU1.J20 CPU1.J21 CPU1.J26 CPU1.J27 PJP505.2 RC2.1 RC30.2
+VCCIOP: PC596.1 PC597.1 PC598.1 PC599.1 PC820.1 PJP505.1 PL509.2 PR5014.1
+VCCSA: CPU1.J30 CPU1.K29 CPU1.K30 CPU1.K31 CPU1.K32 CPU1.K33 CPU1.K34 CPU1.K35 CPU1.L31 CPU1.L32 CPU1.L35 CPU1.L36 CPU1.L37 CPU1.L38 CPU1.M29 CPU1.M30 CPU1.M31 CPU1.M32 CPU1.M33 CPU1.M34 CPU1.M35 CPU1.M36 PC1017.1 PC1018.1 PC1019.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PL508.2 PR5027.2 RH201.2
+VCCST: C6.1 CH107.1 CH108.1 CH109.1 CH110.1 CPU1.H28 CPU1.H30 CPU1.J28 PC502.1 PR501.1 PR502.1 PR503.1 RH151.1 RH152.1 RH156.1 RH163.1 RH164.1 U19.6
+VCCSTG: C10.1 CH105.1 CH106.1 CPU1.G30 CPU1.H29 RH165.1 RH494.1 RH495.1 RH496.1 U20.6
+VDD_TOUCH: CV19.1 JEDP.33 RV81.2
+VDDCT_L: CL32.2 CL33.1 CL34.2 CL35.1 CL36.2 CL37.1 CL38.2 CL39.1 TL1.3 TL1.4 TL1.9 TL1.10
